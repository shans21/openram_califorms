.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_16ck60 FIND v(dout1_16) AT=35.025n

.meas tran vdout1_17ck60 FIND v(dout1_17) AT=35.025n

.meas tran vdout1_18ck60 FIND v(dout1_18) AT=35.025n

.meas tran vdout1_19ck60 FIND v(dout1_19) AT=35.025n

.meas tran vdout1_20ck60 FIND v(dout1_20) AT=35.025n

.meas tran vdout1_21ck60 FIND v(dout1_21) AT=35.025n

.meas tran vdout1_22ck60 FIND v(dout1_22) AT=35.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_8ck110 FIND v(dout1_8) AT=60.025n

.meas tran vdout1_9ck110 FIND v(dout1_9) AT=60.025n

.meas tran vdout1_10ck110 FIND v(dout1_10) AT=60.025n

.meas tran vdout1_11ck110 FIND v(dout1_11) AT=60.025n

.meas tran vdout1_12ck110 FIND v(dout1_12) AT=60.025n

.meas tran vdout1_13ck110 FIND v(dout1_13) AT=60.025n

.meas tran vdout1_14ck110 FIND v(dout1_14) AT=60.025n

.meas tran vdout1_15ck110 FIND v(dout1_15) AT=60.025n

.meas tran vdout1_16ck110 FIND v(dout1_16) AT=60.025n

.meas tran vdout1_17ck110 FIND v(dout1_17) AT=60.025n

.meas tran vdout1_18ck110 FIND v(dout1_18) AT=60.025n

.meas tran vdout1_19ck110 FIND v(dout1_19) AT=60.025n

.meas tran vdout1_20ck110 FIND v(dout1_20) AT=60.025n

.meas tran vdout1_21ck110 FIND v(dout1_21) AT=60.025n

.meas tran vdout1_22ck110 FIND v(dout1_22) AT=60.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_22ck140 FIND v(dout1_22) AT=75.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_19ck150 FIND v(dout1_19) AT=80.025n

.meas tran vdout1_20ck150 FIND v(dout1_20) AT=80.025n

.meas tran vdout1_21ck150 FIND v(dout1_21) AT=80.025n

.meas tran vdout1_22ck150 FIND v(dout1_22) AT=80.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_17ck160 FIND v(dout1_17) AT=85.025n

.meas tran vdout1_18ck160 FIND v(dout1_18) AT=85.025n

.meas tran vdout1_19ck160 FIND v(dout1_19) AT=85.025n

.meas tran vdout1_20ck160 FIND v(dout1_20) AT=85.025n

.meas tran vdout1_21ck160 FIND v(dout1_21) AT=85.025n

.meas tran vdout1_22ck160 FIND v(dout1_22) AT=85.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_17ck250 FIND v(dout1_17) AT=130.025n

.meas tran vdout1_18ck250 FIND v(dout1_18) AT=130.025n

.meas tran vdout1_19ck250 FIND v(dout1_19) AT=130.025n

.meas tran vdout1_20ck250 FIND v(dout1_20) AT=130.025n

.meas tran vdout1_21ck250 FIND v(dout1_21) AT=130.025n

.meas tran vdout1_22ck250 FIND v(dout1_22) AT=130.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_0ck320 FIND v(dout1_0) AT=165.025n

.meas tran vdout1_1ck320 FIND v(dout1_1) AT=165.025n

.meas tran vdout1_2ck320 FIND v(dout1_2) AT=165.025n

.meas tran vdout1_3ck320 FIND v(dout1_3) AT=165.025n

.meas tran vdout1_4ck320 FIND v(dout1_4) AT=165.025n

.meas tran vdout1_5ck320 FIND v(dout1_5) AT=165.025n

.meas tran vdout1_6ck320 FIND v(dout1_6) AT=165.025n

.meas tran vdout1_7ck320 FIND v(dout1_7) AT=165.025n

.meas tran vdout1_8ck320 FIND v(dout1_8) AT=165.025n

.meas tran vdout1_9ck320 FIND v(dout1_9) AT=165.025n

.meas tran vdout1_10ck320 FIND v(dout1_10) AT=165.025n

.meas tran vdout1_11ck320 FIND v(dout1_11) AT=165.025n

.meas tran vdout1_12ck320 FIND v(dout1_12) AT=165.025n

.meas tran vdout1_13ck320 FIND v(dout1_13) AT=165.025n

.meas tran vdout1_14ck320 FIND v(dout1_14) AT=165.025n

.meas tran vdout1_15ck320 FIND v(dout1_15) AT=165.025n

.meas tran vdout1_16ck320 FIND v(dout1_16) AT=165.025n

.meas tran vdout1_17ck320 FIND v(dout1_17) AT=165.025n

.meas tran vdout1_18ck320 FIND v(dout1_18) AT=165.025n

.meas tran vdout1_19ck320 FIND v(dout1_19) AT=165.025n

.meas tran vdout1_20ck320 FIND v(dout1_20) AT=165.025n

.meas tran vdout1_21ck320 FIND v(dout1_21) AT=165.025n

.meas tran vdout1_22ck320 FIND v(dout1_22) AT=165.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_8ck340 FIND v(dout1_8) AT=175.025n

.meas tran vdout1_9ck340 FIND v(dout1_9) AT=175.025n

.meas tran vdout1_10ck340 FIND v(dout1_10) AT=175.025n

.meas tran vdout1_11ck340 FIND v(dout1_11) AT=175.025n

.meas tran vdout1_12ck340 FIND v(dout1_12) AT=175.025n

.meas tran vdout1_13ck340 FIND v(dout1_13) AT=175.025n

.meas tran vdout1_14ck340 FIND v(dout1_14) AT=175.025n

.meas tran vdout1_15ck340 FIND v(dout1_15) AT=175.025n

.meas tran vdout1_16ck340 FIND v(dout1_16) AT=175.025n

.meas tran vdout1_17ck340 FIND v(dout1_17) AT=175.025n

.meas tran vdout1_18ck340 FIND v(dout1_18) AT=175.025n

.meas tran vdout1_19ck340 FIND v(dout1_19) AT=175.025n

.meas tran vdout1_20ck340 FIND v(dout1_20) AT=175.025n

.meas tran vdout1_21ck340 FIND v(dout1_21) AT=175.025n

.meas tran vdout1_22ck340 FIND v(dout1_22) AT=175.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_8ck390 FIND v(dout1_8) AT=200.025n

.meas tran vdout1_9ck390 FIND v(dout1_9) AT=200.025n

.meas tran vdout1_10ck390 FIND v(dout1_10) AT=200.025n

.meas tran vdout1_11ck390 FIND v(dout1_11) AT=200.025n

.meas tran vdout1_12ck390 FIND v(dout1_12) AT=200.025n

.meas tran vdout1_13ck390 FIND v(dout1_13) AT=200.025n

.meas tran vdout1_14ck390 FIND v(dout1_14) AT=200.025n

.meas tran vdout1_15ck390 FIND v(dout1_15) AT=200.025n

.meas tran vdout1_16ck390 FIND v(dout1_16) AT=200.025n

.meas tran vdout1_17ck390 FIND v(dout1_17) AT=200.025n

.meas tran vdout1_18ck390 FIND v(dout1_18) AT=200.025n

.meas tran vdout1_19ck390 FIND v(dout1_19) AT=200.025n

.meas tran vdout1_20ck390 FIND v(dout1_20) AT=200.025n

.meas tran vdout1_21ck390 FIND v(dout1_21) AT=200.025n

.meas tran vdout1_22ck390 FIND v(dout1_22) AT=200.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_16ck440 FIND v(dout1_16) AT=225.025n

.meas tran vdout1_17ck440 FIND v(dout1_17) AT=225.025n

.meas tran vdout1_18ck440 FIND v(dout1_18) AT=225.025n

.meas tran vdout1_19ck440 FIND v(dout1_19) AT=225.025n

.meas tran vdout1_20ck440 FIND v(dout1_20) AT=225.025n

.meas tran vdout1_21ck440 FIND v(dout1_21) AT=225.025n

.meas tran vdout1_22ck440 FIND v(dout1_22) AT=225.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_19ck490 FIND v(dout1_19) AT=250.025n

.meas tran vdout1_20ck490 FIND v(dout1_20) AT=250.025n

.meas tran vdout1_21ck490 FIND v(dout1_21) AT=250.025n

.meas tran vdout1_22ck490 FIND v(dout1_22) AT=250.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_22ck510 FIND v(dout1_22) AT=260.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_8ck630 FIND v(dout1_8) AT=320.025n

.meas tran vdout1_9ck630 FIND v(dout1_9) AT=320.025n

.meas tran vdout1_10ck630 FIND v(dout1_10) AT=320.025n

.meas tran vdout1_11ck630 FIND v(dout1_11) AT=320.025n

.meas tran vdout1_12ck630 FIND v(dout1_12) AT=320.025n

.meas tran vdout1_13ck630 FIND v(dout1_13) AT=320.025n

.meas tran vdout1_14ck630 FIND v(dout1_14) AT=320.025n

.meas tran vdout1_15ck630 FIND v(dout1_15) AT=320.025n

.meas tran vdout1_16ck630 FIND v(dout1_16) AT=320.025n

.meas tran vdout1_17ck630 FIND v(dout1_17) AT=320.025n

.meas tran vdout1_18ck630 FIND v(dout1_18) AT=320.025n

.meas tran vdout1_19ck630 FIND v(dout1_19) AT=320.025n

.meas tran vdout1_20ck630 FIND v(dout1_20) AT=320.025n

.meas tran vdout1_21ck630 FIND v(dout1_21) AT=320.025n

.meas tran vdout1_22ck630 FIND v(dout1_22) AT=320.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_19ck640 FIND v(dout1_19) AT=325.025n

.meas tran vdout1_20ck640 FIND v(dout1_20) AT=325.025n

.meas tran vdout1_21ck640 FIND v(dout1_21) AT=325.025n

.meas tran vdout1_22ck640 FIND v(dout1_22) AT=325.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_17ck700 FIND v(dout1_17) AT=355.025n

.meas tran vdout1_18ck700 FIND v(dout1_18) AT=355.025n

.meas tran vdout1_19ck700 FIND v(dout1_19) AT=355.025n

.meas tran vdout1_20ck700 FIND v(dout1_20) AT=355.025n

.meas tran vdout1_21ck700 FIND v(dout1_21) AT=355.025n

.meas tran vdout1_22ck700 FIND v(dout1_22) AT=355.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_22ck720 FIND v(dout1_22) AT=365.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_17ck730 FIND v(dout1_17) AT=370.025n

.meas tran vdout1_18ck730 FIND v(dout1_18) AT=370.025n

.meas tran vdout1_19ck730 FIND v(dout1_19) AT=370.025n

.meas tran vdout1_20ck730 FIND v(dout1_20) AT=370.025n

.meas tran vdout1_21ck730 FIND v(dout1_21) AT=370.025n

.meas tran vdout1_22ck730 FIND v(dout1_22) AT=370.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_22ck740 FIND v(dout1_22) AT=375.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_19ck760 FIND v(dout1_19) AT=385.025n

.meas tran vdout1_20ck760 FIND v(dout1_20) AT=385.025n

.meas tran vdout1_21ck760 FIND v(dout1_21) AT=385.025n

.meas tran vdout1_22ck760 FIND v(dout1_22) AT=385.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_0ck870 FIND v(dout1_0) AT=440.025n

.meas tran vdout1_1ck870 FIND v(dout1_1) AT=440.025n

.meas tran vdout1_2ck870 FIND v(dout1_2) AT=440.025n

.meas tran vdout1_3ck870 FIND v(dout1_3) AT=440.025n

.meas tran vdout1_4ck870 FIND v(dout1_4) AT=440.025n

.meas tran vdout1_5ck870 FIND v(dout1_5) AT=440.025n

.meas tran vdout1_6ck870 FIND v(dout1_6) AT=440.025n

.meas tran vdout1_7ck870 FIND v(dout1_7) AT=440.025n

.meas tran vdout1_8ck870 FIND v(dout1_8) AT=440.025n

.meas tran vdout1_9ck870 FIND v(dout1_9) AT=440.025n

.meas tran vdout1_10ck870 FIND v(dout1_10) AT=440.025n

.meas tran vdout1_11ck870 FIND v(dout1_11) AT=440.025n

.meas tran vdout1_12ck870 FIND v(dout1_12) AT=440.025n

.meas tran vdout1_13ck870 FIND v(dout1_13) AT=440.025n

.meas tran vdout1_14ck870 FIND v(dout1_14) AT=440.025n

.meas tran vdout1_15ck870 FIND v(dout1_15) AT=440.025n

.meas tran vdout1_16ck870 FIND v(dout1_16) AT=440.025n

.meas tran vdout1_17ck870 FIND v(dout1_17) AT=440.025n

.meas tran vdout1_18ck870 FIND v(dout1_18) AT=440.025n

.meas tran vdout1_19ck870 FIND v(dout1_19) AT=440.025n

.meas tran vdout1_20ck870 FIND v(dout1_20) AT=440.025n

.meas tran vdout1_21ck870 FIND v(dout1_21) AT=440.025n

.meas tran vdout1_22ck870 FIND v(dout1_22) AT=440.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_16ck890 FIND v(dout1_16) AT=450.025n

.meas tran vdout1_17ck890 FIND v(dout1_17) AT=450.025n

.meas tran vdout1_18ck890 FIND v(dout1_18) AT=450.025n

.meas tran vdout1_19ck890 FIND v(dout1_19) AT=450.025n

.meas tran vdout1_20ck890 FIND v(dout1_20) AT=450.025n

.meas tran vdout1_21ck890 FIND v(dout1_21) AT=450.025n

.meas tran vdout1_22ck890 FIND v(dout1_22) AT=450.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_16ck920 FIND v(dout1_16) AT=465.025n

.meas tran vdout1_17ck920 FIND v(dout1_17) AT=465.025n

.meas tran vdout1_18ck920 FIND v(dout1_18) AT=465.025n

.meas tran vdout1_19ck920 FIND v(dout1_19) AT=465.025n

.meas tran vdout1_20ck920 FIND v(dout1_20) AT=465.025n

.meas tran vdout1_21ck920 FIND v(dout1_21) AT=465.025n

.meas tran vdout1_22ck920 FIND v(dout1_22) AT=465.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_16ck980 FIND v(dout1_16) AT=495.025n

.meas tran vdout1_17ck980 FIND v(dout1_17) AT=495.025n

.meas tran vdout1_18ck980 FIND v(dout1_18) AT=495.025n

.meas tran vdout1_19ck980 FIND v(dout1_19) AT=495.025n

.meas tran vdout1_20ck980 FIND v(dout1_20) AT=495.025n

.meas tran vdout1_21ck980 FIND v(dout1_21) AT=495.025n

.meas tran vdout1_22ck980 FIND v(dout1_22) AT=495.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_22ck1060 FIND v(dout1_22) AT=535.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_19ck1080 FIND v(dout1_19) AT=545.025n

.meas tran vdout1_20ck1080 FIND v(dout1_20) AT=545.025n

.meas tran vdout1_21ck1080 FIND v(dout1_21) AT=545.025n

.meas tran vdout1_22ck1080 FIND v(dout1_22) AT=545.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_0ck1130 FIND v(dout1_0) AT=570.025n

.meas tran vdout1_1ck1130 FIND v(dout1_1) AT=570.025n

.meas tran vdout1_2ck1130 FIND v(dout1_2) AT=570.025n

.meas tran vdout1_3ck1130 FIND v(dout1_3) AT=570.025n

.meas tran vdout1_4ck1130 FIND v(dout1_4) AT=570.025n

.meas tran vdout1_5ck1130 FIND v(dout1_5) AT=570.025n

.meas tran vdout1_6ck1130 FIND v(dout1_6) AT=570.025n

.meas tran vdout1_7ck1130 FIND v(dout1_7) AT=570.025n

.meas tran vdout1_8ck1130 FIND v(dout1_8) AT=570.025n

.meas tran vdout1_9ck1130 FIND v(dout1_9) AT=570.025n

.meas tran vdout1_10ck1130 FIND v(dout1_10) AT=570.025n

.meas tran vdout1_11ck1130 FIND v(dout1_11) AT=570.025n

.meas tran vdout1_12ck1130 FIND v(dout1_12) AT=570.025n

.meas tran vdout1_13ck1130 FIND v(dout1_13) AT=570.025n

.meas tran vdout1_14ck1130 FIND v(dout1_14) AT=570.025n

.meas tran vdout1_15ck1130 FIND v(dout1_15) AT=570.025n

.meas tran vdout1_16ck1130 FIND v(dout1_16) AT=570.025n

.meas tran vdout1_17ck1130 FIND v(dout1_17) AT=570.025n

.meas tran vdout1_18ck1130 FIND v(dout1_18) AT=570.025n

.meas tran vdout1_19ck1130 FIND v(dout1_19) AT=570.025n

.meas tran vdout1_20ck1130 FIND v(dout1_20) AT=570.025n

.meas tran vdout1_21ck1130 FIND v(dout1_21) AT=570.025n

.meas tran vdout1_22ck1130 FIND v(dout1_22) AT=570.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_17ck1160 FIND v(dout1_17) AT=585.025n

.meas tran vdout1_18ck1160 FIND v(dout1_18) AT=585.025n

.meas tran vdout1_19ck1160 FIND v(dout1_19) AT=585.025n

.meas tran vdout1_20ck1160 FIND v(dout1_20) AT=585.025n

.meas tran vdout1_21ck1160 FIND v(dout1_21) AT=585.025n

.meas tran vdout1_22ck1160 FIND v(dout1_22) AT=585.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_16ck1170 FIND v(dout1_16) AT=590.025n

.meas tran vdout1_17ck1170 FIND v(dout1_17) AT=590.025n

.meas tran vdout1_18ck1170 FIND v(dout1_18) AT=590.025n

.meas tran vdout1_19ck1170 FIND v(dout1_19) AT=590.025n

.meas tran vdout1_20ck1170 FIND v(dout1_20) AT=590.025n

.meas tran vdout1_21ck1170 FIND v(dout1_21) AT=590.025n

.meas tran vdout1_22ck1170 FIND v(dout1_22) AT=590.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_17ck1260 FIND v(dout1_17) AT=635.025n

.meas tran vdout1_18ck1260 FIND v(dout1_18) AT=635.025n

.meas tran vdout1_19ck1260 FIND v(dout1_19) AT=635.025n

.meas tran vdout1_20ck1260 FIND v(dout1_20) AT=635.025n

.meas tran vdout1_21ck1260 FIND v(dout1_21) AT=635.025n

.meas tran vdout1_22ck1260 FIND v(dout1_22) AT=635.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_8ck1270 FIND v(dout1_8) AT=640.025n

.meas tran vdout1_9ck1270 FIND v(dout1_9) AT=640.025n

.meas tran vdout1_10ck1270 FIND v(dout1_10) AT=640.025n

.meas tran vdout1_11ck1270 FIND v(dout1_11) AT=640.025n

.meas tran vdout1_12ck1270 FIND v(dout1_12) AT=640.025n

.meas tran vdout1_13ck1270 FIND v(dout1_13) AT=640.025n

.meas tran vdout1_14ck1270 FIND v(dout1_14) AT=640.025n

.meas tran vdout1_15ck1270 FIND v(dout1_15) AT=640.025n

.meas tran vdout1_16ck1270 FIND v(dout1_16) AT=640.025n

.meas tran vdout1_17ck1270 FIND v(dout1_17) AT=640.025n

.meas tran vdout1_18ck1270 FIND v(dout1_18) AT=640.025n

.meas tran vdout1_19ck1270 FIND v(dout1_19) AT=640.025n

.meas tran vdout1_20ck1270 FIND v(dout1_20) AT=640.025n

.meas tran vdout1_21ck1270 FIND v(dout1_21) AT=640.025n

.meas tran vdout1_22ck1270 FIND v(dout1_22) AT=640.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_17ck1290 FIND v(dout1_17) AT=650.025n

.meas tran vdout1_18ck1290 FIND v(dout1_18) AT=650.025n

.meas tran vdout1_19ck1290 FIND v(dout1_19) AT=650.025n

.meas tran vdout1_20ck1290 FIND v(dout1_20) AT=650.025n

.meas tran vdout1_21ck1290 FIND v(dout1_21) AT=650.025n

.meas tran vdout1_22ck1290 FIND v(dout1_22) AT=650.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_22ck1300 FIND v(dout1_22) AT=655.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_16ck1390 FIND v(dout1_16) AT=700.025n

.meas tran vdout1_17ck1390 FIND v(dout1_17) AT=700.025n

.meas tran vdout1_18ck1390 FIND v(dout1_18) AT=700.025n

.meas tran vdout1_19ck1390 FIND v(dout1_19) AT=700.025n

.meas tran vdout1_20ck1390 FIND v(dout1_20) AT=700.025n

.meas tran vdout1_21ck1390 FIND v(dout1_21) AT=700.025n

.meas tran vdout1_22ck1390 FIND v(dout1_22) AT=700.025n

.meas tran vdout1_0ck1510 FIND v(dout1_0) AT=760.025n

.meas tran vdout1_1ck1510 FIND v(dout1_1) AT=760.025n

.meas tran vdout1_2ck1510 FIND v(dout1_2) AT=760.025n

.meas tran vdout1_3ck1510 FIND v(dout1_3) AT=760.025n

.meas tran vdout1_4ck1510 FIND v(dout1_4) AT=760.025n

.meas tran vdout1_5ck1510 FIND v(dout1_5) AT=760.025n

.meas tran vdout1_6ck1510 FIND v(dout1_6) AT=760.025n

.meas tran vdout1_7ck1510 FIND v(dout1_7) AT=760.025n

.meas tran vdout1_8ck1510 FIND v(dout1_8) AT=760.025n

.meas tran vdout1_9ck1510 FIND v(dout1_9) AT=760.025n

.meas tran vdout1_10ck1510 FIND v(dout1_10) AT=760.025n

.meas tran vdout1_11ck1510 FIND v(dout1_11) AT=760.025n

.meas tran vdout1_12ck1510 FIND v(dout1_12) AT=760.025n

.meas tran vdout1_13ck1510 FIND v(dout1_13) AT=760.025n

.meas tran vdout1_14ck1510 FIND v(dout1_14) AT=760.025n

.meas tran vdout1_15ck1510 FIND v(dout1_15) AT=760.025n

.meas tran vdout1_16ck1510 FIND v(dout1_16) AT=760.025n

.meas tran vdout1_17ck1510 FIND v(dout1_17) AT=760.025n

.meas tran vdout1_18ck1510 FIND v(dout1_18) AT=760.025n

.meas tran vdout1_19ck1510 FIND v(dout1_19) AT=760.025n

.meas tran vdout1_20ck1510 FIND v(dout1_20) AT=760.025n

.meas tran vdout1_21ck1510 FIND v(dout1_21) AT=760.025n

.meas tran vdout1_22ck1510 FIND v(dout1_22) AT=760.025n

.meas tran vdout1_0ck1530 FIND v(dout1_0) AT=770.025n

.meas tran vdout1_1ck1530 FIND v(dout1_1) AT=770.025n

.meas tran vdout1_2ck1530 FIND v(dout1_2) AT=770.025n

.meas tran vdout1_3ck1530 FIND v(dout1_3) AT=770.025n

.meas tran vdout1_4ck1530 FIND v(dout1_4) AT=770.025n

.meas tran vdout1_5ck1530 FIND v(dout1_5) AT=770.025n

.meas tran vdout1_6ck1530 FIND v(dout1_6) AT=770.025n

.meas tran vdout1_7ck1530 FIND v(dout1_7) AT=770.025n

.meas tran vdout1_8ck1530 FIND v(dout1_8) AT=770.025n

.meas tran vdout1_9ck1530 FIND v(dout1_9) AT=770.025n

.meas tran vdout1_10ck1530 FIND v(dout1_10) AT=770.025n

.meas tran vdout1_11ck1530 FIND v(dout1_11) AT=770.025n

.meas tran vdout1_12ck1530 FIND v(dout1_12) AT=770.025n

.meas tran vdout1_13ck1530 FIND v(dout1_13) AT=770.025n

.meas tran vdout1_14ck1530 FIND v(dout1_14) AT=770.025n

.meas tran vdout1_15ck1530 FIND v(dout1_15) AT=770.025n

.meas tran vdout1_16ck1530 FIND v(dout1_16) AT=770.025n

.meas tran vdout1_17ck1530 FIND v(dout1_17) AT=770.025n

.meas tran vdout1_18ck1530 FIND v(dout1_18) AT=770.025n

.meas tran vdout1_19ck1530 FIND v(dout1_19) AT=770.025n

.meas tran vdout1_20ck1530 FIND v(dout1_20) AT=770.025n

.meas tran vdout1_21ck1530 FIND v(dout1_21) AT=770.025n

.meas tran vdout1_22ck1530 FIND v(dout1_22) AT=770.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_19ck1590 FIND v(dout1_19) AT=800.025n

.meas tran vdout1_20ck1590 FIND v(dout1_20) AT=800.025n

.meas tran vdout1_21ck1590 FIND v(dout1_21) AT=800.025n

.meas tran vdout1_22ck1590 FIND v(dout1_22) AT=800.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_17ck1640 FIND v(dout1_17) AT=825.025n

.meas tran vdout1_18ck1640 FIND v(dout1_18) AT=825.025n

.meas tran vdout1_19ck1640 FIND v(dout1_19) AT=825.025n

.meas tran vdout1_20ck1640 FIND v(dout1_20) AT=825.025n

.meas tran vdout1_21ck1640 FIND v(dout1_21) AT=825.025n

.meas tran vdout1_22ck1640 FIND v(dout1_22) AT=825.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_19ck1650 FIND v(dout1_19) AT=830.025n

.meas tran vdout1_20ck1650 FIND v(dout1_20) AT=830.025n

.meas tran vdout1_21ck1650 FIND v(dout1_21) AT=830.025n

.meas tran vdout1_22ck1650 FIND v(dout1_22) AT=830.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_22ck1690 FIND v(dout1_22) AT=850.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_19ck1780 FIND v(dout1_19) AT=895.025n

.meas tran vdout1_20ck1780 FIND v(dout1_20) AT=895.025n

.meas tran vdout1_21ck1780 FIND v(dout1_21) AT=895.025n

.meas tran vdout1_22ck1780 FIND v(dout1_22) AT=895.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_17ck1990 FIND v(dout1_17) AT=1000.025n

.meas tran vdout1_18ck1990 FIND v(dout1_18) AT=1000.025n

.meas tran vdout1_19ck1990 FIND v(dout1_19) AT=1000.025n

.meas tran vdout1_20ck1990 FIND v(dout1_20) AT=1000.025n

.meas tran vdout1_21ck1990 FIND v(dout1_21) AT=1000.025n

.meas tran vdout1_22ck1990 FIND v(dout1_22) AT=1000.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_17ck2010 FIND v(dout1_17) AT=1010.025n

.meas tran vdout1_18ck2010 FIND v(dout1_18) AT=1010.025n

.meas tran vdout1_19ck2010 FIND v(dout1_19) AT=1010.025n

.meas tran vdout1_20ck2010 FIND v(dout1_20) AT=1010.025n

.meas tran vdout1_21ck2010 FIND v(dout1_21) AT=1010.025n

.meas tran vdout1_22ck2010 FIND v(dout1_22) AT=1010.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n

.meas tran vdout1_22ck2030 FIND v(dout1_22) AT=1020.025n

.meas tran vdout1_0ck2040 FIND v(dout1_0) AT=1025.025n

.meas tran vdout1_1ck2040 FIND v(dout1_1) AT=1025.025n

.meas tran vdout1_2ck2040 FIND v(dout1_2) AT=1025.025n

.meas tran vdout1_3ck2040 FIND v(dout1_3) AT=1025.025n

.meas tran vdout1_4ck2040 FIND v(dout1_4) AT=1025.025n

.meas tran vdout1_5ck2040 FIND v(dout1_5) AT=1025.025n

.meas tran vdout1_6ck2040 FIND v(dout1_6) AT=1025.025n

.meas tran vdout1_7ck2040 FIND v(dout1_7) AT=1025.025n

.meas tran vdout1_8ck2040 FIND v(dout1_8) AT=1025.025n

.meas tran vdout1_9ck2040 FIND v(dout1_9) AT=1025.025n

.meas tran vdout1_10ck2040 FIND v(dout1_10) AT=1025.025n

.meas tran vdout1_11ck2040 FIND v(dout1_11) AT=1025.025n

.meas tran vdout1_12ck2040 FIND v(dout1_12) AT=1025.025n

.meas tran vdout1_13ck2040 FIND v(dout1_13) AT=1025.025n

.meas tran vdout1_14ck2040 FIND v(dout1_14) AT=1025.025n

.meas tran vdout1_15ck2040 FIND v(dout1_15) AT=1025.025n

.meas tran vdout1_16ck2040 FIND v(dout1_16) AT=1025.025n

.meas tran vdout1_17ck2040 FIND v(dout1_17) AT=1025.025n

.meas tran vdout1_18ck2040 FIND v(dout1_18) AT=1025.025n

.meas tran vdout1_19ck2040 FIND v(dout1_19) AT=1025.025n

.meas tran vdout1_20ck2040 FIND v(dout1_20) AT=1025.025n

.meas tran vdout1_21ck2040 FIND v(dout1_21) AT=1025.025n

.meas tran vdout1_22ck2040 FIND v(dout1_22) AT=1025.025n
