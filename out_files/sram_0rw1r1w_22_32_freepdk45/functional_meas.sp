.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_16ck60 FIND v(dout1_16) AT=35.025n

.meas tran vdout1_17ck60 FIND v(dout1_17) AT=35.025n

.meas tran vdout1_18ck60 FIND v(dout1_18) AT=35.025n

.meas tran vdout1_19ck60 FIND v(dout1_19) AT=35.025n

.meas tran vdout1_20ck60 FIND v(dout1_20) AT=35.025n

.meas tran vdout1_21ck60 FIND v(dout1_21) AT=35.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_17ck90 FIND v(dout1_17) AT=50.025n

.meas tran vdout1_18ck90 FIND v(dout1_18) AT=50.025n

.meas tran vdout1_19ck90 FIND v(dout1_19) AT=50.025n

.meas tran vdout1_20ck90 FIND v(dout1_20) AT=50.025n

.meas tran vdout1_21ck90 FIND v(dout1_21) AT=50.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_8ck110 FIND v(dout1_8) AT=60.025n

.meas tran vdout1_9ck110 FIND v(dout1_9) AT=60.025n

.meas tran vdout1_10ck110 FIND v(dout1_10) AT=60.025n

.meas tran vdout1_11ck110 FIND v(dout1_11) AT=60.025n

.meas tran vdout1_12ck110 FIND v(dout1_12) AT=60.025n

.meas tran vdout1_13ck110 FIND v(dout1_13) AT=60.025n

.meas tran vdout1_14ck110 FIND v(dout1_14) AT=60.025n

.meas tran vdout1_15ck110 FIND v(dout1_15) AT=60.025n

.meas tran vdout1_16ck110 FIND v(dout1_16) AT=60.025n

.meas tran vdout1_17ck110 FIND v(dout1_17) AT=60.025n

.meas tran vdout1_18ck110 FIND v(dout1_18) AT=60.025n

.meas tran vdout1_19ck110 FIND v(dout1_19) AT=60.025n

.meas tran vdout1_20ck110 FIND v(dout1_20) AT=60.025n

.meas tran vdout1_21ck110 FIND v(dout1_21) AT=60.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_0ck170 FIND v(dout1_0) AT=90.025n

.meas tran vdout1_1ck170 FIND v(dout1_1) AT=90.025n

.meas tran vdout1_2ck170 FIND v(dout1_2) AT=90.025n

.meas tran vdout1_3ck170 FIND v(dout1_3) AT=90.025n

.meas tran vdout1_4ck170 FIND v(dout1_4) AT=90.025n

.meas tran vdout1_5ck170 FIND v(dout1_5) AT=90.025n

.meas tran vdout1_6ck170 FIND v(dout1_6) AT=90.025n

.meas tran vdout1_7ck170 FIND v(dout1_7) AT=90.025n

.meas tran vdout1_8ck170 FIND v(dout1_8) AT=90.025n

.meas tran vdout1_9ck170 FIND v(dout1_9) AT=90.025n

.meas tran vdout1_10ck170 FIND v(dout1_10) AT=90.025n

.meas tran vdout1_11ck170 FIND v(dout1_11) AT=90.025n

.meas tran vdout1_12ck170 FIND v(dout1_12) AT=90.025n

.meas tran vdout1_13ck170 FIND v(dout1_13) AT=90.025n

.meas tran vdout1_14ck170 FIND v(dout1_14) AT=90.025n

.meas tran vdout1_15ck170 FIND v(dout1_15) AT=90.025n

.meas tran vdout1_16ck170 FIND v(dout1_16) AT=90.025n

.meas tran vdout1_17ck170 FIND v(dout1_17) AT=90.025n

.meas tran vdout1_18ck170 FIND v(dout1_18) AT=90.025n

.meas tran vdout1_19ck170 FIND v(dout1_19) AT=90.025n

.meas tran vdout1_20ck170 FIND v(dout1_20) AT=90.025n

.meas tran vdout1_21ck170 FIND v(dout1_21) AT=90.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_17ck240 FIND v(dout1_17) AT=125.025n

.meas tran vdout1_18ck240 FIND v(dout1_18) AT=125.025n

.meas tran vdout1_19ck240 FIND v(dout1_19) AT=125.025n

.meas tran vdout1_20ck240 FIND v(dout1_20) AT=125.025n

.meas tran vdout1_21ck240 FIND v(dout1_21) AT=125.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_19ck290 FIND v(dout1_19) AT=150.025n

.meas tran vdout1_20ck290 FIND v(dout1_20) AT=150.025n

.meas tran vdout1_21ck290 FIND v(dout1_21) AT=150.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_19ck420 FIND v(dout1_19) AT=215.025n

.meas tran vdout1_20ck420 FIND v(dout1_20) AT=215.025n

.meas tran vdout1_21ck420 FIND v(dout1_21) AT=215.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_19ck490 FIND v(dout1_19) AT=250.025n

.meas tran vdout1_20ck490 FIND v(dout1_20) AT=250.025n

.meas tran vdout1_21ck490 FIND v(dout1_21) AT=250.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_17ck590 FIND v(dout1_17) AT=300.025n

.meas tran vdout1_18ck590 FIND v(dout1_18) AT=300.025n

.meas tran vdout1_19ck590 FIND v(dout1_19) AT=300.025n

.meas tran vdout1_20ck590 FIND v(dout1_20) AT=300.025n

.meas tran vdout1_21ck590 FIND v(dout1_21) AT=300.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_0ck690 FIND v(dout1_0) AT=350.025n

.meas tran vdout1_1ck690 FIND v(dout1_1) AT=350.025n

.meas tran vdout1_2ck690 FIND v(dout1_2) AT=350.025n

.meas tran vdout1_3ck690 FIND v(dout1_3) AT=350.025n

.meas tran vdout1_4ck690 FIND v(dout1_4) AT=350.025n

.meas tran vdout1_5ck690 FIND v(dout1_5) AT=350.025n

.meas tran vdout1_6ck690 FIND v(dout1_6) AT=350.025n

.meas tran vdout1_7ck690 FIND v(dout1_7) AT=350.025n

.meas tran vdout1_8ck690 FIND v(dout1_8) AT=350.025n

.meas tran vdout1_9ck690 FIND v(dout1_9) AT=350.025n

.meas tran vdout1_10ck690 FIND v(dout1_10) AT=350.025n

.meas tran vdout1_11ck690 FIND v(dout1_11) AT=350.025n

.meas tran vdout1_12ck690 FIND v(dout1_12) AT=350.025n

.meas tran vdout1_13ck690 FIND v(dout1_13) AT=350.025n

.meas tran vdout1_14ck690 FIND v(dout1_14) AT=350.025n

.meas tran vdout1_15ck690 FIND v(dout1_15) AT=350.025n

.meas tran vdout1_16ck690 FIND v(dout1_16) AT=350.025n

.meas tran vdout1_17ck690 FIND v(dout1_17) AT=350.025n

.meas tran vdout1_18ck690 FIND v(dout1_18) AT=350.025n

.meas tran vdout1_19ck690 FIND v(dout1_19) AT=350.025n

.meas tran vdout1_20ck690 FIND v(dout1_20) AT=350.025n

.meas tran vdout1_21ck690 FIND v(dout1_21) AT=350.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_19ck760 FIND v(dout1_19) AT=385.025n

.meas tran vdout1_20ck760 FIND v(dout1_20) AT=385.025n

.meas tran vdout1_21ck760 FIND v(dout1_21) AT=385.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_0ck780 FIND v(dout1_0) AT=395.025n

.meas tran vdout1_1ck780 FIND v(dout1_1) AT=395.025n

.meas tran vdout1_2ck780 FIND v(dout1_2) AT=395.025n

.meas tran vdout1_3ck780 FIND v(dout1_3) AT=395.025n

.meas tran vdout1_4ck780 FIND v(dout1_4) AT=395.025n

.meas tran vdout1_5ck780 FIND v(dout1_5) AT=395.025n

.meas tran vdout1_6ck780 FIND v(dout1_6) AT=395.025n

.meas tran vdout1_7ck780 FIND v(dout1_7) AT=395.025n

.meas tran vdout1_8ck780 FIND v(dout1_8) AT=395.025n

.meas tran vdout1_9ck780 FIND v(dout1_9) AT=395.025n

.meas tran vdout1_10ck780 FIND v(dout1_10) AT=395.025n

.meas tran vdout1_11ck780 FIND v(dout1_11) AT=395.025n

.meas tran vdout1_12ck780 FIND v(dout1_12) AT=395.025n

.meas tran vdout1_13ck780 FIND v(dout1_13) AT=395.025n

.meas tran vdout1_14ck780 FIND v(dout1_14) AT=395.025n

.meas tran vdout1_15ck780 FIND v(dout1_15) AT=395.025n

.meas tran vdout1_16ck780 FIND v(dout1_16) AT=395.025n

.meas tran vdout1_17ck780 FIND v(dout1_17) AT=395.025n

.meas tran vdout1_18ck780 FIND v(dout1_18) AT=395.025n

.meas tran vdout1_19ck780 FIND v(dout1_19) AT=395.025n

.meas tran vdout1_20ck780 FIND v(dout1_20) AT=395.025n

.meas tran vdout1_21ck780 FIND v(dout1_21) AT=395.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_8ck800 FIND v(dout1_8) AT=405.025n

.meas tran vdout1_9ck800 FIND v(dout1_9) AT=405.025n

.meas tran vdout1_10ck800 FIND v(dout1_10) AT=405.025n

.meas tran vdout1_11ck800 FIND v(dout1_11) AT=405.025n

.meas tran vdout1_12ck800 FIND v(dout1_12) AT=405.025n

.meas tran vdout1_13ck800 FIND v(dout1_13) AT=405.025n

.meas tran vdout1_14ck800 FIND v(dout1_14) AT=405.025n

.meas tran vdout1_15ck800 FIND v(dout1_15) AT=405.025n

.meas tran vdout1_16ck800 FIND v(dout1_16) AT=405.025n

.meas tran vdout1_17ck800 FIND v(dout1_17) AT=405.025n

.meas tran vdout1_18ck800 FIND v(dout1_18) AT=405.025n

.meas tran vdout1_19ck800 FIND v(dout1_19) AT=405.025n

.meas tran vdout1_20ck800 FIND v(dout1_20) AT=405.025n

.meas tran vdout1_21ck800 FIND v(dout1_21) AT=405.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_8ck810 FIND v(dout1_8) AT=410.025n

.meas tran vdout1_9ck810 FIND v(dout1_9) AT=410.025n

.meas tran vdout1_10ck810 FIND v(dout1_10) AT=410.025n

.meas tran vdout1_11ck810 FIND v(dout1_11) AT=410.025n

.meas tran vdout1_12ck810 FIND v(dout1_12) AT=410.025n

.meas tran vdout1_13ck810 FIND v(dout1_13) AT=410.025n

.meas tran vdout1_14ck810 FIND v(dout1_14) AT=410.025n

.meas tran vdout1_15ck810 FIND v(dout1_15) AT=410.025n

.meas tran vdout1_16ck810 FIND v(dout1_16) AT=410.025n

.meas tran vdout1_17ck810 FIND v(dout1_17) AT=410.025n

.meas tran vdout1_18ck810 FIND v(dout1_18) AT=410.025n

.meas tran vdout1_19ck810 FIND v(dout1_19) AT=410.025n

.meas tran vdout1_20ck810 FIND v(dout1_20) AT=410.025n

.meas tran vdout1_21ck810 FIND v(dout1_21) AT=410.025n

.meas tran vdout1_0ck900 FIND v(dout1_0) AT=455.025n

.meas tran vdout1_1ck900 FIND v(dout1_1) AT=455.025n

.meas tran vdout1_2ck900 FIND v(dout1_2) AT=455.025n

.meas tran vdout1_3ck900 FIND v(dout1_3) AT=455.025n

.meas tran vdout1_4ck900 FIND v(dout1_4) AT=455.025n

.meas tran vdout1_5ck900 FIND v(dout1_5) AT=455.025n

.meas tran vdout1_6ck900 FIND v(dout1_6) AT=455.025n

.meas tran vdout1_7ck900 FIND v(dout1_7) AT=455.025n

.meas tran vdout1_8ck900 FIND v(dout1_8) AT=455.025n

.meas tran vdout1_9ck900 FIND v(dout1_9) AT=455.025n

.meas tran vdout1_10ck900 FIND v(dout1_10) AT=455.025n

.meas tran vdout1_11ck900 FIND v(dout1_11) AT=455.025n

.meas tran vdout1_12ck900 FIND v(dout1_12) AT=455.025n

.meas tran vdout1_13ck900 FIND v(dout1_13) AT=455.025n

.meas tran vdout1_14ck900 FIND v(dout1_14) AT=455.025n

.meas tran vdout1_15ck900 FIND v(dout1_15) AT=455.025n

.meas tran vdout1_16ck900 FIND v(dout1_16) AT=455.025n

.meas tran vdout1_17ck900 FIND v(dout1_17) AT=455.025n

.meas tran vdout1_18ck900 FIND v(dout1_18) AT=455.025n

.meas tran vdout1_19ck900 FIND v(dout1_19) AT=455.025n

.meas tran vdout1_20ck900 FIND v(dout1_20) AT=455.025n

.meas tran vdout1_21ck900 FIND v(dout1_21) AT=455.025n

.meas tran vdout1_0ck910 FIND v(dout1_0) AT=460.025n

.meas tran vdout1_1ck910 FIND v(dout1_1) AT=460.025n

.meas tran vdout1_2ck910 FIND v(dout1_2) AT=460.025n

.meas tran vdout1_3ck910 FIND v(dout1_3) AT=460.025n

.meas tran vdout1_4ck910 FIND v(dout1_4) AT=460.025n

.meas tran vdout1_5ck910 FIND v(dout1_5) AT=460.025n

.meas tran vdout1_6ck910 FIND v(dout1_6) AT=460.025n

.meas tran vdout1_7ck910 FIND v(dout1_7) AT=460.025n

.meas tran vdout1_8ck910 FIND v(dout1_8) AT=460.025n

.meas tran vdout1_9ck910 FIND v(dout1_9) AT=460.025n

.meas tran vdout1_10ck910 FIND v(dout1_10) AT=460.025n

.meas tran vdout1_11ck910 FIND v(dout1_11) AT=460.025n

.meas tran vdout1_12ck910 FIND v(dout1_12) AT=460.025n

.meas tran vdout1_13ck910 FIND v(dout1_13) AT=460.025n

.meas tran vdout1_14ck910 FIND v(dout1_14) AT=460.025n

.meas tran vdout1_15ck910 FIND v(dout1_15) AT=460.025n

.meas tran vdout1_16ck910 FIND v(dout1_16) AT=460.025n

.meas tran vdout1_17ck910 FIND v(dout1_17) AT=460.025n

.meas tran vdout1_18ck910 FIND v(dout1_18) AT=460.025n

.meas tran vdout1_19ck910 FIND v(dout1_19) AT=460.025n

.meas tran vdout1_20ck910 FIND v(dout1_20) AT=460.025n

.meas tran vdout1_21ck910 FIND v(dout1_21) AT=460.025n

.meas tran vdout1_0ck940 FIND v(dout1_0) AT=475.025n

.meas tran vdout1_1ck940 FIND v(dout1_1) AT=475.025n

.meas tran vdout1_2ck940 FIND v(dout1_2) AT=475.025n

.meas tran vdout1_3ck940 FIND v(dout1_3) AT=475.025n

.meas tran vdout1_4ck940 FIND v(dout1_4) AT=475.025n

.meas tran vdout1_5ck940 FIND v(dout1_5) AT=475.025n

.meas tran vdout1_6ck940 FIND v(dout1_6) AT=475.025n

.meas tran vdout1_7ck940 FIND v(dout1_7) AT=475.025n

.meas tran vdout1_8ck940 FIND v(dout1_8) AT=475.025n

.meas tran vdout1_9ck940 FIND v(dout1_9) AT=475.025n

.meas tran vdout1_10ck940 FIND v(dout1_10) AT=475.025n

.meas tran vdout1_11ck940 FIND v(dout1_11) AT=475.025n

.meas tran vdout1_12ck940 FIND v(dout1_12) AT=475.025n

.meas tran vdout1_13ck940 FIND v(dout1_13) AT=475.025n

.meas tran vdout1_14ck940 FIND v(dout1_14) AT=475.025n

.meas tran vdout1_15ck940 FIND v(dout1_15) AT=475.025n

.meas tran vdout1_16ck940 FIND v(dout1_16) AT=475.025n

.meas tran vdout1_17ck940 FIND v(dout1_17) AT=475.025n

.meas tran vdout1_18ck940 FIND v(dout1_18) AT=475.025n

.meas tran vdout1_19ck940 FIND v(dout1_19) AT=475.025n

.meas tran vdout1_20ck940 FIND v(dout1_20) AT=475.025n

.meas tran vdout1_21ck940 FIND v(dout1_21) AT=475.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_0ck970 FIND v(dout1_0) AT=490.025n

.meas tran vdout1_1ck970 FIND v(dout1_1) AT=490.025n

.meas tran vdout1_2ck970 FIND v(dout1_2) AT=490.025n

.meas tran vdout1_3ck970 FIND v(dout1_3) AT=490.025n

.meas tran vdout1_4ck970 FIND v(dout1_4) AT=490.025n

.meas tran vdout1_5ck970 FIND v(dout1_5) AT=490.025n

.meas tran vdout1_6ck970 FIND v(dout1_6) AT=490.025n

.meas tran vdout1_7ck970 FIND v(dout1_7) AT=490.025n

.meas tran vdout1_8ck970 FIND v(dout1_8) AT=490.025n

.meas tran vdout1_9ck970 FIND v(dout1_9) AT=490.025n

.meas tran vdout1_10ck970 FIND v(dout1_10) AT=490.025n

.meas tran vdout1_11ck970 FIND v(dout1_11) AT=490.025n

.meas tran vdout1_12ck970 FIND v(dout1_12) AT=490.025n

.meas tran vdout1_13ck970 FIND v(dout1_13) AT=490.025n

.meas tran vdout1_14ck970 FIND v(dout1_14) AT=490.025n

.meas tran vdout1_15ck970 FIND v(dout1_15) AT=490.025n

.meas tran vdout1_16ck970 FIND v(dout1_16) AT=490.025n

.meas tran vdout1_17ck970 FIND v(dout1_17) AT=490.025n

.meas tran vdout1_18ck970 FIND v(dout1_18) AT=490.025n

.meas tran vdout1_19ck970 FIND v(dout1_19) AT=490.025n

.meas tran vdout1_20ck970 FIND v(dout1_20) AT=490.025n

.meas tran vdout1_21ck970 FIND v(dout1_21) AT=490.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_16ck980 FIND v(dout1_16) AT=495.025n

.meas tran vdout1_17ck980 FIND v(dout1_17) AT=495.025n

.meas tran vdout1_18ck980 FIND v(dout1_18) AT=495.025n

.meas tran vdout1_19ck980 FIND v(dout1_19) AT=495.025n

.meas tran vdout1_20ck980 FIND v(dout1_20) AT=495.025n

.meas tran vdout1_21ck980 FIND v(dout1_21) AT=495.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_17ck1020 FIND v(dout1_17) AT=515.025n

.meas tran vdout1_18ck1020 FIND v(dout1_18) AT=515.025n

.meas tran vdout1_19ck1020 FIND v(dout1_19) AT=515.025n

.meas tran vdout1_20ck1020 FIND v(dout1_20) AT=515.025n

.meas tran vdout1_21ck1020 FIND v(dout1_21) AT=515.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_16ck1120 FIND v(dout1_16) AT=565.025n

.meas tran vdout1_17ck1120 FIND v(dout1_17) AT=565.025n

.meas tran vdout1_18ck1120 FIND v(dout1_18) AT=565.025n

.meas tran vdout1_19ck1120 FIND v(dout1_19) AT=565.025n

.meas tran vdout1_20ck1120 FIND v(dout1_20) AT=565.025n

.meas tran vdout1_21ck1120 FIND v(dout1_21) AT=565.025n

.meas tran vdout1_0ck1150 FIND v(dout1_0) AT=580.025n

.meas tran vdout1_1ck1150 FIND v(dout1_1) AT=580.025n

.meas tran vdout1_2ck1150 FIND v(dout1_2) AT=580.025n

.meas tran vdout1_3ck1150 FIND v(dout1_3) AT=580.025n

.meas tran vdout1_4ck1150 FIND v(dout1_4) AT=580.025n

.meas tran vdout1_5ck1150 FIND v(dout1_5) AT=580.025n

.meas tran vdout1_6ck1150 FIND v(dout1_6) AT=580.025n

.meas tran vdout1_7ck1150 FIND v(dout1_7) AT=580.025n

.meas tran vdout1_8ck1150 FIND v(dout1_8) AT=580.025n

.meas tran vdout1_9ck1150 FIND v(dout1_9) AT=580.025n

.meas tran vdout1_10ck1150 FIND v(dout1_10) AT=580.025n

.meas tran vdout1_11ck1150 FIND v(dout1_11) AT=580.025n

.meas tran vdout1_12ck1150 FIND v(dout1_12) AT=580.025n

.meas tran vdout1_13ck1150 FIND v(dout1_13) AT=580.025n

.meas tran vdout1_14ck1150 FIND v(dout1_14) AT=580.025n

.meas tran vdout1_15ck1150 FIND v(dout1_15) AT=580.025n

.meas tran vdout1_16ck1150 FIND v(dout1_16) AT=580.025n

.meas tran vdout1_17ck1150 FIND v(dout1_17) AT=580.025n

.meas tran vdout1_18ck1150 FIND v(dout1_18) AT=580.025n

.meas tran vdout1_19ck1150 FIND v(dout1_19) AT=580.025n

.meas tran vdout1_20ck1150 FIND v(dout1_20) AT=580.025n

.meas tran vdout1_21ck1150 FIND v(dout1_21) AT=580.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_16ck1170 FIND v(dout1_16) AT=590.025n

.meas tran vdout1_17ck1170 FIND v(dout1_17) AT=590.025n

.meas tran vdout1_18ck1170 FIND v(dout1_18) AT=590.025n

.meas tran vdout1_19ck1170 FIND v(dout1_19) AT=590.025n

.meas tran vdout1_20ck1170 FIND v(dout1_20) AT=590.025n

.meas tran vdout1_21ck1170 FIND v(dout1_21) AT=590.025n

.meas tran vdout1_0ck1250 FIND v(dout1_0) AT=630.025n

.meas tran vdout1_1ck1250 FIND v(dout1_1) AT=630.025n

.meas tran vdout1_2ck1250 FIND v(dout1_2) AT=630.025n

.meas tran vdout1_3ck1250 FIND v(dout1_3) AT=630.025n

.meas tran vdout1_4ck1250 FIND v(dout1_4) AT=630.025n

.meas tran vdout1_5ck1250 FIND v(dout1_5) AT=630.025n

.meas tran vdout1_6ck1250 FIND v(dout1_6) AT=630.025n

.meas tran vdout1_7ck1250 FIND v(dout1_7) AT=630.025n

.meas tran vdout1_8ck1250 FIND v(dout1_8) AT=630.025n

.meas tran vdout1_9ck1250 FIND v(dout1_9) AT=630.025n

.meas tran vdout1_10ck1250 FIND v(dout1_10) AT=630.025n

.meas tran vdout1_11ck1250 FIND v(dout1_11) AT=630.025n

.meas tran vdout1_12ck1250 FIND v(dout1_12) AT=630.025n

.meas tran vdout1_13ck1250 FIND v(dout1_13) AT=630.025n

.meas tran vdout1_14ck1250 FIND v(dout1_14) AT=630.025n

.meas tran vdout1_15ck1250 FIND v(dout1_15) AT=630.025n

.meas tran vdout1_16ck1250 FIND v(dout1_16) AT=630.025n

.meas tran vdout1_17ck1250 FIND v(dout1_17) AT=630.025n

.meas tran vdout1_18ck1250 FIND v(dout1_18) AT=630.025n

.meas tran vdout1_19ck1250 FIND v(dout1_19) AT=630.025n

.meas tran vdout1_20ck1250 FIND v(dout1_20) AT=630.025n

.meas tran vdout1_21ck1250 FIND v(dout1_21) AT=630.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_16ck1360 FIND v(dout1_16) AT=685.025n

.meas tran vdout1_17ck1360 FIND v(dout1_17) AT=685.025n

.meas tran vdout1_18ck1360 FIND v(dout1_18) AT=685.025n

.meas tran vdout1_19ck1360 FIND v(dout1_19) AT=685.025n

.meas tran vdout1_20ck1360 FIND v(dout1_20) AT=685.025n

.meas tran vdout1_21ck1360 FIND v(dout1_21) AT=685.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_16ck1420 FIND v(dout1_16) AT=715.025n

.meas tran vdout1_17ck1420 FIND v(dout1_17) AT=715.025n

.meas tran vdout1_18ck1420 FIND v(dout1_18) AT=715.025n

.meas tran vdout1_19ck1420 FIND v(dout1_19) AT=715.025n

.meas tran vdout1_20ck1420 FIND v(dout1_20) AT=715.025n

.meas tran vdout1_21ck1420 FIND v(dout1_21) AT=715.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_19ck1430 FIND v(dout1_19) AT=720.025n

.meas tran vdout1_20ck1430 FIND v(dout1_20) AT=720.025n

.meas tran vdout1_21ck1430 FIND v(dout1_21) AT=720.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_8ck1470 FIND v(dout1_8) AT=740.025n

.meas tran vdout1_9ck1470 FIND v(dout1_9) AT=740.025n

.meas tran vdout1_10ck1470 FIND v(dout1_10) AT=740.025n

.meas tran vdout1_11ck1470 FIND v(dout1_11) AT=740.025n

.meas tran vdout1_12ck1470 FIND v(dout1_12) AT=740.025n

.meas tran vdout1_13ck1470 FIND v(dout1_13) AT=740.025n

.meas tran vdout1_14ck1470 FIND v(dout1_14) AT=740.025n

.meas tran vdout1_15ck1470 FIND v(dout1_15) AT=740.025n

.meas tran vdout1_16ck1470 FIND v(dout1_16) AT=740.025n

.meas tran vdout1_17ck1470 FIND v(dout1_17) AT=740.025n

.meas tran vdout1_18ck1470 FIND v(dout1_18) AT=740.025n

.meas tran vdout1_19ck1470 FIND v(dout1_19) AT=740.025n

.meas tran vdout1_20ck1470 FIND v(dout1_20) AT=740.025n

.meas tran vdout1_21ck1470 FIND v(dout1_21) AT=740.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_16ck1480 FIND v(dout1_16) AT=745.025n

.meas tran vdout1_17ck1480 FIND v(dout1_17) AT=745.025n

.meas tran vdout1_18ck1480 FIND v(dout1_18) AT=745.025n

.meas tran vdout1_19ck1480 FIND v(dout1_19) AT=745.025n

.meas tran vdout1_20ck1480 FIND v(dout1_20) AT=745.025n

.meas tran vdout1_21ck1480 FIND v(dout1_21) AT=745.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_0ck1530 FIND v(dout1_0) AT=770.025n

.meas tran vdout1_1ck1530 FIND v(dout1_1) AT=770.025n

.meas tran vdout1_2ck1530 FIND v(dout1_2) AT=770.025n

.meas tran vdout1_3ck1530 FIND v(dout1_3) AT=770.025n

.meas tran vdout1_4ck1530 FIND v(dout1_4) AT=770.025n

.meas tran vdout1_5ck1530 FIND v(dout1_5) AT=770.025n

.meas tran vdout1_6ck1530 FIND v(dout1_6) AT=770.025n

.meas tran vdout1_7ck1530 FIND v(dout1_7) AT=770.025n

.meas tran vdout1_8ck1530 FIND v(dout1_8) AT=770.025n

.meas tran vdout1_9ck1530 FIND v(dout1_9) AT=770.025n

.meas tran vdout1_10ck1530 FIND v(dout1_10) AT=770.025n

.meas tran vdout1_11ck1530 FIND v(dout1_11) AT=770.025n

.meas tran vdout1_12ck1530 FIND v(dout1_12) AT=770.025n

.meas tran vdout1_13ck1530 FIND v(dout1_13) AT=770.025n

.meas tran vdout1_14ck1530 FIND v(dout1_14) AT=770.025n

.meas tran vdout1_15ck1530 FIND v(dout1_15) AT=770.025n

.meas tran vdout1_16ck1530 FIND v(dout1_16) AT=770.025n

.meas tran vdout1_17ck1530 FIND v(dout1_17) AT=770.025n

.meas tran vdout1_18ck1530 FIND v(dout1_18) AT=770.025n

.meas tran vdout1_19ck1530 FIND v(dout1_19) AT=770.025n

.meas tran vdout1_20ck1530 FIND v(dout1_20) AT=770.025n

.meas tran vdout1_21ck1530 FIND v(dout1_21) AT=770.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_17ck1570 FIND v(dout1_17) AT=790.025n

.meas tran vdout1_18ck1570 FIND v(dout1_18) AT=790.025n

.meas tran vdout1_19ck1570 FIND v(dout1_19) AT=790.025n

.meas tran vdout1_20ck1570 FIND v(dout1_20) AT=790.025n

.meas tran vdout1_21ck1570 FIND v(dout1_21) AT=790.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_16ck1620 FIND v(dout1_16) AT=815.025n

.meas tran vdout1_17ck1620 FIND v(dout1_17) AT=815.025n

.meas tran vdout1_18ck1620 FIND v(dout1_18) AT=815.025n

.meas tran vdout1_19ck1620 FIND v(dout1_19) AT=815.025n

.meas tran vdout1_20ck1620 FIND v(dout1_20) AT=815.025n

.meas tran vdout1_21ck1620 FIND v(dout1_21) AT=815.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_19ck1700 FIND v(dout1_19) AT=855.025n

.meas tran vdout1_20ck1700 FIND v(dout1_20) AT=855.025n

.meas tran vdout1_21ck1700 FIND v(dout1_21) AT=855.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_16ck1720 FIND v(dout1_16) AT=865.025n

.meas tran vdout1_17ck1720 FIND v(dout1_17) AT=865.025n

.meas tran vdout1_18ck1720 FIND v(dout1_18) AT=865.025n

.meas tran vdout1_19ck1720 FIND v(dout1_19) AT=865.025n

.meas tran vdout1_20ck1720 FIND v(dout1_20) AT=865.025n

.meas tran vdout1_21ck1720 FIND v(dout1_21) AT=865.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_16ck1820 FIND v(dout1_16) AT=915.025n

.meas tran vdout1_17ck1820 FIND v(dout1_17) AT=915.025n

.meas tran vdout1_18ck1820 FIND v(dout1_18) AT=915.025n

.meas tran vdout1_19ck1820 FIND v(dout1_19) AT=915.025n

.meas tran vdout1_20ck1820 FIND v(dout1_20) AT=915.025n

.meas tran vdout1_21ck1820 FIND v(dout1_21) AT=915.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_8ck1850 FIND v(dout1_8) AT=930.025n

.meas tran vdout1_9ck1850 FIND v(dout1_9) AT=930.025n

.meas tran vdout1_10ck1850 FIND v(dout1_10) AT=930.025n

.meas tran vdout1_11ck1850 FIND v(dout1_11) AT=930.025n

.meas tran vdout1_12ck1850 FIND v(dout1_12) AT=930.025n

.meas tran vdout1_13ck1850 FIND v(dout1_13) AT=930.025n

.meas tran vdout1_14ck1850 FIND v(dout1_14) AT=930.025n

.meas tran vdout1_15ck1850 FIND v(dout1_15) AT=930.025n

.meas tran vdout1_16ck1850 FIND v(dout1_16) AT=930.025n

.meas tran vdout1_17ck1850 FIND v(dout1_17) AT=930.025n

.meas tran vdout1_18ck1850 FIND v(dout1_18) AT=930.025n

.meas tran vdout1_19ck1850 FIND v(dout1_19) AT=930.025n

.meas tran vdout1_20ck1850 FIND v(dout1_20) AT=930.025n

.meas tran vdout1_21ck1850 FIND v(dout1_21) AT=930.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_8ck1900 FIND v(dout1_8) AT=955.025n

.meas tran vdout1_9ck1900 FIND v(dout1_9) AT=955.025n

.meas tran vdout1_10ck1900 FIND v(dout1_10) AT=955.025n

.meas tran vdout1_11ck1900 FIND v(dout1_11) AT=955.025n

.meas tran vdout1_12ck1900 FIND v(dout1_12) AT=955.025n

.meas tran vdout1_13ck1900 FIND v(dout1_13) AT=955.025n

.meas tran vdout1_14ck1900 FIND v(dout1_14) AT=955.025n

.meas tran vdout1_15ck1900 FIND v(dout1_15) AT=955.025n

.meas tran vdout1_16ck1900 FIND v(dout1_16) AT=955.025n

.meas tran vdout1_17ck1900 FIND v(dout1_17) AT=955.025n

.meas tran vdout1_18ck1900 FIND v(dout1_18) AT=955.025n

.meas tran vdout1_19ck1900 FIND v(dout1_19) AT=955.025n

.meas tran vdout1_20ck1900 FIND v(dout1_20) AT=955.025n

.meas tran vdout1_21ck1900 FIND v(dout1_21) AT=955.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n
