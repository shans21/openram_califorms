.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_0ck50 FIND v(dout1_0) AT=30.025n

.meas tran vdout1_1ck50 FIND v(dout1_1) AT=30.025n

.meas tran vdout1_2ck50 FIND v(dout1_2) AT=30.025n

.meas tran vdout1_3ck50 FIND v(dout1_3) AT=30.025n

.meas tran vdout1_4ck50 FIND v(dout1_4) AT=30.025n

.meas tran vdout1_5ck50 FIND v(dout1_5) AT=30.025n

.meas tran vdout1_6ck50 FIND v(dout1_6) AT=30.025n

.meas tran vdout1_7ck50 FIND v(dout1_7) AT=30.025n

.meas tran vdout1_8ck50 FIND v(dout1_8) AT=30.025n

.meas tran vdout1_9ck50 FIND v(dout1_9) AT=30.025n

.meas tran vdout1_10ck50 FIND v(dout1_10) AT=30.025n

.meas tran vdout1_11ck50 FIND v(dout1_11) AT=30.025n

.meas tran vdout1_12ck50 FIND v(dout1_12) AT=30.025n

.meas tran vdout1_13ck50 FIND v(dout1_13) AT=30.025n

.meas tran vdout1_14ck50 FIND v(dout1_14) AT=30.025n

.meas tran vdout1_15ck50 FIND v(dout1_15) AT=30.025n

.meas tran vdout1_16ck50 FIND v(dout1_16) AT=30.025n

.meas tran vdout1_17ck50 FIND v(dout1_17) AT=30.025n

.meas tran vdout1_18ck50 FIND v(dout1_18) AT=30.025n

.meas tran vdout1_19ck50 FIND v(dout1_19) AT=30.025n

.meas tran vdout1_20ck50 FIND v(dout1_20) AT=30.025n

.meas tran vdout1_21ck50 FIND v(dout1_21) AT=30.025n

.meas tran vdout1_22ck50 FIND v(dout1_22) AT=30.025n

.meas tran vdout1_23ck50 FIND v(dout1_23) AT=30.025n

.meas tran vdout1_24ck50 FIND v(dout1_24) AT=30.025n

.meas tran vdout1_25ck50 FIND v(dout1_25) AT=30.025n

.meas tran vdout1_26ck50 FIND v(dout1_26) AT=30.025n

.meas tran vdout1_27ck50 FIND v(dout1_27) AT=30.025n

.meas tran vdout1_28ck50 FIND v(dout1_28) AT=30.025n

.meas tran vdout1_29ck50 FIND v(dout1_29) AT=30.025n

.meas tran vdout1_30ck50 FIND v(dout1_30) AT=30.025n

.meas tran vdout1_31ck50 FIND v(dout1_31) AT=30.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_17ck80 FIND v(dout1_17) AT=45.025n

.meas tran vdout1_18ck80 FIND v(dout1_18) AT=45.025n

.meas tran vdout1_19ck80 FIND v(dout1_19) AT=45.025n

.meas tran vdout1_20ck80 FIND v(dout1_20) AT=45.025n

.meas tran vdout1_21ck80 FIND v(dout1_21) AT=45.025n

.meas tran vdout1_22ck80 FIND v(dout1_22) AT=45.025n

.meas tran vdout1_23ck80 FIND v(dout1_23) AT=45.025n

.meas tran vdout1_24ck80 FIND v(dout1_24) AT=45.025n

.meas tran vdout1_25ck80 FIND v(dout1_25) AT=45.025n

.meas tran vdout1_26ck80 FIND v(dout1_26) AT=45.025n

.meas tran vdout1_27ck80 FIND v(dout1_27) AT=45.025n

.meas tran vdout1_28ck80 FIND v(dout1_28) AT=45.025n

.meas tran vdout1_29ck80 FIND v(dout1_29) AT=45.025n

.meas tran vdout1_30ck80 FIND v(dout1_30) AT=45.025n

.meas tran vdout1_31ck80 FIND v(dout1_31) AT=45.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_17ck90 FIND v(dout1_17) AT=50.025n

.meas tran vdout1_18ck90 FIND v(dout1_18) AT=50.025n

.meas tran vdout1_19ck90 FIND v(dout1_19) AT=50.025n

.meas tran vdout1_20ck90 FIND v(dout1_20) AT=50.025n

.meas tran vdout1_21ck90 FIND v(dout1_21) AT=50.025n

.meas tran vdout1_22ck90 FIND v(dout1_22) AT=50.025n

.meas tran vdout1_23ck90 FIND v(dout1_23) AT=50.025n

.meas tran vdout1_24ck90 FIND v(dout1_24) AT=50.025n

.meas tran vdout1_25ck90 FIND v(dout1_25) AT=50.025n

.meas tran vdout1_26ck90 FIND v(dout1_26) AT=50.025n

.meas tran vdout1_27ck90 FIND v(dout1_27) AT=50.025n

.meas tran vdout1_28ck90 FIND v(dout1_28) AT=50.025n

.meas tran vdout1_29ck90 FIND v(dout1_29) AT=50.025n

.meas tran vdout1_30ck90 FIND v(dout1_30) AT=50.025n

.meas tran vdout1_31ck90 FIND v(dout1_31) AT=50.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_22ck140 FIND v(dout1_22) AT=75.025n

.meas tran vdout1_23ck140 FIND v(dout1_23) AT=75.025n

.meas tran vdout1_24ck140 FIND v(dout1_24) AT=75.025n

.meas tran vdout1_25ck140 FIND v(dout1_25) AT=75.025n

.meas tran vdout1_26ck140 FIND v(dout1_26) AT=75.025n

.meas tran vdout1_27ck140 FIND v(dout1_27) AT=75.025n

.meas tran vdout1_28ck140 FIND v(dout1_28) AT=75.025n

.meas tran vdout1_29ck140 FIND v(dout1_29) AT=75.025n

.meas tran vdout1_30ck140 FIND v(dout1_30) AT=75.025n

.meas tran vdout1_31ck140 FIND v(dout1_31) AT=75.025n

.meas tran vdout1_0ck170 FIND v(dout1_0) AT=90.025n

.meas tran vdout1_1ck170 FIND v(dout1_1) AT=90.025n

.meas tran vdout1_2ck170 FIND v(dout1_2) AT=90.025n

.meas tran vdout1_3ck170 FIND v(dout1_3) AT=90.025n

.meas tran vdout1_4ck170 FIND v(dout1_4) AT=90.025n

.meas tran vdout1_5ck170 FIND v(dout1_5) AT=90.025n

.meas tran vdout1_6ck170 FIND v(dout1_6) AT=90.025n

.meas tran vdout1_7ck170 FIND v(dout1_7) AT=90.025n

.meas tran vdout1_8ck170 FIND v(dout1_8) AT=90.025n

.meas tran vdout1_9ck170 FIND v(dout1_9) AT=90.025n

.meas tran vdout1_10ck170 FIND v(dout1_10) AT=90.025n

.meas tran vdout1_11ck170 FIND v(dout1_11) AT=90.025n

.meas tran vdout1_12ck170 FIND v(dout1_12) AT=90.025n

.meas tran vdout1_13ck170 FIND v(dout1_13) AT=90.025n

.meas tran vdout1_14ck170 FIND v(dout1_14) AT=90.025n

.meas tran vdout1_15ck170 FIND v(dout1_15) AT=90.025n

.meas tran vdout1_16ck170 FIND v(dout1_16) AT=90.025n

.meas tran vdout1_17ck170 FIND v(dout1_17) AT=90.025n

.meas tran vdout1_18ck170 FIND v(dout1_18) AT=90.025n

.meas tran vdout1_19ck170 FIND v(dout1_19) AT=90.025n

.meas tran vdout1_20ck170 FIND v(dout1_20) AT=90.025n

.meas tran vdout1_21ck170 FIND v(dout1_21) AT=90.025n

.meas tran vdout1_22ck170 FIND v(dout1_22) AT=90.025n

.meas tran vdout1_23ck170 FIND v(dout1_23) AT=90.025n

.meas tran vdout1_24ck170 FIND v(dout1_24) AT=90.025n

.meas tran vdout1_25ck170 FIND v(dout1_25) AT=90.025n

.meas tran vdout1_26ck170 FIND v(dout1_26) AT=90.025n

.meas tran vdout1_27ck170 FIND v(dout1_27) AT=90.025n

.meas tran vdout1_28ck170 FIND v(dout1_28) AT=90.025n

.meas tran vdout1_29ck170 FIND v(dout1_29) AT=90.025n

.meas tran vdout1_30ck170 FIND v(dout1_30) AT=90.025n

.meas tran vdout1_31ck170 FIND v(dout1_31) AT=90.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_22ck180 FIND v(dout1_22) AT=95.025n

.meas tran vdout1_23ck180 FIND v(dout1_23) AT=95.025n

.meas tran vdout1_24ck180 FIND v(dout1_24) AT=95.025n

.meas tran vdout1_25ck180 FIND v(dout1_25) AT=95.025n

.meas tran vdout1_26ck180 FIND v(dout1_26) AT=95.025n

.meas tran vdout1_27ck180 FIND v(dout1_27) AT=95.025n

.meas tran vdout1_28ck180 FIND v(dout1_28) AT=95.025n

.meas tran vdout1_29ck180 FIND v(dout1_29) AT=95.025n

.meas tran vdout1_30ck180 FIND v(dout1_30) AT=95.025n

.meas tran vdout1_31ck180 FIND v(dout1_31) AT=95.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_22ck200 FIND v(dout1_22) AT=105.025n

.meas tran vdout1_23ck200 FIND v(dout1_23) AT=105.025n

.meas tran vdout1_24ck200 FIND v(dout1_24) AT=105.025n

.meas tran vdout1_25ck200 FIND v(dout1_25) AT=105.025n

.meas tran vdout1_26ck200 FIND v(dout1_26) AT=105.025n

.meas tran vdout1_27ck200 FIND v(dout1_27) AT=105.025n

.meas tran vdout1_28ck200 FIND v(dout1_28) AT=105.025n

.meas tran vdout1_29ck200 FIND v(dout1_29) AT=105.025n

.meas tran vdout1_30ck200 FIND v(dout1_30) AT=105.025n

.meas tran vdout1_31ck200 FIND v(dout1_31) AT=105.025n

.meas tran vdout1_0ck220 FIND v(dout1_0) AT=115.025n

.meas tran vdout1_1ck220 FIND v(dout1_1) AT=115.025n

.meas tran vdout1_2ck220 FIND v(dout1_2) AT=115.025n

.meas tran vdout1_3ck220 FIND v(dout1_3) AT=115.025n

.meas tran vdout1_4ck220 FIND v(dout1_4) AT=115.025n

.meas tran vdout1_5ck220 FIND v(dout1_5) AT=115.025n

.meas tran vdout1_6ck220 FIND v(dout1_6) AT=115.025n

.meas tran vdout1_7ck220 FIND v(dout1_7) AT=115.025n

.meas tran vdout1_8ck220 FIND v(dout1_8) AT=115.025n

.meas tran vdout1_9ck220 FIND v(dout1_9) AT=115.025n

.meas tran vdout1_10ck220 FIND v(dout1_10) AT=115.025n

.meas tran vdout1_11ck220 FIND v(dout1_11) AT=115.025n

.meas tran vdout1_12ck220 FIND v(dout1_12) AT=115.025n

.meas tran vdout1_13ck220 FIND v(dout1_13) AT=115.025n

.meas tran vdout1_14ck220 FIND v(dout1_14) AT=115.025n

.meas tran vdout1_15ck220 FIND v(dout1_15) AT=115.025n

.meas tran vdout1_16ck220 FIND v(dout1_16) AT=115.025n

.meas tran vdout1_17ck220 FIND v(dout1_17) AT=115.025n

.meas tran vdout1_18ck220 FIND v(dout1_18) AT=115.025n

.meas tran vdout1_19ck220 FIND v(dout1_19) AT=115.025n

.meas tran vdout1_20ck220 FIND v(dout1_20) AT=115.025n

.meas tran vdout1_21ck220 FIND v(dout1_21) AT=115.025n

.meas tran vdout1_22ck220 FIND v(dout1_22) AT=115.025n

.meas tran vdout1_23ck220 FIND v(dout1_23) AT=115.025n

.meas tran vdout1_24ck220 FIND v(dout1_24) AT=115.025n

.meas tran vdout1_25ck220 FIND v(dout1_25) AT=115.025n

.meas tran vdout1_26ck220 FIND v(dout1_26) AT=115.025n

.meas tran vdout1_27ck220 FIND v(dout1_27) AT=115.025n

.meas tran vdout1_28ck220 FIND v(dout1_28) AT=115.025n

.meas tran vdout1_29ck220 FIND v(dout1_29) AT=115.025n

.meas tran vdout1_30ck220 FIND v(dout1_30) AT=115.025n

.meas tran vdout1_31ck220 FIND v(dout1_31) AT=115.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_17ck250 FIND v(dout1_17) AT=130.025n

.meas tran vdout1_18ck250 FIND v(dout1_18) AT=130.025n

.meas tran vdout1_19ck250 FIND v(dout1_19) AT=130.025n

.meas tran vdout1_20ck250 FIND v(dout1_20) AT=130.025n

.meas tran vdout1_21ck250 FIND v(dout1_21) AT=130.025n

.meas tran vdout1_22ck250 FIND v(dout1_22) AT=130.025n

.meas tran vdout1_23ck250 FIND v(dout1_23) AT=130.025n

.meas tran vdout1_24ck250 FIND v(dout1_24) AT=130.025n

.meas tran vdout1_25ck250 FIND v(dout1_25) AT=130.025n

.meas tran vdout1_26ck250 FIND v(dout1_26) AT=130.025n

.meas tran vdout1_27ck250 FIND v(dout1_27) AT=130.025n

.meas tran vdout1_28ck250 FIND v(dout1_28) AT=130.025n

.meas tran vdout1_29ck250 FIND v(dout1_29) AT=130.025n

.meas tran vdout1_30ck250 FIND v(dout1_30) AT=130.025n

.meas tran vdout1_31ck250 FIND v(dout1_31) AT=130.025n

.meas tran vdout1_0ck280 FIND v(dout1_0) AT=145.025n

.meas tran vdout1_1ck280 FIND v(dout1_1) AT=145.025n

.meas tran vdout1_2ck280 FIND v(dout1_2) AT=145.025n

.meas tran vdout1_3ck280 FIND v(dout1_3) AT=145.025n

.meas tran vdout1_4ck280 FIND v(dout1_4) AT=145.025n

.meas tran vdout1_5ck280 FIND v(dout1_5) AT=145.025n

.meas tran vdout1_6ck280 FIND v(dout1_6) AT=145.025n

.meas tran vdout1_7ck280 FIND v(dout1_7) AT=145.025n

.meas tran vdout1_8ck280 FIND v(dout1_8) AT=145.025n

.meas tran vdout1_9ck280 FIND v(dout1_9) AT=145.025n

.meas tran vdout1_10ck280 FIND v(dout1_10) AT=145.025n

.meas tran vdout1_11ck280 FIND v(dout1_11) AT=145.025n

.meas tran vdout1_12ck280 FIND v(dout1_12) AT=145.025n

.meas tran vdout1_13ck280 FIND v(dout1_13) AT=145.025n

.meas tran vdout1_14ck280 FIND v(dout1_14) AT=145.025n

.meas tran vdout1_15ck280 FIND v(dout1_15) AT=145.025n

.meas tran vdout1_16ck280 FIND v(dout1_16) AT=145.025n

.meas tran vdout1_17ck280 FIND v(dout1_17) AT=145.025n

.meas tran vdout1_18ck280 FIND v(dout1_18) AT=145.025n

.meas tran vdout1_19ck280 FIND v(dout1_19) AT=145.025n

.meas tran vdout1_20ck280 FIND v(dout1_20) AT=145.025n

.meas tran vdout1_21ck280 FIND v(dout1_21) AT=145.025n

.meas tran vdout1_22ck280 FIND v(dout1_22) AT=145.025n

.meas tran vdout1_23ck280 FIND v(dout1_23) AT=145.025n

.meas tran vdout1_24ck280 FIND v(dout1_24) AT=145.025n

.meas tran vdout1_25ck280 FIND v(dout1_25) AT=145.025n

.meas tran vdout1_26ck280 FIND v(dout1_26) AT=145.025n

.meas tran vdout1_27ck280 FIND v(dout1_27) AT=145.025n

.meas tran vdout1_28ck280 FIND v(dout1_28) AT=145.025n

.meas tran vdout1_29ck280 FIND v(dout1_29) AT=145.025n

.meas tran vdout1_30ck280 FIND v(dout1_30) AT=145.025n

.meas tran vdout1_31ck280 FIND v(dout1_31) AT=145.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_8ck300 FIND v(dout1_8) AT=155.025n

.meas tran vdout1_9ck300 FIND v(dout1_9) AT=155.025n

.meas tran vdout1_10ck300 FIND v(dout1_10) AT=155.025n

.meas tran vdout1_11ck300 FIND v(dout1_11) AT=155.025n

.meas tran vdout1_12ck300 FIND v(dout1_12) AT=155.025n

.meas tran vdout1_13ck300 FIND v(dout1_13) AT=155.025n

.meas tran vdout1_14ck300 FIND v(dout1_14) AT=155.025n

.meas tran vdout1_15ck300 FIND v(dout1_15) AT=155.025n

.meas tran vdout1_16ck300 FIND v(dout1_16) AT=155.025n

.meas tran vdout1_17ck300 FIND v(dout1_17) AT=155.025n

.meas tran vdout1_18ck300 FIND v(dout1_18) AT=155.025n

.meas tran vdout1_19ck300 FIND v(dout1_19) AT=155.025n

.meas tran vdout1_20ck300 FIND v(dout1_20) AT=155.025n

.meas tran vdout1_21ck300 FIND v(dout1_21) AT=155.025n

.meas tran vdout1_22ck300 FIND v(dout1_22) AT=155.025n

.meas tran vdout1_23ck300 FIND v(dout1_23) AT=155.025n

.meas tran vdout1_24ck300 FIND v(dout1_24) AT=155.025n

.meas tran vdout1_25ck300 FIND v(dout1_25) AT=155.025n

.meas tran vdout1_26ck300 FIND v(dout1_26) AT=155.025n

.meas tran vdout1_27ck300 FIND v(dout1_27) AT=155.025n

.meas tran vdout1_28ck300 FIND v(dout1_28) AT=155.025n

.meas tran vdout1_29ck300 FIND v(dout1_29) AT=155.025n

.meas tran vdout1_30ck300 FIND v(dout1_30) AT=155.025n

.meas tran vdout1_31ck300 FIND v(dout1_31) AT=155.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_23ck310 FIND v(dout1_23) AT=160.025n

.meas tran vdout1_24ck310 FIND v(dout1_24) AT=160.025n

.meas tran vdout1_25ck310 FIND v(dout1_25) AT=160.025n

.meas tran vdout1_26ck310 FIND v(dout1_26) AT=160.025n

.meas tran vdout1_27ck310 FIND v(dout1_27) AT=160.025n

.meas tran vdout1_28ck310 FIND v(dout1_28) AT=160.025n

.meas tran vdout1_29ck310 FIND v(dout1_29) AT=160.025n

.meas tran vdout1_30ck310 FIND v(dout1_30) AT=160.025n

.meas tran vdout1_31ck310 FIND v(dout1_31) AT=160.025n

.meas tran vdout1_0ck320 FIND v(dout1_0) AT=165.025n

.meas tran vdout1_1ck320 FIND v(dout1_1) AT=165.025n

.meas tran vdout1_2ck320 FIND v(dout1_2) AT=165.025n

.meas tran vdout1_3ck320 FIND v(dout1_3) AT=165.025n

.meas tran vdout1_4ck320 FIND v(dout1_4) AT=165.025n

.meas tran vdout1_5ck320 FIND v(dout1_5) AT=165.025n

.meas tran vdout1_6ck320 FIND v(dout1_6) AT=165.025n

.meas tran vdout1_7ck320 FIND v(dout1_7) AT=165.025n

.meas tran vdout1_8ck320 FIND v(dout1_8) AT=165.025n

.meas tran vdout1_9ck320 FIND v(dout1_9) AT=165.025n

.meas tran vdout1_10ck320 FIND v(dout1_10) AT=165.025n

.meas tran vdout1_11ck320 FIND v(dout1_11) AT=165.025n

.meas tran vdout1_12ck320 FIND v(dout1_12) AT=165.025n

.meas tran vdout1_13ck320 FIND v(dout1_13) AT=165.025n

.meas tran vdout1_14ck320 FIND v(dout1_14) AT=165.025n

.meas tran vdout1_15ck320 FIND v(dout1_15) AT=165.025n

.meas tran vdout1_16ck320 FIND v(dout1_16) AT=165.025n

.meas tran vdout1_17ck320 FIND v(dout1_17) AT=165.025n

.meas tran vdout1_18ck320 FIND v(dout1_18) AT=165.025n

.meas tran vdout1_19ck320 FIND v(dout1_19) AT=165.025n

.meas tran vdout1_20ck320 FIND v(dout1_20) AT=165.025n

.meas tran vdout1_21ck320 FIND v(dout1_21) AT=165.025n

.meas tran vdout1_22ck320 FIND v(dout1_22) AT=165.025n

.meas tran vdout1_23ck320 FIND v(dout1_23) AT=165.025n

.meas tran vdout1_24ck320 FIND v(dout1_24) AT=165.025n

.meas tran vdout1_25ck320 FIND v(dout1_25) AT=165.025n

.meas tran vdout1_26ck320 FIND v(dout1_26) AT=165.025n

.meas tran vdout1_27ck320 FIND v(dout1_27) AT=165.025n

.meas tran vdout1_28ck320 FIND v(dout1_28) AT=165.025n

.meas tran vdout1_29ck320 FIND v(dout1_29) AT=165.025n

.meas tran vdout1_30ck320 FIND v(dout1_30) AT=165.025n

.meas tran vdout1_31ck320 FIND v(dout1_31) AT=165.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_8ck340 FIND v(dout1_8) AT=175.025n

.meas tran vdout1_9ck340 FIND v(dout1_9) AT=175.025n

.meas tran vdout1_10ck340 FIND v(dout1_10) AT=175.025n

.meas tran vdout1_11ck340 FIND v(dout1_11) AT=175.025n

.meas tran vdout1_12ck340 FIND v(dout1_12) AT=175.025n

.meas tran vdout1_13ck340 FIND v(dout1_13) AT=175.025n

.meas tran vdout1_14ck340 FIND v(dout1_14) AT=175.025n

.meas tran vdout1_15ck340 FIND v(dout1_15) AT=175.025n

.meas tran vdout1_16ck340 FIND v(dout1_16) AT=175.025n

.meas tran vdout1_17ck340 FIND v(dout1_17) AT=175.025n

.meas tran vdout1_18ck340 FIND v(dout1_18) AT=175.025n

.meas tran vdout1_19ck340 FIND v(dout1_19) AT=175.025n

.meas tran vdout1_20ck340 FIND v(dout1_20) AT=175.025n

.meas tran vdout1_21ck340 FIND v(dout1_21) AT=175.025n

.meas tran vdout1_22ck340 FIND v(dout1_22) AT=175.025n

.meas tran vdout1_23ck340 FIND v(dout1_23) AT=175.025n

.meas tran vdout1_24ck340 FIND v(dout1_24) AT=175.025n

.meas tran vdout1_25ck340 FIND v(dout1_25) AT=175.025n

.meas tran vdout1_26ck340 FIND v(dout1_26) AT=175.025n

.meas tran vdout1_27ck340 FIND v(dout1_27) AT=175.025n

.meas tran vdout1_28ck340 FIND v(dout1_28) AT=175.025n

.meas tran vdout1_29ck340 FIND v(dout1_29) AT=175.025n

.meas tran vdout1_30ck340 FIND v(dout1_30) AT=175.025n

.meas tran vdout1_31ck340 FIND v(dout1_31) AT=175.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_22ck350 FIND v(dout1_22) AT=180.025n

.meas tran vdout1_23ck350 FIND v(dout1_23) AT=180.025n

.meas tran vdout1_24ck350 FIND v(dout1_24) AT=180.025n

.meas tran vdout1_25ck350 FIND v(dout1_25) AT=180.025n

.meas tran vdout1_26ck350 FIND v(dout1_26) AT=180.025n

.meas tran vdout1_27ck350 FIND v(dout1_27) AT=180.025n

.meas tran vdout1_28ck350 FIND v(dout1_28) AT=180.025n

.meas tran vdout1_29ck350 FIND v(dout1_29) AT=180.025n

.meas tran vdout1_30ck350 FIND v(dout1_30) AT=180.025n

.meas tran vdout1_31ck350 FIND v(dout1_31) AT=180.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_19ck420 FIND v(dout1_19) AT=215.025n

.meas tran vdout1_20ck420 FIND v(dout1_20) AT=215.025n

.meas tran vdout1_21ck420 FIND v(dout1_21) AT=215.025n

.meas tran vdout1_22ck420 FIND v(dout1_22) AT=215.025n

.meas tran vdout1_23ck420 FIND v(dout1_23) AT=215.025n

.meas tran vdout1_24ck420 FIND v(dout1_24) AT=215.025n

.meas tran vdout1_25ck420 FIND v(dout1_25) AT=215.025n

.meas tran vdout1_26ck420 FIND v(dout1_26) AT=215.025n

.meas tran vdout1_27ck420 FIND v(dout1_27) AT=215.025n

.meas tran vdout1_28ck420 FIND v(dout1_28) AT=215.025n

.meas tran vdout1_29ck420 FIND v(dout1_29) AT=215.025n

.meas tran vdout1_30ck420 FIND v(dout1_30) AT=215.025n

.meas tran vdout1_31ck420 FIND v(dout1_31) AT=215.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_16ck440 FIND v(dout1_16) AT=225.025n

.meas tran vdout1_17ck440 FIND v(dout1_17) AT=225.025n

.meas tran vdout1_18ck440 FIND v(dout1_18) AT=225.025n

.meas tran vdout1_19ck440 FIND v(dout1_19) AT=225.025n

.meas tran vdout1_20ck440 FIND v(dout1_20) AT=225.025n

.meas tran vdout1_21ck440 FIND v(dout1_21) AT=225.025n

.meas tran vdout1_22ck440 FIND v(dout1_22) AT=225.025n

.meas tran vdout1_23ck440 FIND v(dout1_23) AT=225.025n

.meas tran vdout1_24ck440 FIND v(dout1_24) AT=225.025n

.meas tran vdout1_25ck440 FIND v(dout1_25) AT=225.025n

.meas tran vdout1_26ck440 FIND v(dout1_26) AT=225.025n

.meas tran vdout1_27ck440 FIND v(dout1_27) AT=225.025n

.meas tran vdout1_28ck440 FIND v(dout1_28) AT=225.025n

.meas tran vdout1_29ck440 FIND v(dout1_29) AT=225.025n

.meas tran vdout1_30ck440 FIND v(dout1_30) AT=225.025n

.meas tran vdout1_31ck440 FIND v(dout1_31) AT=225.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_0ck500 FIND v(dout1_0) AT=255.025n

.meas tran vdout1_1ck500 FIND v(dout1_1) AT=255.025n

.meas tran vdout1_2ck500 FIND v(dout1_2) AT=255.025n

.meas tran vdout1_3ck500 FIND v(dout1_3) AT=255.025n

.meas tran vdout1_4ck500 FIND v(dout1_4) AT=255.025n

.meas tran vdout1_5ck500 FIND v(dout1_5) AT=255.025n

.meas tran vdout1_6ck500 FIND v(dout1_6) AT=255.025n

.meas tran vdout1_7ck500 FIND v(dout1_7) AT=255.025n

.meas tran vdout1_8ck500 FIND v(dout1_8) AT=255.025n

.meas tran vdout1_9ck500 FIND v(dout1_9) AT=255.025n

.meas tran vdout1_10ck500 FIND v(dout1_10) AT=255.025n

.meas tran vdout1_11ck500 FIND v(dout1_11) AT=255.025n

.meas tran vdout1_12ck500 FIND v(dout1_12) AT=255.025n

.meas tran vdout1_13ck500 FIND v(dout1_13) AT=255.025n

.meas tran vdout1_14ck500 FIND v(dout1_14) AT=255.025n

.meas tran vdout1_15ck500 FIND v(dout1_15) AT=255.025n

.meas tran vdout1_16ck500 FIND v(dout1_16) AT=255.025n

.meas tran vdout1_17ck500 FIND v(dout1_17) AT=255.025n

.meas tran vdout1_18ck500 FIND v(dout1_18) AT=255.025n

.meas tran vdout1_19ck500 FIND v(dout1_19) AT=255.025n

.meas tran vdout1_20ck500 FIND v(dout1_20) AT=255.025n

.meas tran vdout1_21ck500 FIND v(dout1_21) AT=255.025n

.meas tran vdout1_22ck500 FIND v(dout1_22) AT=255.025n

.meas tran vdout1_23ck500 FIND v(dout1_23) AT=255.025n

.meas tran vdout1_24ck500 FIND v(dout1_24) AT=255.025n

.meas tran vdout1_25ck500 FIND v(dout1_25) AT=255.025n

.meas tran vdout1_26ck500 FIND v(dout1_26) AT=255.025n

.meas tran vdout1_27ck500 FIND v(dout1_27) AT=255.025n

.meas tran vdout1_28ck500 FIND v(dout1_28) AT=255.025n

.meas tran vdout1_29ck500 FIND v(dout1_29) AT=255.025n

.meas tran vdout1_30ck500 FIND v(dout1_30) AT=255.025n

.meas tran vdout1_31ck500 FIND v(dout1_31) AT=255.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_8ck520 FIND v(dout1_8) AT=265.025n

.meas tran vdout1_9ck520 FIND v(dout1_9) AT=265.025n

.meas tran vdout1_10ck520 FIND v(dout1_10) AT=265.025n

.meas tran vdout1_11ck520 FIND v(dout1_11) AT=265.025n

.meas tran vdout1_12ck520 FIND v(dout1_12) AT=265.025n

.meas tran vdout1_13ck520 FIND v(dout1_13) AT=265.025n

.meas tran vdout1_14ck520 FIND v(dout1_14) AT=265.025n

.meas tran vdout1_15ck520 FIND v(dout1_15) AT=265.025n

.meas tran vdout1_16ck520 FIND v(dout1_16) AT=265.025n

.meas tran vdout1_17ck520 FIND v(dout1_17) AT=265.025n

.meas tran vdout1_18ck520 FIND v(dout1_18) AT=265.025n

.meas tran vdout1_19ck520 FIND v(dout1_19) AT=265.025n

.meas tran vdout1_20ck520 FIND v(dout1_20) AT=265.025n

.meas tran vdout1_21ck520 FIND v(dout1_21) AT=265.025n

.meas tran vdout1_22ck520 FIND v(dout1_22) AT=265.025n

.meas tran vdout1_23ck520 FIND v(dout1_23) AT=265.025n

.meas tran vdout1_24ck520 FIND v(dout1_24) AT=265.025n

.meas tran vdout1_25ck520 FIND v(dout1_25) AT=265.025n

.meas tran vdout1_26ck520 FIND v(dout1_26) AT=265.025n

.meas tran vdout1_27ck520 FIND v(dout1_27) AT=265.025n

.meas tran vdout1_28ck520 FIND v(dout1_28) AT=265.025n

.meas tran vdout1_29ck520 FIND v(dout1_29) AT=265.025n

.meas tran vdout1_30ck520 FIND v(dout1_30) AT=265.025n

.meas tran vdout1_31ck520 FIND v(dout1_31) AT=265.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_16ck550 FIND v(dout1_16) AT=280.025n

.meas tran vdout1_17ck550 FIND v(dout1_17) AT=280.025n

.meas tran vdout1_18ck550 FIND v(dout1_18) AT=280.025n

.meas tran vdout1_19ck550 FIND v(dout1_19) AT=280.025n

.meas tran vdout1_20ck550 FIND v(dout1_20) AT=280.025n

.meas tran vdout1_21ck550 FIND v(dout1_21) AT=280.025n

.meas tran vdout1_22ck550 FIND v(dout1_22) AT=280.025n

.meas tran vdout1_23ck550 FIND v(dout1_23) AT=280.025n

.meas tran vdout1_24ck550 FIND v(dout1_24) AT=280.025n

.meas tran vdout1_25ck550 FIND v(dout1_25) AT=280.025n

.meas tran vdout1_26ck550 FIND v(dout1_26) AT=280.025n

.meas tran vdout1_27ck550 FIND v(dout1_27) AT=280.025n

.meas tran vdout1_28ck550 FIND v(dout1_28) AT=280.025n

.meas tran vdout1_29ck550 FIND v(dout1_29) AT=280.025n

.meas tran vdout1_30ck550 FIND v(dout1_30) AT=280.025n

.meas tran vdout1_31ck550 FIND v(dout1_31) AT=280.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_22ck570 FIND v(dout1_22) AT=290.025n

.meas tran vdout1_23ck570 FIND v(dout1_23) AT=290.025n

.meas tran vdout1_24ck570 FIND v(dout1_24) AT=290.025n

.meas tran vdout1_25ck570 FIND v(dout1_25) AT=290.025n

.meas tran vdout1_26ck570 FIND v(dout1_26) AT=290.025n

.meas tran vdout1_27ck570 FIND v(dout1_27) AT=290.025n

.meas tran vdout1_28ck570 FIND v(dout1_28) AT=290.025n

.meas tran vdout1_29ck570 FIND v(dout1_29) AT=290.025n

.meas tran vdout1_30ck570 FIND v(dout1_30) AT=290.025n

.meas tran vdout1_31ck570 FIND v(dout1_31) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_23ck580 FIND v(dout1_23) AT=295.025n

.meas tran vdout1_24ck580 FIND v(dout1_24) AT=295.025n

.meas tran vdout1_25ck580 FIND v(dout1_25) AT=295.025n

.meas tran vdout1_26ck580 FIND v(dout1_26) AT=295.025n

.meas tran vdout1_27ck580 FIND v(dout1_27) AT=295.025n

.meas tran vdout1_28ck580 FIND v(dout1_28) AT=295.025n

.meas tran vdout1_29ck580 FIND v(dout1_29) AT=295.025n

.meas tran vdout1_30ck580 FIND v(dout1_30) AT=295.025n

.meas tran vdout1_31ck580 FIND v(dout1_31) AT=295.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_17ck590 FIND v(dout1_17) AT=300.025n

.meas tran vdout1_18ck590 FIND v(dout1_18) AT=300.025n

.meas tran vdout1_19ck590 FIND v(dout1_19) AT=300.025n

.meas tran vdout1_20ck590 FIND v(dout1_20) AT=300.025n

.meas tran vdout1_21ck590 FIND v(dout1_21) AT=300.025n

.meas tran vdout1_22ck590 FIND v(dout1_22) AT=300.025n

.meas tran vdout1_23ck590 FIND v(dout1_23) AT=300.025n

.meas tran vdout1_24ck590 FIND v(dout1_24) AT=300.025n

.meas tran vdout1_25ck590 FIND v(dout1_25) AT=300.025n

.meas tran vdout1_26ck590 FIND v(dout1_26) AT=300.025n

.meas tran vdout1_27ck590 FIND v(dout1_27) AT=300.025n

.meas tran vdout1_28ck590 FIND v(dout1_28) AT=300.025n

.meas tran vdout1_29ck590 FIND v(dout1_29) AT=300.025n

.meas tran vdout1_30ck590 FIND v(dout1_30) AT=300.025n

.meas tran vdout1_31ck590 FIND v(dout1_31) AT=300.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_22ck610 FIND v(dout1_22) AT=310.025n

.meas tran vdout1_23ck610 FIND v(dout1_23) AT=310.025n

.meas tran vdout1_24ck610 FIND v(dout1_24) AT=310.025n

.meas tran vdout1_25ck610 FIND v(dout1_25) AT=310.025n

.meas tran vdout1_26ck610 FIND v(dout1_26) AT=310.025n

.meas tran vdout1_27ck610 FIND v(dout1_27) AT=310.025n

.meas tran vdout1_28ck610 FIND v(dout1_28) AT=310.025n

.meas tran vdout1_29ck610 FIND v(dout1_29) AT=310.025n

.meas tran vdout1_30ck610 FIND v(dout1_30) AT=310.025n

.meas tran vdout1_31ck610 FIND v(dout1_31) AT=310.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_8ck630 FIND v(dout1_8) AT=320.025n

.meas tran vdout1_9ck630 FIND v(dout1_9) AT=320.025n

.meas tran vdout1_10ck630 FIND v(dout1_10) AT=320.025n

.meas tran vdout1_11ck630 FIND v(dout1_11) AT=320.025n

.meas tran vdout1_12ck630 FIND v(dout1_12) AT=320.025n

.meas tran vdout1_13ck630 FIND v(dout1_13) AT=320.025n

.meas tran vdout1_14ck630 FIND v(dout1_14) AT=320.025n

.meas tran vdout1_15ck630 FIND v(dout1_15) AT=320.025n

.meas tran vdout1_16ck630 FIND v(dout1_16) AT=320.025n

.meas tran vdout1_17ck630 FIND v(dout1_17) AT=320.025n

.meas tran vdout1_18ck630 FIND v(dout1_18) AT=320.025n

.meas tran vdout1_19ck630 FIND v(dout1_19) AT=320.025n

.meas tran vdout1_20ck630 FIND v(dout1_20) AT=320.025n

.meas tran vdout1_21ck630 FIND v(dout1_21) AT=320.025n

.meas tran vdout1_22ck630 FIND v(dout1_22) AT=320.025n

.meas tran vdout1_23ck630 FIND v(dout1_23) AT=320.025n

.meas tran vdout1_24ck630 FIND v(dout1_24) AT=320.025n

.meas tran vdout1_25ck630 FIND v(dout1_25) AT=320.025n

.meas tran vdout1_26ck630 FIND v(dout1_26) AT=320.025n

.meas tran vdout1_27ck630 FIND v(dout1_27) AT=320.025n

.meas tran vdout1_28ck630 FIND v(dout1_28) AT=320.025n

.meas tran vdout1_29ck630 FIND v(dout1_29) AT=320.025n

.meas tran vdout1_30ck630 FIND v(dout1_30) AT=320.025n

.meas tran vdout1_31ck630 FIND v(dout1_31) AT=320.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_22ck660 FIND v(dout1_22) AT=335.025n

.meas tran vdout1_23ck660 FIND v(dout1_23) AT=335.025n

.meas tran vdout1_24ck660 FIND v(dout1_24) AT=335.025n

.meas tran vdout1_25ck660 FIND v(dout1_25) AT=335.025n

.meas tran vdout1_26ck660 FIND v(dout1_26) AT=335.025n

.meas tran vdout1_27ck660 FIND v(dout1_27) AT=335.025n

.meas tran vdout1_28ck660 FIND v(dout1_28) AT=335.025n

.meas tran vdout1_29ck660 FIND v(dout1_29) AT=335.025n

.meas tran vdout1_30ck660 FIND v(dout1_30) AT=335.025n

.meas tran vdout1_31ck660 FIND v(dout1_31) AT=335.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_19ck680 FIND v(dout1_19) AT=345.025n

.meas tran vdout1_20ck680 FIND v(dout1_20) AT=345.025n

.meas tran vdout1_21ck680 FIND v(dout1_21) AT=345.025n

.meas tran vdout1_22ck680 FIND v(dout1_22) AT=345.025n

.meas tran vdout1_23ck680 FIND v(dout1_23) AT=345.025n

.meas tran vdout1_24ck680 FIND v(dout1_24) AT=345.025n

.meas tran vdout1_25ck680 FIND v(dout1_25) AT=345.025n

.meas tran vdout1_26ck680 FIND v(dout1_26) AT=345.025n

.meas tran vdout1_27ck680 FIND v(dout1_27) AT=345.025n

.meas tran vdout1_28ck680 FIND v(dout1_28) AT=345.025n

.meas tran vdout1_29ck680 FIND v(dout1_29) AT=345.025n

.meas tran vdout1_30ck680 FIND v(dout1_30) AT=345.025n

.meas tran vdout1_31ck680 FIND v(dout1_31) AT=345.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_22ck720 FIND v(dout1_22) AT=365.025n

.meas tran vdout1_23ck720 FIND v(dout1_23) AT=365.025n

.meas tran vdout1_24ck720 FIND v(dout1_24) AT=365.025n

.meas tran vdout1_25ck720 FIND v(dout1_25) AT=365.025n

.meas tran vdout1_26ck720 FIND v(dout1_26) AT=365.025n

.meas tran vdout1_27ck720 FIND v(dout1_27) AT=365.025n

.meas tran vdout1_28ck720 FIND v(dout1_28) AT=365.025n

.meas tran vdout1_29ck720 FIND v(dout1_29) AT=365.025n

.meas tran vdout1_30ck720 FIND v(dout1_30) AT=365.025n

.meas tran vdout1_31ck720 FIND v(dout1_31) AT=365.025n

.meas tran vdout1_0ck750 FIND v(dout1_0) AT=380.025n

.meas tran vdout1_1ck750 FIND v(dout1_1) AT=380.025n

.meas tran vdout1_2ck750 FIND v(dout1_2) AT=380.025n

.meas tran vdout1_3ck750 FIND v(dout1_3) AT=380.025n

.meas tran vdout1_4ck750 FIND v(dout1_4) AT=380.025n

.meas tran vdout1_5ck750 FIND v(dout1_5) AT=380.025n

.meas tran vdout1_6ck750 FIND v(dout1_6) AT=380.025n

.meas tran vdout1_7ck750 FIND v(dout1_7) AT=380.025n

.meas tran vdout1_8ck750 FIND v(dout1_8) AT=380.025n

.meas tran vdout1_9ck750 FIND v(dout1_9) AT=380.025n

.meas tran vdout1_10ck750 FIND v(dout1_10) AT=380.025n

.meas tran vdout1_11ck750 FIND v(dout1_11) AT=380.025n

.meas tran vdout1_12ck750 FIND v(dout1_12) AT=380.025n

.meas tran vdout1_13ck750 FIND v(dout1_13) AT=380.025n

.meas tran vdout1_14ck750 FIND v(dout1_14) AT=380.025n

.meas tran vdout1_15ck750 FIND v(dout1_15) AT=380.025n

.meas tran vdout1_16ck750 FIND v(dout1_16) AT=380.025n

.meas tran vdout1_17ck750 FIND v(dout1_17) AT=380.025n

.meas tran vdout1_18ck750 FIND v(dout1_18) AT=380.025n

.meas tran vdout1_19ck750 FIND v(dout1_19) AT=380.025n

.meas tran vdout1_20ck750 FIND v(dout1_20) AT=380.025n

.meas tran vdout1_21ck750 FIND v(dout1_21) AT=380.025n

.meas tran vdout1_22ck750 FIND v(dout1_22) AT=380.025n

.meas tran vdout1_23ck750 FIND v(dout1_23) AT=380.025n

.meas tran vdout1_24ck750 FIND v(dout1_24) AT=380.025n

.meas tran vdout1_25ck750 FIND v(dout1_25) AT=380.025n

.meas tran vdout1_26ck750 FIND v(dout1_26) AT=380.025n

.meas tran vdout1_27ck750 FIND v(dout1_27) AT=380.025n

.meas tran vdout1_28ck750 FIND v(dout1_28) AT=380.025n

.meas tran vdout1_29ck750 FIND v(dout1_29) AT=380.025n

.meas tran vdout1_30ck750 FIND v(dout1_30) AT=380.025n

.meas tran vdout1_31ck750 FIND v(dout1_31) AT=380.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_23ck770 FIND v(dout1_23) AT=390.025n

.meas tran vdout1_24ck770 FIND v(dout1_24) AT=390.025n

.meas tran vdout1_25ck770 FIND v(dout1_25) AT=390.025n

.meas tran vdout1_26ck770 FIND v(dout1_26) AT=390.025n

.meas tran vdout1_27ck770 FIND v(dout1_27) AT=390.025n

.meas tran vdout1_28ck770 FIND v(dout1_28) AT=390.025n

.meas tran vdout1_29ck770 FIND v(dout1_29) AT=390.025n

.meas tran vdout1_30ck770 FIND v(dout1_30) AT=390.025n

.meas tran vdout1_31ck770 FIND v(dout1_31) AT=390.025n

.meas tran vdout1_0ck790 FIND v(dout1_0) AT=400.025n

.meas tran vdout1_1ck790 FIND v(dout1_1) AT=400.025n

.meas tran vdout1_2ck790 FIND v(dout1_2) AT=400.025n

.meas tran vdout1_3ck790 FIND v(dout1_3) AT=400.025n

.meas tran vdout1_4ck790 FIND v(dout1_4) AT=400.025n

.meas tran vdout1_5ck790 FIND v(dout1_5) AT=400.025n

.meas tran vdout1_6ck790 FIND v(dout1_6) AT=400.025n

.meas tran vdout1_7ck790 FIND v(dout1_7) AT=400.025n

.meas tran vdout1_8ck790 FIND v(dout1_8) AT=400.025n

.meas tran vdout1_9ck790 FIND v(dout1_9) AT=400.025n

.meas tran vdout1_10ck790 FIND v(dout1_10) AT=400.025n

.meas tran vdout1_11ck790 FIND v(dout1_11) AT=400.025n

.meas tran vdout1_12ck790 FIND v(dout1_12) AT=400.025n

.meas tran vdout1_13ck790 FIND v(dout1_13) AT=400.025n

.meas tran vdout1_14ck790 FIND v(dout1_14) AT=400.025n

.meas tran vdout1_15ck790 FIND v(dout1_15) AT=400.025n

.meas tran vdout1_16ck790 FIND v(dout1_16) AT=400.025n

.meas tran vdout1_17ck790 FIND v(dout1_17) AT=400.025n

.meas tran vdout1_18ck790 FIND v(dout1_18) AT=400.025n

.meas tran vdout1_19ck790 FIND v(dout1_19) AT=400.025n

.meas tran vdout1_20ck790 FIND v(dout1_20) AT=400.025n

.meas tran vdout1_21ck790 FIND v(dout1_21) AT=400.025n

.meas tran vdout1_22ck790 FIND v(dout1_22) AT=400.025n

.meas tran vdout1_23ck790 FIND v(dout1_23) AT=400.025n

.meas tran vdout1_24ck790 FIND v(dout1_24) AT=400.025n

.meas tran vdout1_25ck790 FIND v(dout1_25) AT=400.025n

.meas tran vdout1_26ck790 FIND v(dout1_26) AT=400.025n

.meas tran vdout1_27ck790 FIND v(dout1_27) AT=400.025n

.meas tran vdout1_28ck790 FIND v(dout1_28) AT=400.025n

.meas tran vdout1_29ck790 FIND v(dout1_29) AT=400.025n

.meas tran vdout1_30ck790 FIND v(dout1_30) AT=400.025n

.meas tran vdout1_31ck790 FIND v(dout1_31) AT=400.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_0ck870 FIND v(dout1_0) AT=440.025n

.meas tran vdout1_1ck870 FIND v(dout1_1) AT=440.025n

.meas tran vdout1_2ck870 FIND v(dout1_2) AT=440.025n

.meas tran vdout1_3ck870 FIND v(dout1_3) AT=440.025n

.meas tran vdout1_4ck870 FIND v(dout1_4) AT=440.025n

.meas tran vdout1_5ck870 FIND v(dout1_5) AT=440.025n

.meas tran vdout1_6ck870 FIND v(dout1_6) AT=440.025n

.meas tran vdout1_7ck870 FIND v(dout1_7) AT=440.025n

.meas tran vdout1_8ck870 FIND v(dout1_8) AT=440.025n

.meas tran vdout1_9ck870 FIND v(dout1_9) AT=440.025n

.meas tran vdout1_10ck870 FIND v(dout1_10) AT=440.025n

.meas tran vdout1_11ck870 FIND v(dout1_11) AT=440.025n

.meas tran vdout1_12ck870 FIND v(dout1_12) AT=440.025n

.meas tran vdout1_13ck870 FIND v(dout1_13) AT=440.025n

.meas tran vdout1_14ck870 FIND v(dout1_14) AT=440.025n

.meas tran vdout1_15ck870 FIND v(dout1_15) AT=440.025n

.meas tran vdout1_16ck870 FIND v(dout1_16) AT=440.025n

.meas tran vdout1_17ck870 FIND v(dout1_17) AT=440.025n

.meas tran vdout1_18ck870 FIND v(dout1_18) AT=440.025n

.meas tran vdout1_19ck870 FIND v(dout1_19) AT=440.025n

.meas tran vdout1_20ck870 FIND v(dout1_20) AT=440.025n

.meas tran vdout1_21ck870 FIND v(dout1_21) AT=440.025n

.meas tran vdout1_22ck870 FIND v(dout1_22) AT=440.025n

.meas tran vdout1_23ck870 FIND v(dout1_23) AT=440.025n

.meas tran vdout1_24ck870 FIND v(dout1_24) AT=440.025n

.meas tran vdout1_25ck870 FIND v(dout1_25) AT=440.025n

.meas tran vdout1_26ck870 FIND v(dout1_26) AT=440.025n

.meas tran vdout1_27ck870 FIND v(dout1_27) AT=440.025n

.meas tran vdout1_28ck870 FIND v(dout1_28) AT=440.025n

.meas tran vdout1_29ck870 FIND v(dout1_29) AT=440.025n

.meas tran vdout1_30ck870 FIND v(dout1_30) AT=440.025n

.meas tran vdout1_31ck870 FIND v(dout1_31) AT=440.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_19ck1080 FIND v(dout1_19) AT=545.025n

.meas tran vdout1_20ck1080 FIND v(dout1_20) AT=545.025n

.meas tran vdout1_21ck1080 FIND v(dout1_21) AT=545.025n

.meas tran vdout1_22ck1080 FIND v(dout1_22) AT=545.025n

.meas tran vdout1_23ck1080 FIND v(dout1_23) AT=545.025n

.meas tran vdout1_24ck1080 FIND v(dout1_24) AT=545.025n

.meas tran vdout1_25ck1080 FIND v(dout1_25) AT=545.025n

.meas tran vdout1_26ck1080 FIND v(dout1_26) AT=545.025n

.meas tran vdout1_27ck1080 FIND v(dout1_27) AT=545.025n

.meas tran vdout1_28ck1080 FIND v(dout1_28) AT=545.025n

.meas tran vdout1_29ck1080 FIND v(dout1_29) AT=545.025n

.meas tran vdout1_30ck1080 FIND v(dout1_30) AT=545.025n

.meas tran vdout1_31ck1080 FIND v(dout1_31) AT=545.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_23ck1090 FIND v(dout1_23) AT=550.025n

.meas tran vdout1_24ck1090 FIND v(dout1_24) AT=550.025n

.meas tran vdout1_25ck1090 FIND v(dout1_25) AT=550.025n

.meas tran vdout1_26ck1090 FIND v(dout1_26) AT=550.025n

.meas tran vdout1_27ck1090 FIND v(dout1_27) AT=550.025n

.meas tran vdout1_28ck1090 FIND v(dout1_28) AT=550.025n

.meas tran vdout1_29ck1090 FIND v(dout1_29) AT=550.025n

.meas tran vdout1_30ck1090 FIND v(dout1_30) AT=550.025n

.meas tran vdout1_31ck1090 FIND v(dout1_31) AT=550.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_22ck1100 FIND v(dout1_22) AT=555.025n

.meas tran vdout1_23ck1100 FIND v(dout1_23) AT=555.025n

.meas tran vdout1_24ck1100 FIND v(dout1_24) AT=555.025n

.meas tran vdout1_25ck1100 FIND v(dout1_25) AT=555.025n

.meas tran vdout1_26ck1100 FIND v(dout1_26) AT=555.025n

.meas tran vdout1_27ck1100 FIND v(dout1_27) AT=555.025n

.meas tran vdout1_28ck1100 FIND v(dout1_28) AT=555.025n

.meas tran vdout1_29ck1100 FIND v(dout1_29) AT=555.025n

.meas tran vdout1_30ck1100 FIND v(dout1_30) AT=555.025n

.meas tran vdout1_31ck1100 FIND v(dout1_31) AT=555.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_19ck1110 FIND v(dout1_19) AT=560.025n

.meas tran vdout1_20ck1110 FIND v(dout1_20) AT=560.025n

.meas tran vdout1_21ck1110 FIND v(dout1_21) AT=560.025n

.meas tran vdout1_22ck1110 FIND v(dout1_22) AT=560.025n

.meas tran vdout1_23ck1110 FIND v(dout1_23) AT=560.025n

.meas tran vdout1_24ck1110 FIND v(dout1_24) AT=560.025n

.meas tran vdout1_25ck1110 FIND v(dout1_25) AT=560.025n

.meas tran vdout1_26ck1110 FIND v(dout1_26) AT=560.025n

.meas tran vdout1_27ck1110 FIND v(dout1_27) AT=560.025n

.meas tran vdout1_28ck1110 FIND v(dout1_28) AT=560.025n

.meas tran vdout1_29ck1110 FIND v(dout1_29) AT=560.025n

.meas tran vdout1_30ck1110 FIND v(dout1_30) AT=560.025n

.meas tran vdout1_31ck1110 FIND v(dout1_31) AT=560.025n

.meas tran vdout1_0ck1140 FIND v(dout1_0) AT=575.025n

.meas tran vdout1_1ck1140 FIND v(dout1_1) AT=575.025n

.meas tran vdout1_2ck1140 FIND v(dout1_2) AT=575.025n

.meas tran vdout1_3ck1140 FIND v(dout1_3) AT=575.025n

.meas tran vdout1_4ck1140 FIND v(dout1_4) AT=575.025n

.meas tran vdout1_5ck1140 FIND v(dout1_5) AT=575.025n

.meas tran vdout1_6ck1140 FIND v(dout1_6) AT=575.025n

.meas tran vdout1_7ck1140 FIND v(dout1_7) AT=575.025n

.meas tran vdout1_8ck1140 FIND v(dout1_8) AT=575.025n

.meas tran vdout1_9ck1140 FIND v(dout1_9) AT=575.025n

.meas tran vdout1_10ck1140 FIND v(dout1_10) AT=575.025n

.meas tran vdout1_11ck1140 FIND v(dout1_11) AT=575.025n

.meas tran vdout1_12ck1140 FIND v(dout1_12) AT=575.025n

.meas tran vdout1_13ck1140 FIND v(dout1_13) AT=575.025n

.meas tran vdout1_14ck1140 FIND v(dout1_14) AT=575.025n

.meas tran vdout1_15ck1140 FIND v(dout1_15) AT=575.025n

.meas tran vdout1_16ck1140 FIND v(dout1_16) AT=575.025n

.meas tran vdout1_17ck1140 FIND v(dout1_17) AT=575.025n

.meas tran vdout1_18ck1140 FIND v(dout1_18) AT=575.025n

.meas tran vdout1_19ck1140 FIND v(dout1_19) AT=575.025n

.meas tran vdout1_20ck1140 FIND v(dout1_20) AT=575.025n

.meas tran vdout1_21ck1140 FIND v(dout1_21) AT=575.025n

.meas tran vdout1_22ck1140 FIND v(dout1_22) AT=575.025n

.meas tran vdout1_23ck1140 FIND v(dout1_23) AT=575.025n

.meas tran vdout1_24ck1140 FIND v(dout1_24) AT=575.025n

.meas tran vdout1_25ck1140 FIND v(dout1_25) AT=575.025n

.meas tran vdout1_26ck1140 FIND v(dout1_26) AT=575.025n

.meas tran vdout1_27ck1140 FIND v(dout1_27) AT=575.025n

.meas tran vdout1_28ck1140 FIND v(dout1_28) AT=575.025n

.meas tran vdout1_29ck1140 FIND v(dout1_29) AT=575.025n

.meas tran vdout1_30ck1140 FIND v(dout1_30) AT=575.025n

.meas tran vdout1_31ck1140 FIND v(dout1_31) AT=575.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_17ck1160 FIND v(dout1_17) AT=585.025n

.meas tran vdout1_18ck1160 FIND v(dout1_18) AT=585.025n

.meas tran vdout1_19ck1160 FIND v(dout1_19) AT=585.025n

.meas tran vdout1_20ck1160 FIND v(dout1_20) AT=585.025n

.meas tran vdout1_21ck1160 FIND v(dout1_21) AT=585.025n

.meas tran vdout1_22ck1160 FIND v(dout1_22) AT=585.025n

.meas tran vdout1_23ck1160 FIND v(dout1_23) AT=585.025n

.meas tran vdout1_24ck1160 FIND v(dout1_24) AT=585.025n

.meas tran vdout1_25ck1160 FIND v(dout1_25) AT=585.025n

.meas tran vdout1_26ck1160 FIND v(dout1_26) AT=585.025n

.meas tran vdout1_27ck1160 FIND v(dout1_27) AT=585.025n

.meas tran vdout1_28ck1160 FIND v(dout1_28) AT=585.025n

.meas tran vdout1_29ck1160 FIND v(dout1_29) AT=585.025n

.meas tran vdout1_30ck1160 FIND v(dout1_30) AT=585.025n

.meas tran vdout1_31ck1160 FIND v(dout1_31) AT=585.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_16ck1170 FIND v(dout1_16) AT=590.025n

.meas tran vdout1_17ck1170 FIND v(dout1_17) AT=590.025n

.meas tran vdout1_18ck1170 FIND v(dout1_18) AT=590.025n

.meas tran vdout1_19ck1170 FIND v(dout1_19) AT=590.025n

.meas tran vdout1_20ck1170 FIND v(dout1_20) AT=590.025n

.meas tran vdout1_21ck1170 FIND v(dout1_21) AT=590.025n

.meas tran vdout1_22ck1170 FIND v(dout1_22) AT=590.025n

.meas tran vdout1_23ck1170 FIND v(dout1_23) AT=590.025n

.meas tran vdout1_24ck1170 FIND v(dout1_24) AT=590.025n

.meas tran vdout1_25ck1170 FIND v(dout1_25) AT=590.025n

.meas tran vdout1_26ck1170 FIND v(dout1_26) AT=590.025n

.meas tran vdout1_27ck1170 FIND v(dout1_27) AT=590.025n

.meas tran vdout1_28ck1170 FIND v(dout1_28) AT=590.025n

.meas tran vdout1_29ck1170 FIND v(dout1_29) AT=590.025n

.meas tran vdout1_30ck1170 FIND v(dout1_30) AT=590.025n

.meas tran vdout1_31ck1170 FIND v(dout1_31) AT=590.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_17ck1230 FIND v(dout1_17) AT=620.025n

.meas tran vdout1_18ck1230 FIND v(dout1_18) AT=620.025n

.meas tran vdout1_19ck1230 FIND v(dout1_19) AT=620.025n

.meas tran vdout1_20ck1230 FIND v(dout1_20) AT=620.025n

.meas tran vdout1_21ck1230 FIND v(dout1_21) AT=620.025n

.meas tran vdout1_22ck1230 FIND v(dout1_22) AT=620.025n

.meas tran vdout1_23ck1230 FIND v(dout1_23) AT=620.025n

.meas tran vdout1_24ck1230 FIND v(dout1_24) AT=620.025n

.meas tran vdout1_25ck1230 FIND v(dout1_25) AT=620.025n

.meas tran vdout1_26ck1230 FIND v(dout1_26) AT=620.025n

.meas tran vdout1_27ck1230 FIND v(dout1_27) AT=620.025n

.meas tran vdout1_28ck1230 FIND v(dout1_28) AT=620.025n

.meas tran vdout1_29ck1230 FIND v(dout1_29) AT=620.025n

.meas tran vdout1_30ck1230 FIND v(dout1_30) AT=620.025n

.meas tran vdout1_31ck1230 FIND v(dout1_31) AT=620.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_17ck1260 FIND v(dout1_17) AT=635.025n

.meas tran vdout1_18ck1260 FIND v(dout1_18) AT=635.025n

.meas tran vdout1_19ck1260 FIND v(dout1_19) AT=635.025n

.meas tran vdout1_20ck1260 FIND v(dout1_20) AT=635.025n

.meas tran vdout1_21ck1260 FIND v(dout1_21) AT=635.025n

.meas tran vdout1_22ck1260 FIND v(dout1_22) AT=635.025n

.meas tran vdout1_23ck1260 FIND v(dout1_23) AT=635.025n

.meas tran vdout1_24ck1260 FIND v(dout1_24) AT=635.025n

.meas tran vdout1_25ck1260 FIND v(dout1_25) AT=635.025n

.meas tran vdout1_26ck1260 FIND v(dout1_26) AT=635.025n

.meas tran vdout1_27ck1260 FIND v(dout1_27) AT=635.025n

.meas tran vdout1_28ck1260 FIND v(dout1_28) AT=635.025n

.meas tran vdout1_29ck1260 FIND v(dout1_29) AT=635.025n

.meas tran vdout1_30ck1260 FIND v(dout1_30) AT=635.025n

.meas tran vdout1_31ck1260 FIND v(dout1_31) AT=635.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_22ck1300 FIND v(dout1_22) AT=655.025n

.meas tran vdout1_23ck1300 FIND v(dout1_23) AT=655.025n

.meas tran vdout1_24ck1300 FIND v(dout1_24) AT=655.025n

.meas tran vdout1_25ck1300 FIND v(dout1_25) AT=655.025n

.meas tran vdout1_26ck1300 FIND v(dout1_26) AT=655.025n

.meas tran vdout1_27ck1300 FIND v(dout1_27) AT=655.025n

.meas tran vdout1_28ck1300 FIND v(dout1_28) AT=655.025n

.meas tran vdout1_29ck1300 FIND v(dout1_29) AT=655.025n

.meas tran vdout1_30ck1300 FIND v(dout1_30) AT=655.025n

.meas tran vdout1_31ck1300 FIND v(dout1_31) AT=655.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_16ck1340 FIND v(dout1_16) AT=675.025n

.meas tran vdout1_17ck1340 FIND v(dout1_17) AT=675.025n

.meas tran vdout1_18ck1340 FIND v(dout1_18) AT=675.025n

.meas tran vdout1_19ck1340 FIND v(dout1_19) AT=675.025n

.meas tran vdout1_20ck1340 FIND v(dout1_20) AT=675.025n

.meas tran vdout1_21ck1340 FIND v(dout1_21) AT=675.025n

.meas tran vdout1_22ck1340 FIND v(dout1_22) AT=675.025n

.meas tran vdout1_23ck1340 FIND v(dout1_23) AT=675.025n

.meas tran vdout1_24ck1340 FIND v(dout1_24) AT=675.025n

.meas tran vdout1_25ck1340 FIND v(dout1_25) AT=675.025n

.meas tran vdout1_26ck1340 FIND v(dout1_26) AT=675.025n

.meas tran vdout1_27ck1340 FIND v(dout1_27) AT=675.025n

.meas tran vdout1_28ck1340 FIND v(dout1_28) AT=675.025n

.meas tran vdout1_29ck1340 FIND v(dout1_29) AT=675.025n

.meas tran vdout1_30ck1340 FIND v(dout1_30) AT=675.025n

.meas tran vdout1_31ck1340 FIND v(dout1_31) AT=675.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_22ck1410 FIND v(dout1_22) AT=710.025n

.meas tran vdout1_23ck1410 FIND v(dout1_23) AT=710.025n

.meas tran vdout1_24ck1410 FIND v(dout1_24) AT=710.025n

.meas tran vdout1_25ck1410 FIND v(dout1_25) AT=710.025n

.meas tran vdout1_26ck1410 FIND v(dout1_26) AT=710.025n

.meas tran vdout1_27ck1410 FIND v(dout1_27) AT=710.025n

.meas tran vdout1_28ck1410 FIND v(dout1_28) AT=710.025n

.meas tran vdout1_29ck1410 FIND v(dout1_29) AT=710.025n

.meas tran vdout1_30ck1410 FIND v(dout1_30) AT=710.025n

.meas tran vdout1_31ck1410 FIND v(dout1_31) AT=710.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_16ck1420 FIND v(dout1_16) AT=715.025n

.meas tran vdout1_17ck1420 FIND v(dout1_17) AT=715.025n

.meas tran vdout1_18ck1420 FIND v(dout1_18) AT=715.025n

.meas tran vdout1_19ck1420 FIND v(dout1_19) AT=715.025n

.meas tran vdout1_20ck1420 FIND v(dout1_20) AT=715.025n

.meas tran vdout1_21ck1420 FIND v(dout1_21) AT=715.025n

.meas tran vdout1_22ck1420 FIND v(dout1_22) AT=715.025n

.meas tran vdout1_23ck1420 FIND v(dout1_23) AT=715.025n

.meas tran vdout1_24ck1420 FIND v(dout1_24) AT=715.025n

.meas tran vdout1_25ck1420 FIND v(dout1_25) AT=715.025n

.meas tran vdout1_26ck1420 FIND v(dout1_26) AT=715.025n

.meas tran vdout1_27ck1420 FIND v(dout1_27) AT=715.025n

.meas tran vdout1_28ck1420 FIND v(dout1_28) AT=715.025n

.meas tran vdout1_29ck1420 FIND v(dout1_29) AT=715.025n

.meas tran vdout1_30ck1420 FIND v(dout1_30) AT=715.025n

.meas tran vdout1_31ck1420 FIND v(dout1_31) AT=715.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_22ck1460 FIND v(dout1_22) AT=735.025n

.meas tran vdout1_23ck1460 FIND v(dout1_23) AT=735.025n

.meas tran vdout1_24ck1460 FIND v(dout1_24) AT=735.025n

.meas tran vdout1_25ck1460 FIND v(dout1_25) AT=735.025n

.meas tran vdout1_26ck1460 FIND v(dout1_26) AT=735.025n

.meas tran vdout1_27ck1460 FIND v(dout1_27) AT=735.025n

.meas tran vdout1_28ck1460 FIND v(dout1_28) AT=735.025n

.meas tran vdout1_29ck1460 FIND v(dout1_29) AT=735.025n

.meas tran vdout1_30ck1460 FIND v(dout1_30) AT=735.025n

.meas tran vdout1_31ck1460 FIND v(dout1_31) AT=735.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_8ck1470 FIND v(dout1_8) AT=740.025n

.meas tran vdout1_9ck1470 FIND v(dout1_9) AT=740.025n

.meas tran vdout1_10ck1470 FIND v(dout1_10) AT=740.025n

.meas tran vdout1_11ck1470 FIND v(dout1_11) AT=740.025n

.meas tran vdout1_12ck1470 FIND v(dout1_12) AT=740.025n

.meas tran vdout1_13ck1470 FIND v(dout1_13) AT=740.025n

.meas tran vdout1_14ck1470 FIND v(dout1_14) AT=740.025n

.meas tran vdout1_15ck1470 FIND v(dout1_15) AT=740.025n

.meas tran vdout1_16ck1470 FIND v(dout1_16) AT=740.025n

.meas tran vdout1_17ck1470 FIND v(dout1_17) AT=740.025n

.meas tran vdout1_18ck1470 FIND v(dout1_18) AT=740.025n

.meas tran vdout1_19ck1470 FIND v(dout1_19) AT=740.025n

.meas tran vdout1_20ck1470 FIND v(dout1_20) AT=740.025n

.meas tran vdout1_21ck1470 FIND v(dout1_21) AT=740.025n

.meas tran vdout1_22ck1470 FIND v(dout1_22) AT=740.025n

.meas tran vdout1_23ck1470 FIND v(dout1_23) AT=740.025n

.meas tran vdout1_24ck1470 FIND v(dout1_24) AT=740.025n

.meas tran vdout1_25ck1470 FIND v(dout1_25) AT=740.025n

.meas tran vdout1_26ck1470 FIND v(dout1_26) AT=740.025n

.meas tran vdout1_27ck1470 FIND v(dout1_27) AT=740.025n

.meas tran vdout1_28ck1470 FIND v(dout1_28) AT=740.025n

.meas tran vdout1_29ck1470 FIND v(dout1_29) AT=740.025n

.meas tran vdout1_30ck1470 FIND v(dout1_30) AT=740.025n

.meas tran vdout1_31ck1470 FIND v(dout1_31) AT=740.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_22ck1490 FIND v(dout1_22) AT=750.025n

.meas tran vdout1_23ck1490 FIND v(dout1_23) AT=750.025n

.meas tran vdout1_24ck1490 FIND v(dout1_24) AT=750.025n

.meas tran vdout1_25ck1490 FIND v(dout1_25) AT=750.025n

.meas tran vdout1_26ck1490 FIND v(dout1_26) AT=750.025n

.meas tran vdout1_27ck1490 FIND v(dout1_27) AT=750.025n

.meas tran vdout1_28ck1490 FIND v(dout1_28) AT=750.025n

.meas tran vdout1_29ck1490 FIND v(dout1_29) AT=750.025n

.meas tran vdout1_30ck1490 FIND v(dout1_30) AT=750.025n

.meas tran vdout1_31ck1490 FIND v(dout1_31) AT=750.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_22ck1500 FIND v(dout1_22) AT=755.025n

.meas tran vdout1_23ck1500 FIND v(dout1_23) AT=755.025n

.meas tran vdout1_24ck1500 FIND v(dout1_24) AT=755.025n

.meas tran vdout1_25ck1500 FIND v(dout1_25) AT=755.025n

.meas tran vdout1_26ck1500 FIND v(dout1_26) AT=755.025n

.meas tran vdout1_27ck1500 FIND v(dout1_27) AT=755.025n

.meas tran vdout1_28ck1500 FIND v(dout1_28) AT=755.025n

.meas tran vdout1_29ck1500 FIND v(dout1_29) AT=755.025n

.meas tran vdout1_30ck1500 FIND v(dout1_30) AT=755.025n

.meas tran vdout1_31ck1500 FIND v(dout1_31) AT=755.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_16ck1520 FIND v(dout1_16) AT=765.025n

.meas tran vdout1_17ck1520 FIND v(dout1_17) AT=765.025n

.meas tran vdout1_18ck1520 FIND v(dout1_18) AT=765.025n

.meas tran vdout1_19ck1520 FIND v(dout1_19) AT=765.025n

.meas tran vdout1_20ck1520 FIND v(dout1_20) AT=765.025n

.meas tran vdout1_21ck1520 FIND v(dout1_21) AT=765.025n

.meas tran vdout1_22ck1520 FIND v(dout1_22) AT=765.025n

.meas tran vdout1_23ck1520 FIND v(dout1_23) AT=765.025n

.meas tran vdout1_24ck1520 FIND v(dout1_24) AT=765.025n

.meas tran vdout1_25ck1520 FIND v(dout1_25) AT=765.025n

.meas tran vdout1_26ck1520 FIND v(dout1_26) AT=765.025n

.meas tran vdout1_27ck1520 FIND v(dout1_27) AT=765.025n

.meas tran vdout1_28ck1520 FIND v(dout1_28) AT=765.025n

.meas tran vdout1_29ck1520 FIND v(dout1_29) AT=765.025n

.meas tran vdout1_30ck1520 FIND v(dout1_30) AT=765.025n

.meas tran vdout1_31ck1520 FIND v(dout1_31) AT=765.025n

.meas tran vdout1_0ck1550 FIND v(dout1_0) AT=780.025n

.meas tran vdout1_1ck1550 FIND v(dout1_1) AT=780.025n

.meas tran vdout1_2ck1550 FIND v(dout1_2) AT=780.025n

.meas tran vdout1_3ck1550 FIND v(dout1_3) AT=780.025n

.meas tran vdout1_4ck1550 FIND v(dout1_4) AT=780.025n

.meas tran vdout1_5ck1550 FIND v(dout1_5) AT=780.025n

.meas tran vdout1_6ck1550 FIND v(dout1_6) AT=780.025n

.meas tran vdout1_7ck1550 FIND v(dout1_7) AT=780.025n

.meas tran vdout1_8ck1550 FIND v(dout1_8) AT=780.025n

.meas tran vdout1_9ck1550 FIND v(dout1_9) AT=780.025n

.meas tran vdout1_10ck1550 FIND v(dout1_10) AT=780.025n

.meas tran vdout1_11ck1550 FIND v(dout1_11) AT=780.025n

.meas tran vdout1_12ck1550 FIND v(dout1_12) AT=780.025n

.meas tran vdout1_13ck1550 FIND v(dout1_13) AT=780.025n

.meas tran vdout1_14ck1550 FIND v(dout1_14) AT=780.025n

.meas tran vdout1_15ck1550 FIND v(dout1_15) AT=780.025n

.meas tran vdout1_16ck1550 FIND v(dout1_16) AT=780.025n

.meas tran vdout1_17ck1550 FIND v(dout1_17) AT=780.025n

.meas tran vdout1_18ck1550 FIND v(dout1_18) AT=780.025n

.meas tran vdout1_19ck1550 FIND v(dout1_19) AT=780.025n

.meas tran vdout1_20ck1550 FIND v(dout1_20) AT=780.025n

.meas tran vdout1_21ck1550 FIND v(dout1_21) AT=780.025n

.meas tran vdout1_22ck1550 FIND v(dout1_22) AT=780.025n

.meas tran vdout1_23ck1550 FIND v(dout1_23) AT=780.025n

.meas tran vdout1_24ck1550 FIND v(dout1_24) AT=780.025n

.meas tran vdout1_25ck1550 FIND v(dout1_25) AT=780.025n

.meas tran vdout1_26ck1550 FIND v(dout1_26) AT=780.025n

.meas tran vdout1_27ck1550 FIND v(dout1_27) AT=780.025n

.meas tran vdout1_28ck1550 FIND v(dout1_28) AT=780.025n

.meas tran vdout1_29ck1550 FIND v(dout1_29) AT=780.025n

.meas tran vdout1_30ck1550 FIND v(dout1_30) AT=780.025n

.meas tran vdout1_31ck1550 FIND v(dout1_31) AT=780.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_16ck1560 FIND v(dout1_16) AT=785.025n

.meas tran vdout1_17ck1560 FIND v(dout1_17) AT=785.025n

.meas tran vdout1_18ck1560 FIND v(dout1_18) AT=785.025n

.meas tran vdout1_19ck1560 FIND v(dout1_19) AT=785.025n

.meas tran vdout1_20ck1560 FIND v(dout1_20) AT=785.025n

.meas tran vdout1_21ck1560 FIND v(dout1_21) AT=785.025n

.meas tran vdout1_22ck1560 FIND v(dout1_22) AT=785.025n

.meas tran vdout1_23ck1560 FIND v(dout1_23) AT=785.025n

.meas tran vdout1_24ck1560 FIND v(dout1_24) AT=785.025n

.meas tran vdout1_25ck1560 FIND v(dout1_25) AT=785.025n

.meas tran vdout1_26ck1560 FIND v(dout1_26) AT=785.025n

.meas tran vdout1_27ck1560 FIND v(dout1_27) AT=785.025n

.meas tran vdout1_28ck1560 FIND v(dout1_28) AT=785.025n

.meas tran vdout1_29ck1560 FIND v(dout1_29) AT=785.025n

.meas tran vdout1_30ck1560 FIND v(dout1_30) AT=785.025n

.meas tran vdout1_31ck1560 FIND v(dout1_31) AT=785.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_17ck1570 FIND v(dout1_17) AT=790.025n

.meas tran vdout1_18ck1570 FIND v(dout1_18) AT=790.025n

.meas tran vdout1_19ck1570 FIND v(dout1_19) AT=790.025n

.meas tran vdout1_20ck1570 FIND v(dout1_20) AT=790.025n

.meas tran vdout1_21ck1570 FIND v(dout1_21) AT=790.025n

.meas tran vdout1_22ck1570 FIND v(dout1_22) AT=790.025n

.meas tran vdout1_23ck1570 FIND v(dout1_23) AT=790.025n

.meas tran vdout1_24ck1570 FIND v(dout1_24) AT=790.025n

.meas tran vdout1_25ck1570 FIND v(dout1_25) AT=790.025n

.meas tran vdout1_26ck1570 FIND v(dout1_26) AT=790.025n

.meas tran vdout1_27ck1570 FIND v(dout1_27) AT=790.025n

.meas tran vdout1_28ck1570 FIND v(dout1_28) AT=790.025n

.meas tran vdout1_29ck1570 FIND v(dout1_29) AT=790.025n

.meas tran vdout1_30ck1570 FIND v(dout1_30) AT=790.025n

.meas tran vdout1_31ck1570 FIND v(dout1_31) AT=790.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_19ck1600 FIND v(dout1_19) AT=805.025n

.meas tran vdout1_20ck1600 FIND v(dout1_20) AT=805.025n

.meas tran vdout1_21ck1600 FIND v(dout1_21) AT=805.025n

.meas tran vdout1_22ck1600 FIND v(dout1_22) AT=805.025n

.meas tran vdout1_23ck1600 FIND v(dout1_23) AT=805.025n

.meas tran vdout1_24ck1600 FIND v(dout1_24) AT=805.025n

.meas tran vdout1_25ck1600 FIND v(dout1_25) AT=805.025n

.meas tran vdout1_26ck1600 FIND v(dout1_26) AT=805.025n

.meas tran vdout1_27ck1600 FIND v(dout1_27) AT=805.025n

.meas tran vdout1_28ck1600 FIND v(dout1_28) AT=805.025n

.meas tran vdout1_29ck1600 FIND v(dout1_29) AT=805.025n

.meas tran vdout1_30ck1600 FIND v(dout1_30) AT=805.025n

.meas tran vdout1_31ck1600 FIND v(dout1_31) AT=805.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_22ck1610 FIND v(dout1_22) AT=810.025n

.meas tran vdout1_23ck1610 FIND v(dout1_23) AT=810.025n

.meas tran vdout1_24ck1610 FIND v(dout1_24) AT=810.025n

.meas tran vdout1_25ck1610 FIND v(dout1_25) AT=810.025n

.meas tran vdout1_26ck1610 FIND v(dout1_26) AT=810.025n

.meas tran vdout1_27ck1610 FIND v(dout1_27) AT=810.025n

.meas tran vdout1_28ck1610 FIND v(dout1_28) AT=810.025n

.meas tran vdout1_29ck1610 FIND v(dout1_29) AT=810.025n

.meas tran vdout1_30ck1610 FIND v(dout1_30) AT=810.025n

.meas tran vdout1_31ck1610 FIND v(dout1_31) AT=810.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_0ck1670 FIND v(dout1_0) AT=840.025n

.meas tran vdout1_1ck1670 FIND v(dout1_1) AT=840.025n

.meas tran vdout1_2ck1670 FIND v(dout1_2) AT=840.025n

.meas tran vdout1_3ck1670 FIND v(dout1_3) AT=840.025n

.meas tran vdout1_4ck1670 FIND v(dout1_4) AT=840.025n

.meas tran vdout1_5ck1670 FIND v(dout1_5) AT=840.025n

.meas tran vdout1_6ck1670 FIND v(dout1_6) AT=840.025n

.meas tran vdout1_7ck1670 FIND v(dout1_7) AT=840.025n

.meas tran vdout1_8ck1670 FIND v(dout1_8) AT=840.025n

.meas tran vdout1_9ck1670 FIND v(dout1_9) AT=840.025n

.meas tran vdout1_10ck1670 FIND v(dout1_10) AT=840.025n

.meas tran vdout1_11ck1670 FIND v(dout1_11) AT=840.025n

.meas tran vdout1_12ck1670 FIND v(dout1_12) AT=840.025n

.meas tran vdout1_13ck1670 FIND v(dout1_13) AT=840.025n

.meas tran vdout1_14ck1670 FIND v(dout1_14) AT=840.025n

.meas tran vdout1_15ck1670 FIND v(dout1_15) AT=840.025n

.meas tran vdout1_16ck1670 FIND v(dout1_16) AT=840.025n

.meas tran vdout1_17ck1670 FIND v(dout1_17) AT=840.025n

.meas tran vdout1_18ck1670 FIND v(dout1_18) AT=840.025n

.meas tran vdout1_19ck1670 FIND v(dout1_19) AT=840.025n

.meas tran vdout1_20ck1670 FIND v(dout1_20) AT=840.025n

.meas tran vdout1_21ck1670 FIND v(dout1_21) AT=840.025n

.meas tran vdout1_22ck1670 FIND v(dout1_22) AT=840.025n

.meas tran vdout1_23ck1670 FIND v(dout1_23) AT=840.025n

.meas tran vdout1_24ck1670 FIND v(dout1_24) AT=840.025n

.meas tran vdout1_25ck1670 FIND v(dout1_25) AT=840.025n

.meas tran vdout1_26ck1670 FIND v(dout1_26) AT=840.025n

.meas tran vdout1_27ck1670 FIND v(dout1_27) AT=840.025n

.meas tran vdout1_28ck1670 FIND v(dout1_28) AT=840.025n

.meas tran vdout1_29ck1670 FIND v(dout1_29) AT=840.025n

.meas tran vdout1_30ck1670 FIND v(dout1_30) AT=840.025n

.meas tran vdout1_31ck1670 FIND v(dout1_31) AT=840.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_22ck1690 FIND v(dout1_22) AT=850.025n

.meas tran vdout1_23ck1690 FIND v(dout1_23) AT=850.025n

.meas tran vdout1_24ck1690 FIND v(dout1_24) AT=850.025n

.meas tran vdout1_25ck1690 FIND v(dout1_25) AT=850.025n

.meas tran vdout1_26ck1690 FIND v(dout1_26) AT=850.025n

.meas tran vdout1_27ck1690 FIND v(dout1_27) AT=850.025n

.meas tran vdout1_28ck1690 FIND v(dout1_28) AT=850.025n

.meas tran vdout1_29ck1690 FIND v(dout1_29) AT=850.025n

.meas tran vdout1_30ck1690 FIND v(dout1_30) AT=850.025n

.meas tran vdout1_31ck1690 FIND v(dout1_31) AT=850.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_19ck1700 FIND v(dout1_19) AT=855.025n

.meas tran vdout1_20ck1700 FIND v(dout1_20) AT=855.025n

.meas tran vdout1_21ck1700 FIND v(dout1_21) AT=855.025n

.meas tran vdout1_22ck1700 FIND v(dout1_22) AT=855.025n

.meas tran vdout1_23ck1700 FIND v(dout1_23) AT=855.025n

.meas tran vdout1_24ck1700 FIND v(dout1_24) AT=855.025n

.meas tran vdout1_25ck1700 FIND v(dout1_25) AT=855.025n

.meas tran vdout1_26ck1700 FIND v(dout1_26) AT=855.025n

.meas tran vdout1_27ck1700 FIND v(dout1_27) AT=855.025n

.meas tran vdout1_28ck1700 FIND v(dout1_28) AT=855.025n

.meas tran vdout1_29ck1700 FIND v(dout1_29) AT=855.025n

.meas tran vdout1_30ck1700 FIND v(dout1_30) AT=855.025n

.meas tran vdout1_31ck1700 FIND v(dout1_31) AT=855.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_19ck1710 FIND v(dout1_19) AT=860.025n

.meas tran vdout1_20ck1710 FIND v(dout1_20) AT=860.025n

.meas tran vdout1_21ck1710 FIND v(dout1_21) AT=860.025n

.meas tran vdout1_22ck1710 FIND v(dout1_22) AT=860.025n

.meas tran vdout1_23ck1710 FIND v(dout1_23) AT=860.025n

.meas tran vdout1_24ck1710 FIND v(dout1_24) AT=860.025n

.meas tran vdout1_25ck1710 FIND v(dout1_25) AT=860.025n

.meas tran vdout1_26ck1710 FIND v(dout1_26) AT=860.025n

.meas tran vdout1_27ck1710 FIND v(dout1_27) AT=860.025n

.meas tran vdout1_28ck1710 FIND v(dout1_28) AT=860.025n

.meas tran vdout1_29ck1710 FIND v(dout1_29) AT=860.025n

.meas tran vdout1_30ck1710 FIND v(dout1_30) AT=860.025n

.meas tran vdout1_31ck1710 FIND v(dout1_31) AT=860.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_22ck1750 FIND v(dout1_22) AT=880.025n

.meas tran vdout1_23ck1750 FIND v(dout1_23) AT=880.025n

.meas tran vdout1_24ck1750 FIND v(dout1_24) AT=880.025n

.meas tran vdout1_25ck1750 FIND v(dout1_25) AT=880.025n

.meas tran vdout1_26ck1750 FIND v(dout1_26) AT=880.025n

.meas tran vdout1_27ck1750 FIND v(dout1_27) AT=880.025n

.meas tran vdout1_28ck1750 FIND v(dout1_28) AT=880.025n

.meas tran vdout1_29ck1750 FIND v(dout1_29) AT=880.025n

.meas tran vdout1_30ck1750 FIND v(dout1_30) AT=880.025n

.meas tran vdout1_31ck1750 FIND v(dout1_31) AT=880.025n

.meas tran vdout1_0ck1770 FIND v(dout1_0) AT=890.025n

.meas tran vdout1_1ck1770 FIND v(dout1_1) AT=890.025n

.meas tran vdout1_2ck1770 FIND v(dout1_2) AT=890.025n

.meas tran vdout1_3ck1770 FIND v(dout1_3) AT=890.025n

.meas tran vdout1_4ck1770 FIND v(dout1_4) AT=890.025n

.meas tran vdout1_5ck1770 FIND v(dout1_5) AT=890.025n

.meas tran vdout1_6ck1770 FIND v(dout1_6) AT=890.025n

.meas tran vdout1_7ck1770 FIND v(dout1_7) AT=890.025n

.meas tran vdout1_8ck1770 FIND v(dout1_8) AT=890.025n

.meas tran vdout1_9ck1770 FIND v(dout1_9) AT=890.025n

.meas tran vdout1_10ck1770 FIND v(dout1_10) AT=890.025n

.meas tran vdout1_11ck1770 FIND v(dout1_11) AT=890.025n

.meas tran vdout1_12ck1770 FIND v(dout1_12) AT=890.025n

.meas tran vdout1_13ck1770 FIND v(dout1_13) AT=890.025n

.meas tran vdout1_14ck1770 FIND v(dout1_14) AT=890.025n

.meas tran vdout1_15ck1770 FIND v(dout1_15) AT=890.025n

.meas tran vdout1_16ck1770 FIND v(dout1_16) AT=890.025n

.meas tran vdout1_17ck1770 FIND v(dout1_17) AT=890.025n

.meas tran vdout1_18ck1770 FIND v(dout1_18) AT=890.025n

.meas tran vdout1_19ck1770 FIND v(dout1_19) AT=890.025n

.meas tran vdout1_20ck1770 FIND v(dout1_20) AT=890.025n

.meas tran vdout1_21ck1770 FIND v(dout1_21) AT=890.025n

.meas tran vdout1_22ck1770 FIND v(dout1_22) AT=890.025n

.meas tran vdout1_23ck1770 FIND v(dout1_23) AT=890.025n

.meas tran vdout1_24ck1770 FIND v(dout1_24) AT=890.025n

.meas tran vdout1_25ck1770 FIND v(dout1_25) AT=890.025n

.meas tran vdout1_26ck1770 FIND v(dout1_26) AT=890.025n

.meas tran vdout1_27ck1770 FIND v(dout1_27) AT=890.025n

.meas tran vdout1_28ck1770 FIND v(dout1_28) AT=890.025n

.meas tran vdout1_29ck1770 FIND v(dout1_29) AT=890.025n

.meas tran vdout1_30ck1770 FIND v(dout1_30) AT=890.025n

.meas tran vdout1_31ck1770 FIND v(dout1_31) AT=890.025n

.meas tran vdout1_0ck1790 FIND v(dout1_0) AT=900.025n

.meas tran vdout1_1ck1790 FIND v(dout1_1) AT=900.025n

.meas tran vdout1_2ck1790 FIND v(dout1_2) AT=900.025n

.meas tran vdout1_3ck1790 FIND v(dout1_3) AT=900.025n

.meas tran vdout1_4ck1790 FIND v(dout1_4) AT=900.025n

.meas tran vdout1_5ck1790 FIND v(dout1_5) AT=900.025n

.meas tran vdout1_6ck1790 FIND v(dout1_6) AT=900.025n

.meas tran vdout1_7ck1790 FIND v(dout1_7) AT=900.025n

.meas tran vdout1_8ck1790 FIND v(dout1_8) AT=900.025n

.meas tran vdout1_9ck1790 FIND v(dout1_9) AT=900.025n

.meas tran vdout1_10ck1790 FIND v(dout1_10) AT=900.025n

.meas tran vdout1_11ck1790 FIND v(dout1_11) AT=900.025n

.meas tran vdout1_12ck1790 FIND v(dout1_12) AT=900.025n

.meas tran vdout1_13ck1790 FIND v(dout1_13) AT=900.025n

.meas tran vdout1_14ck1790 FIND v(dout1_14) AT=900.025n

.meas tran vdout1_15ck1790 FIND v(dout1_15) AT=900.025n

.meas tran vdout1_16ck1790 FIND v(dout1_16) AT=900.025n

.meas tran vdout1_17ck1790 FIND v(dout1_17) AT=900.025n

.meas tran vdout1_18ck1790 FIND v(dout1_18) AT=900.025n

.meas tran vdout1_19ck1790 FIND v(dout1_19) AT=900.025n

.meas tran vdout1_20ck1790 FIND v(dout1_20) AT=900.025n

.meas tran vdout1_21ck1790 FIND v(dout1_21) AT=900.025n

.meas tran vdout1_22ck1790 FIND v(dout1_22) AT=900.025n

.meas tran vdout1_23ck1790 FIND v(dout1_23) AT=900.025n

.meas tran vdout1_24ck1790 FIND v(dout1_24) AT=900.025n

.meas tran vdout1_25ck1790 FIND v(dout1_25) AT=900.025n

.meas tran vdout1_26ck1790 FIND v(dout1_26) AT=900.025n

.meas tran vdout1_27ck1790 FIND v(dout1_27) AT=900.025n

.meas tran vdout1_28ck1790 FIND v(dout1_28) AT=900.025n

.meas tran vdout1_29ck1790 FIND v(dout1_29) AT=900.025n

.meas tran vdout1_30ck1790 FIND v(dout1_30) AT=900.025n

.meas tran vdout1_31ck1790 FIND v(dout1_31) AT=900.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_17ck1810 FIND v(dout1_17) AT=910.025n

.meas tran vdout1_18ck1810 FIND v(dout1_18) AT=910.025n

.meas tran vdout1_19ck1810 FIND v(dout1_19) AT=910.025n

.meas tran vdout1_20ck1810 FIND v(dout1_20) AT=910.025n

.meas tran vdout1_21ck1810 FIND v(dout1_21) AT=910.025n

.meas tran vdout1_22ck1810 FIND v(dout1_22) AT=910.025n

.meas tran vdout1_23ck1810 FIND v(dout1_23) AT=910.025n

.meas tran vdout1_24ck1810 FIND v(dout1_24) AT=910.025n

.meas tran vdout1_25ck1810 FIND v(dout1_25) AT=910.025n

.meas tran vdout1_26ck1810 FIND v(dout1_26) AT=910.025n

.meas tran vdout1_27ck1810 FIND v(dout1_27) AT=910.025n

.meas tran vdout1_28ck1810 FIND v(dout1_28) AT=910.025n

.meas tran vdout1_29ck1810 FIND v(dout1_29) AT=910.025n

.meas tran vdout1_30ck1810 FIND v(dout1_30) AT=910.025n

.meas tran vdout1_31ck1810 FIND v(dout1_31) AT=910.025n

.meas tran vdout1_0ck1880 FIND v(dout1_0) AT=945.025n

.meas tran vdout1_1ck1880 FIND v(dout1_1) AT=945.025n

.meas tran vdout1_2ck1880 FIND v(dout1_2) AT=945.025n

.meas tran vdout1_3ck1880 FIND v(dout1_3) AT=945.025n

.meas tran vdout1_4ck1880 FIND v(dout1_4) AT=945.025n

.meas tran vdout1_5ck1880 FIND v(dout1_5) AT=945.025n

.meas tran vdout1_6ck1880 FIND v(dout1_6) AT=945.025n

.meas tran vdout1_7ck1880 FIND v(dout1_7) AT=945.025n

.meas tran vdout1_8ck1880 FIND v(dout1_8) AT=945.025n

.meas tran vdout1_9ck1880 FIND v(dout1_9) AT=945.025n

.meas tran vdout1_10ck1880 FIND v(dout1_10) AT=945.025n

.meas tran vdout1_11ck1880 FIND v(dout1_11) AT=945.025n

.meas tran vdout1_12ck1880 FIND v(dout1_12) AT=945.025n

.meas tran vdout1_13ck1880 FIND v(dout1_13) AT=945.025n

.meas tran vdout1_14ck1880 FIND v(dout1_14) AT=945.025n

.meas tran vdout1_15ck1880 FIND v(dout1_15) AT=945.025n

.meas tran vdout1_16ck1880 FIND v(dout1_16) AT=945.025n

.meas tran vdout1_17ck1880 FIND v(dout1_17) AT=945.025n

.meas tran vdout1_18ck1880 FIND v(dout1_18) AT=945.025n

.meas tran vdout1_19ck1880 FIND v(dout1_19) AT=945.025n

.meas tran vdout1_20ck1880 FIND v(dout1_20) AT=945.025n

.meas tran vdout1_21ck1880 FIND v(dout1_21) AT=945.025n

.meas tran vdout1_22ck1880 FIND v(dout1_22) AT=945.025n

.meas tran vdout1_23ck1880 FIND v(dout1_23) AT=945.025n

.meas tran vdout1_24ck1880 FIND v(dout1_24) AT=945.025n

.meas tran vdout1_25ck1880 FIND v(dout1_25) AT=945.025n

.meas tran vdout1_26ck1880 FIND v(dout1_26) AT=945.025n

.meas tran vdout1_27ck1880 FIND v(dout1_27) AT=945.025n

.meas tran vdout1_28ck1880 FIND v(dout1_28) AT=945.025n

.meas tran vdout1_29ck1880 FIND v(dout1_29) AT=945.025n

.meas tran vdout1_30ck1880 FIND v(dout1_30) AT=945.025n

.meas tran vdout1_31ck1880 FIND v(dout1_31) AT=945.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_23ck1890 FIND v(dout1_23) AT=950.025n

.meas tran vdout1_24ck1890 FIND v(dout1_24) AT=950.025n

.meas tran vdout1_25ck1890 FIND v(dout1_25) AT=950.025n

.meas tran vdout1_26ck1890 FIND v(dout1_26) AT=950.025n

.meas tran vdout1_27ck1890 FIND v(dout1_27) AT=950.025n

.meas tran vdout1_28ck1890 FIND v(dout1_28) AT=950.025n

.meas tran vdout1_29ck1890 FIND v(dout1_29) AT=950.025n

.meas tran vdout1_30ck1890 FIND v(dout1_30) AT=950.025n

.meas tran vdout1_31ck1890 FIND v(dout1_31) AT=950.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_23ck1920 FIND v(dout1_23) AT=965.025n

.meas tran vdout1_24ck1920 FIND v(dout1_24) AT=965.025n

.meas tran vdout1_25ck1920 FIND v(dout1_25) AT=965.025n

.meas tran vdout1_26ck1920 FIND v(dout1_26) AT=965.025n

.meas tran vdout1_27ck1920 FIND v(dout1_27) AT=965.025n

.meas tran vdout1_28ck1920 FIND v(dout1_28) AT=965.025n

.meas tran vdout1_29ck1920 FIND v(dout1_29) AT=965.025n

.meas tran vdout1_30ck1920 FIND v(dout1_30) AT=965.025n

.meas tran vdout1_31ck1920 FIND v(dout1_31) AT=965.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_17ck1930 FIND v(dout1_17) AT=970.025n

.meas tran vdout1_18ck1930 FIND v(dout1_18) AT=970.025n

.meas tran vdout1_19ck1930 FIND v(dout1_19) AT=970.025n

.meas tran vdout1_20ck1930 FIND v(dout1_20) AT=970.025n

.meas tran vdout1_21ck1930 FIND v(dout1_21) AT=970.025n

.meas tran vdout1_22ck1930 FIND v(dout1_22) AT=970.025n

.meas tran vdout1_23ck1930 FIND v(dout1_23) AT=970.025n

.meas tran vdout1_24ck1930 FIND v(dout1_24) AT=970.025n

.meas tran vdout1_25ck1930 FIND v(dout1_25) AT=970.025n

.meas tran vdout1_26ck1930 FIND v(dout1_26) AT=970.025n

.meas tran vdout1_27ck1930 FIND v(dout1_27) AT=970.025n

.meas tran vdout1_28ck1930 FIND v(dout1_28) AT=970.025n

.meas tran vdout1_29ck1930 FIND v(dout1_29) AT=970.025n

.meas tran vdout1_30ck1930 FIND v(dout1_30) AT=970.025n

.meas tran vdout1_31ck1930 FIND v(dout1_31) AT=970.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_0ck2000 FIND v(dout1_0) AT=1005.025n

.meas tran vdout1_1ck2000 FIND v(dout1_1) AT=1005.025n

.meas tran vdout1_2ck2000 FIND v(dout1_2) AT=1005.025n

.meas tran vdout1_3ck2000 FIND v(dout1_3) AT=1005.025n

.meas tran vdout1_4ck2000 FIND v(dout1_4) AT=1005.025n

.meas tran vdout1_5ck2000 FIND v(dout1_5) AT=1005.025n

.meas tran vdout1_6ck2000 FIND v(dout1_6) AT=1005.025n

.meas tran vdout1_7ck2000 FIND v(dout1_7) AT=1005.025n

.meas tran vdout1_8ck2000 FIND v(dout1_8) AT=1005.025n

.meas tran vdout1_9ck2000 FIND v(dout1_9) AT=1005.025n

.meas tran vdout1_10ck2000 FIND v(dout1_10) AT=1005.025n

.meas tran vdout1_11ck2000 FIND v(dout1_11) AT=1005.025n

.meas tran vdout1_12ck2000 FIND v(dout1_12) AT=1005.025n

.meas tran vdout1_13ck2000 FIND v(dout1_13) AT=1005.025n

.meas tran vdout1_14ck2000 FIND v(dout1_14) AT=1005.025n

.meas tran vdout1_15ck2000 FIND v(dout1_15) AT=1005.025n

.meas tran vdout1_16ck2000 FIND v(dout1_16) AT=1005.025n

.meas tran vdout1_17ck2000 FIND v(dout1_17) AT=1005.025n

.meas tran vdout1_18ck2000 FIND v(dout1_18) AT=1005.025n

.meas tran vdout1_19ck2000 FIND v(dout1_19) AT=1005.025n

.meas tran vdout1_20ck2000 FIND v(dout1_20) AT=1005.025n

.meas tran vdout1_21ck2000 FIND v(dout1_21) AT=1005.025n

.meas tran vdout1_22ck2000 FIND v(dout1_22) AT=1005.025n

.meas tran vdout1_23ck2000 FIND v(dout1_23) AT=1005.025n

.meas tran vdout1_24ck2000 FIND v(dout1_24) AT=1005.025n

.meas tran vdout1_25ck2000 FIND v(dout1_25) AT=1005.025n

.meas tran vdout1_26ck2000 FIND v(dout1_26) AT=1005.025n

.meas tran vdout1_27ck2000 FIND v(dout1_27) AT=1005.025n

.meas tran vdout1_28ck2000 FIND v(dout1_28) AT=1005.025n

.meas tran vdout1_29ck2000 FIND v(dout1_29) AT=1005.025n

.meas tran vdout1_30ck2000 FIND v(dout1_30) AT=1005.025n

.meas tran vdout1_31ck2000 FIND v(dout1_31) AT=1005.025n

.meas tran vdout1_0ck2040 FIND v(dout1_0) AT=1025.025n

.meas tran vdout1_1ck2040 FIND v(dout1_1) AT=1025.025n

.meas tran vdout1_2ck2040 FIND v(dout1_2) AT=1025.025n

.meas tran vdout1_3ck2040 FIND v(dout1_3) AT=1025.025n

.meas tran vdout1_4ck2040 FIND v(dout1_4) AT=1025.025n

.meas tran vdout1_5ck2040 FIND v(dout1_5) AT=1025.025n

.meas tran vdout1_6ck2040 FIND v(dout1_6) AT=1025.025n

.meas tran vdout1_7ck2040 FIND v(dout1_7) AT=1025.025n

.meas tran vdout1_8ck2040 FIND v(dout1_8) AT=1025.025n

.meas tran vdout1_9ck2040 FIND v(dout1_9) AT=1025.025n

.meas tran vdout1_10ck2040 FIND v(dout1_10) AT=1025.025n

.meas tran vdout1_11ck2040 FIND v(dout1_11) AT=1025.025n

.meas tran vdout1_12ck2040 FIND v(dout1_12) AT=1025.025n

.meas tran vdout1_13ck2040 FIND v(dout1_13) AT=1025.025n

.meas tran vdout1_14ck2040 FIND v(dout1_14) AT=1025.025n

.meas tran vdout1_15ck2040 FIND v(dout1_15) AT=1025.025n

.meas tran vdout1_16ck2040 FIND v(dout1_16) AT=1025.025n

.meas tran vdout1_17ck2040 FIND v(dout1_17) AT=1025.025n

.meas tran vdout1_18ck2040 FIND v(dout1_18) AT=1025.025n

.meas tran vdout1_19ck2040 FIND v(dout1_19) AT=1025.025n

.meas tran vdout1_20ck2040 FIND v(dout1_20) AT=1025.025n

.meas tran vdout1_21ck2040 FIND v(dout1_21) AT=1025.025n

.meas tran vdout1_22ck2040 FIND v(dout1_22) AT=1025.025n

.meas tran vdout1_23ck2040 FIND v(dout1_23) AT=1025.025n

.meas tran vdout1_24ck2040 FIND v(dout1_24) AT=1025.025n

.meas tran vdout1_25ck2040 FIND v(dout1_25) AT=1025.025n

.meas tran vdout1_26ck2040 FIND v(dout1_26) AT=1025.025n

.meas tran vdout1_27ck2040 FIND v(dout1_27) AT=1025.025n

.meas tran vdout1_28ck2040 FIND v(dout1_28) AT=1025.025n

.meas tran vdout1_29ck2040 FIND v(dout1_29) AT=1025.025n

.meas tran vdout1_30ck2040 FIND v(dout1_30) AT=1025.025n

.meas tran vdout1_31ck2040 FIND v(dout1_31) AT=1025.025n
