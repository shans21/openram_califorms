.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_0ck50 FIND v(dout1_0) AT=30.025n

.meas tran vdout1_1ck50 FIND v(dout1_1) AT=30.025n

.meas tran vdout1_2ck50 FIND v(dout1_2) AT=30.025n

.meas tran vdout1_3ck50 FIND v(dout1_3) AT=30.025n

.meas tran vdout1_4ck50 FIND v(dout1_4) AT=30.025n

.meas tran vdout1_5ck50 FIND v(dout1_5) AT=30.025n

.meas tran vdout1_6ck50 FIND v(dout1_6) AT=30.025n

.meas tran vdout1_7ck50 FIND v(dout1_7) AT=30.025n

.meas tran vdout1_8ck50 FIND v(dout1_8) AT=30.025n

.meas tran vdout1_9ck50 FIND v(dout1_9) AT=30.025n

.meas tran vdout1_10ck50 FIND v(dout1_10) AT=30.025n

.meas tran vdout1_11ck50 FIND v(dout1_11) AT=30.025n

.meas tran vdout1_12ck50 FIND v(dout1_12) AT=30.025n

.meas tran vdout1_13ck50 FIND v(dout1_13) AT=30.025n

.meas tran vdout1_14ck50 FIND v(dout1_14) AT=30.025n

.meas tran vdout1_15ck50 FIND v(dout1_15) AT=30.025n

.meas tran vdout1_16ck50 FIND v(dout1_16) AT=30.025n

.meas tran vdout1_17ck50 FIND v(dout1_17) AT=30.025n

.meas tran vdout1_18ck50 FIND v(dout1_18) AT=30.025n

.meas tran vdout1_19ck50 FIND v(dout1_19) AT=30.025n

.meas tran vdout1_20ck50 FIND v(dout1_20) AT=30.025n

.meas tran vdout1_21ck50 FIND v(dout1_21) AT=30.025n

.meas tran vdout1_22ck50 FIND v(dout1_22) AT=30.025n

.meas tran vdout1_23ck50 FIND v(dout1_23) AT=30.025n

.meas tran vdout1_24ck50 FIND v(dout1_24) AT=30.025n

.meas tran vdout1_25ck50 FIND v(dout1_25) AT=30.025n

.meas tran vdout1_26ck50 FIND v(dout1_26) AT=30.025n

.meas tran vdout1_27ck50 FIND v(dout1_27) AT=30.025n

.meas tran vdout1_28ck50 FIND v(dout1_28) AT=30.025n

.meas tran vdout1_29ck50 FIND v(dout1_29) AT=30.025n

.meas tran vdout1_30ck50 FIND v(dout1_30) AT=30.025n

.meas tran vdout1_31ck50 FIND v(dout1_31) AT=30.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_17ck80 FIND v(dout1_17) AT=45.025n

.meas tran vdout1_18ck80 FIND v(dout1_18) AT=45.025n

.meas tran vdout1_19ck80 FIND v(dout1_19) AT=45.025n

.meas tran vdout1_20ck80 FIND v(dout1_20) AT=45.025n

.meas tran vdout1_21ck80 FIND v(dout1_21) AT=45.025n

.meas tran vdout1_22ck80 FIND v(dout1_22) AT=45.025n

.meas tran vdout1_23ck80 FIND v(dout1_23) AT=45.025n

.meas tran vdout1_24ck80 FIND v(dout1_24) AT=45.025n

.meas tran vdout1_25ck80 FIND v(dout1_25) AT=45.025n

.meas tran vdout1_26ck80 FIND v(dout1_26) AT=45.025n

.meas tran vdout1_27ck80 FIND v(dout1_27) AT=45.025n

.meas tran vdout1_28ck80 FIND v(dout1_28) AT=45.025n

.meas tran vdout1_29ck80 FIND v(dout1_29) AT=45.025n

.meas tran vdout1_30ck80 FIND v(dout1_30) AT=45.025n

.meas tran vdout1_31ck80 FIND v(dout1_31) AT=45.025n

.meas tran vdout1_0ck120 FIND v(dout1_0) AT=65.025n

.meas tran vdout1_1ck120 FIND v(dout1_1) AT=65.025n

.meas tran vdout1_2ck120 FIND v(dout1_2) AT=65.025n

.meas tran vdout1_3ck120 FIND v(dout1_3) AT=65.025n

.meas tran vdout1_4ck120 FIND v(dout1_4) AT=65.025n

.meas tran vdout1_5ck120 FIND v(dout1_5) AT=65.025n

.meas tran vdout1_6ck120 FIND v(dout1_6) AT=65.025n

.meas tran vdout1_7ck120 FIND v(dout1_7) AT=65.025n

.meas tran vdout1_8ck120 FIND v(dout1_8) AT=65.025n

.meas tran vdout1_9ck120 FIND v(dout1_9) AT=65.025n

.meas tran vdout1_10ck120 FIND v(dout1_10) AT=65.025n

.meas tran vdout1_11ck120 FIND v(dout1_11) AT=65.025n

.meas tran vdout1_12ck120 FIND v(dout1_12) AT=65.025n

.meas tran vdout1_13ck120 FIND v(dout1_13) AT=65.025n

.meas tran vdout1_14ck120 FIND v(dout1_14) AT=65.025n

.meas tran vdout1_15ck120 FIND v(dout1_15) AT=65.025n

.meas tran vdout1_16ck120 FIND v(dout1_16) AT=65.025n

.meas tran vdout1_17ck120 FIND v(dout1_17) AT=65.025n

.meas tran vdout1_18ck120 FIND v(dout1_18) AT=65.025n

.meas tran vdout1_19ck120 FIND v(dout1_19) AT=65.025n

.meas tran vdout1_20ck120 FIND v(dout1_20) AT=65.025n

.meas tran vdout1_21ck120 FIND v(dout1_21) AT=65.025n

.meas tran vdout1_22ck120 FIND v(dout1_22) AT=65.025n

.meas tran vdout1_23ck120 FIND v(dout1_23) AT=65.025n

.meas tran vdout1_24ck120 FIND v(dout1_24) AT=65.025n

.meas tran vdout1_25ck120 FIND v(dout1_25) AT=65.025n

.meas tran vdout1_26ck120 FIND v(dout1_26) AT=65.025n

.meas tran vdout1_27ck120 FIND v(dout1_27) AT=65.025n

.meas tran vdout1_28ck120 FIND v(dout1_28) AT=65.025n

.meas tran vdout1_29ck120 FIND v(dout1_29) AT=65.025n

.meas tran vdout1_30ck120 FIND v(dout1_30) AT=65.025n

.meas tran vdout1_31ck120 FIND v(dout1_31) AT=65.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_19ck150 FIND v(dout1_19) AT=80.025n

.meas tran vdout1_20ck150 FIND v(dout1_20) AT=80.025n

.meas tran vdout1_21ck150 FIND v(dout1_21) AT=80.025n

.meas tran vdout1_22ck150 FIND v(dout1_22) AT=80.025n

.meas tran vdout1_23ck150 FIND v(dout1_23) AT=80.025n

.meas tran vdout1_24ck150 FIND v(dout1_24) AT=80.025n

.meas tran vdout1_25ck150 FIND v(dout1_25) AT=80.025n

.meas tran vdout1_26ck150 FIND v(dout1_26) AT=80.025n

.meas tran vdout1_27ck150 FIND v(dout1_27) AT=80.025n

.meas tran vdout1_28ck150 FIND v(dout1_28) AT=80.025n

.meas tran vdout1_29ck150 FIND v(dout1_29) AT=80.025n

.meas tran vdout1_30ck150 FIND v(dout1_30) AT=80.025n

.meas tran vdout1_31ck150 FIND v(dout1_31) AT=80.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_17ck160 FIND v(dout1_17) AT=85.025n

.meas tran vdout1_18ck160 FIND v(dout1_18) AT=85.025n

.meas tran vdout1_19ck160 FIND v(dout1_19) AT=85.025n

.meas tran vdout1_20ck160 FIND v(dout1_20) AT=85.025n

.meas tran vdout1_21ck160 FIND v(dout1_21) AT=85.025n

.meas tran vdout1_22ck160 FIND v(dout1_22) AT=85.025n

.meas tran vdout1_23ck160 FIND v(dout1_23) AT=85.025n

.meas tran vdout1_24ck160 FIND v(dout1_24) AT=85.025n

.meas tran vdout1_25ck160 FIND v(dout1_25) AT=85.025n

.meas tran vdout1_26ck160 FIND v(dout1_26) AT=85.025n

.meas tran vdout1_27ck160 FIND v(dout1_27) AT=85.025n

.meas tran vdout1_28ck160 FIND v(dout1_28) AT=85.025n

.meas tran vdout1_29ck160 FIND v(dout1_29) AT=85.025n

.meas tran vdout1_30ck160 FIND v(dout1_30) AT=85.025n

.meas tran vdout1_31ck160 FIND v(dout1_31) AT=85.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_0ck220 FIND v(dout1_0) AT=115.025n

.meas tran vdout1_1ck220 FIND v(dout1_1) AT=115.025n

.meas tran vdout1_2ck220 FIND v(dout1_2) AT=115.025n

.meas tran vdout1_3ck220 FIND v(dout1_3) AT=115.025n

.meas tran vdout1_4ck220 FIND v(dout1_4) AT=115.025n

.meas tran vdout1_5ck220 FIND v(dout1_5) AT=115.025n

.meas tran vdout1_6ck220 FIND v(dout1_6) AT=115.025n

.meas tran vdout1_7ck220 FIND v(dout1_7) AT=115.025n

.meas tran vdout1_8ck220 FIND v(dout1_8) AT=115.025n

.meas tran vdout1_9ck220 FIND v(dout1_9) AT=115.025n

.meas tran vdout1_10ck220 FIND v(dout1_10) AT=115.025n

.meas tran vdout1_11ck220 FIND v(dout1_11) AT=115.025n

.meas tran vdout1_12ck220 FIND v(dout1_12) AT=115.025n

.meas tran vdout1_13ck220 FIND v(dout1_13) AT=115.025n

.meas tran vdout1_14ck220 FIND v(dout1_14) AT=115.025n

.meas tran vdout1_15ck220 FIND v(dout1_15) AT=115.025n

.meas tran vdout1_16ck220 FIND v(dout1_16) AT=115.025n

.meas tran vdout1_17ck220 FIND v(dout1_17) AT=115.025n

.meas tran vdout1_18ck220 FIND v(dout1_18) AT=115.025n

.meas tran vdout1_19ck220 FIND v(dout1_19) AT=115.025n

.meas tran vdout1_20ck220 FIND v(dout1_20) AT=115.025n

.meas tran vdout1_21ck220 FIND v(dout1_21) AT=115.025n

.meas tran vdout1_22ck220 FIND v(dout1_22) AT=115.025n

.meas tran vdout1_23ck220 FIND v(dout1_23) AT=115.025n

.meas tran vdout1_24ck220 FIND v(dout1_24) AT=115.025n

.meas tran vdout1_25ck220 FIND v(dout1_25) AT=115.025n

.meas tran vdout1_26ck220 FIND v(dout1_26) AT=115.025n

.meas tran vdout1_27ck220 FIND v(dout1_27) AT=115.025n

.meas tran vdout1_28ck220 FIND v(dout1_28) AT=115.025n

.meas tran vdout1_29ck220 FIND v(dout1_29) AT=115.025n

.meas tran vdout1_30ck220 FIND v(dout1_30) AT=115.025n

.meas tran vdout1_31ck220 FIND v(dout1_31) AT=115.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_17ck250 FIND v(dout1_17) AT=130.025n

.meas tran vdout1_18ck250 FIND v(dout1_18) AT=130.025n

.meas tran vdout1_19ck250 FIND v(dout1_19) AT=130.025n

.meas tran vdout1_20ck250 FIND v(dout1_20) AT=130.025n

.meas tran vdout1_21ck250 FIND v(dout1_21) AT=130.025n

.meas tran vdout1_22ck250 FIND v(dout1_22) AT=130.025n

.meas tran vdout1_23ck250 FIND v(dout1_23) AT=130.025n

.meas tran vdout1_24ck250 FIND v(dout1_24) AT=130.025n

.meas tran vdout1_25ck250 FIND v(dout1_25) AT=130.025n

.meas tran vdout1_26ck250 FIND v(dout1_26) AT=130.025n

.meas tran vdout1_27ck250 FIND v(dout1_27) AT=130.025n

.meas tran vdout1_28ck250 FIND v(dout1_28) AT=130.025n

.meas tran vdout1_29ck250 FIND v(dout1_29) AT=130.025n

.meas tran vdout1_30ck250 FIND v(dout1_30) AT=130.025n

.meas tran vdout1_31ck250 FIND v(dout1_31) AT=130.025n

.meas tran vdout1_0ck280 FIND v(dout1_0) AT=145.025n

.meas tran vdout1_1ck280 FIND v(dout1_1) AT=145.025n

.meas tran vdout1_2ck280 FIND v(dout1_2) AT=145.025n

.meas tran vdout1_3ck280 FIND v(dout1_3) AT=145.025n

.meas tran vdout1_4ck280 FIND v(dout1_4) AT=145.025n

.meas tran vdout1_5ck280 FIND v(dout1_5) AT=145.025n

.meas tran vdout1_6ck280 FIND v(dout1_6) AT=145.025n

.meas tran vdout1_7ck280 FIND v(dout1_7) AT=145.025n

.meas tran vdout1_8ck280 FIND v(dout1_8) AT=145.025n

.meas tran vdout1_9ck280 FIND v(dout1_9) AT=145.025n

.meas tran vdout1_10ck280 FIND v(dout1_10) AT=145.025n

.meas tran vdout1_11ck280 FIND v(dout1_11) AT=145.025n

.meas tran vdout1_12ck280 FIND v(dout1_12) AT=145.025n

.meas tran vdout1_13ck280 FIND v(dout1_13) AT=145.025n

.meas tran vdout1_14ck280 FIND v(dout1_14) AT=145.025n

.meas tran vdout1_15ck280 FIND v(dout1_15) AT=145.025n

.meas tran vdout1_16ck280 FIND v(dout1_16) AT=145.025n

.meas tran vdout1_17ck280 FIND v(dout1_17) AT=145.025n

.meas tran vdout1_18ck280 FIND v(dout1_18) AT=145.025n

.meas tran vdout1_19ck280 FIND v(dout1_19) AT=145.025n

.meas tran vdout1_20ck280 FIND v(dout1_20) AT=145.025n

.meas tran vdout1_21ck280 FIND v(dout1_21) AT=145.025n

.meas tran vdout1_22ck280 FIND v(dout1_22) AT=145.025n

.meas tran vdout1_23ck280 FIND v(dout1_23) AT=145.025n

.meas tran vdout1_24ck280 FIND v(dout1_24) AT=145.025n

.meas tran vdout1_25ck280 FIND v(dout1_25) AT=145.025n

.meas tran vdout1_26ck280 FIND v(dout1_26) AT=145.025n

.meas tran vdout1_27ck280 FIND v(dout1_27) AT=145.025n

.meas tran vdout1_28ck280 FIND v(dout1_28) AT=145.025n

.meas tran vdout1_29ck280 FIND v(dout1_29) AT=145.025n

.meas tran vdout1_30ck280 FIND v(dout1_30) AT=145.025n

.meas tran vdout1_31ck280 FIND v(dout1_31) AT=145.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_23ck310 FIND v(dout1_23) AT=160.025n

.meas tran vdout1_24ck310 FIND v(dout1_24) AT=160.025n

.meas tran vdout1_25ck310 FIND v(dout1_25) AT=160.025n

.meas tran vdout1_26ck310 FIND v(dout1_26) AT=160.025n

.meas tran vdout1_27ck310 FIND v(dout1_27) AT=160.025n

.meas tran vdout1_28ck310 FIND v(dout1_28) AT=160.025n

.meas tran vdout1_29ck310 FIND v(dout1_29) AT=160.025n

.meas tran vdout1_30ck310 FIND v(dout1_30) AT=160.025n

.meas tran vdout1_31ck310 FIND v(dout1_31) AT=160.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_17ck330 FIND v(dout1_17) AT=170.025n

.meas tran vdout1_18ck330 FIND v(dout1_18) AT=170.025n

.meas tran vdout1_19ck330 FIND v(dout1_19) AT=170.025n

.meas tran vdout1_20ck330 FIND v(dout1_20) AT=170.025n

.meas tran vdout1_21ck330 FIND v(dout1_21) AT=170.025n

.meas tran vdout1_22ck330 FIND v(dout1_22) AT=170.025n

.meas tran vdout1_23ck330 FIND v(dout1_23) AT=170.025n

.meas tran vdout1_24ck330 FIND v(dout1_24) AT=170.025n

.meas tran vdout1_25ck330 FIND v(dout1_25) AT=170.025n

.meas tran vdout1_26ck330 FIND v(dout1_26) AT=170.025n

.meas tran vdout1_27ck330 FIND v(dout1_27) AT=170.025n

.meas tran vdout1_28ck330 FIND v(dout1_28) AT=170.025n

.meas tran vdout1_29ck330 FIND v(dout1_29) AT=170.025n

.meas tran vdout1_30ck330 FIND v(dout1_30) AT=170.025n

.meas tran vdout1_31ck330 FIND v(dout1_31) AT=170.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_23ck360 FIND v(dout1_23) AT=185.025n

.meas tran vdout1_24ck360 FIND v(dout1_24) AT=185.025n

.meas tran vdout1_25ck360 FIND v(dout1_25) AT=185.025n

.meas tran vdout1_26ck360 FIND v(dout1_26) AT=185.025n

.meas tran vdout1_27ck360 FIND v(dout1_27) AT=185.025n

.meas tran vdout1_28ck360 FIND v(dout1_28) AT=185.025n

.meas tran vdout1_29ck360 FIND v(dout1_29) AT=185.025n

.meas tran vdout1_30ck360 FIND v(dout1_30) AT=185.025n

.meas tran vdout1_31ck360 FIND v(dout1_31) AT=185.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_22ck370 FIND v(dout1_22) AT=190.025n

.meas tran vdout1_23ck370 FIND v(dout1_23) AT=190.025n

.meas tran vdout1_24ck370 FIND v(dout1_24) AT=190.025n

.meas tran vdout1_25ck370 FIND v(dout1_25) AT=190.025n

.meas tran vdout1_26ck370 FIND v(dout1_26) AT=190.025n

.meas tran vdout1_27ck370 FIND v(dout1_27) AT=190.025n

.meas tran vdout1_28ck370 FIND v(dout1_28) AT=190.025n

.meas tran vdout1_29ck370 FIND v(dout1_29) AT=190.025n

.meas tran vdout1_30ck370 FIND v(dout1_30) AT=190.025n

.meas tran vdout1_31ck370 FIND v(dout1_31) AT=190.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_23ck380 FIND v(dout1_23) AT=195.025n

.meas tran vdout1_24ck380 FIND v(dout1_24) AT=195.025n

.meas tran vdout1_25ck380 FIND v(dout1_25) AT=195.025n

.meas tran vdout1_26ck380 FIND v(dout1_26) AT=195.025n

.meas tran vdout1_27ck380 FIND v(dout1_27) AT=195.025n

.meas tran vdout1_28ck380 FIND v(dout1_28) AT=195.025n

.meas tran vdout1_29ck380 FIND v(dout1_29) AT=195.025n

.meas tran vdout1_30ck380 FIND v(dout1_30) AT=195.025n

.meas tran vdout1_31ck380 FIND v(dout1_31) AT=195.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_19ck400 FIND v(dout1_19) AT=205.025n

.meas tran vdout1_20ck400 FIND v(dout1_20) AT=205.025n

.meas tran vdout1_21ck400 FIND v(dout1_21) AT=205.025n

.meas tran vdout1_22ck400 FIND v(dout1_22) AT=205.025n

.meas tran vdout1_23ck400 FIND v(dout1_23) AT=205.025n

.meas tran vdout1_24ck400 FIND v(dout1_24) AT=205.025n

.meas tran vdout1_25ck400 FIND v(dout1_25) AT=205.025n

.meas tran vdout1_26ck400 FIND v(dout1_26) AT=205.025n

.meas tran vdout1_27ck400 FIND v(dout1_27) AT=205.025n

.meas tran vdout1_28ck400 FIND v(dout1_28) AT=205.025n

.meas tran vdout1_29ck400 FIND v(dout1_29) AT=205.025n

.meas tran vdout1_30ck400 FIND v(dout1_30) AT=205.025n

.meas tran vdout1_31ck400 FIND v(dout1_31) AT=205.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_17ck410 FIND v(dout1_17) AT=210.025n

.meas tran vdout1_18ck410 FIND v(dout1_18) AT=210.025n

.meas tran vdout1_19ck410 FIND v(dout1_19) AT=210.025n

.meas tran vdout1_20ck410 FIND v(dout1_20) AT=210.025n

.meas tran vdout1_21ck410 FIND v(dout1_21) AT=210.025n

.meas tran vdout1_22ck410 FIND v(dout1_22) AT=210.025n

.meas tran vdout1_23ck410 FIND v(dout1_23) AT=210.025n

.meas tran vdout1_24ck410 FIND v(dout1_24) AT=210.025n

.meas tran vdout1_25ck410 FIND v(dout1_25) AT=210.025n

.meas tran vdout1_26ck410 FIND v(dout1_26) AT=210.025n

.meas tran vdout1_27ck410 FIND v(dout1_27) AT=210.025n

.meas tran vdout1_28ck410 FIND v(dout1_28) AT=210.025n

.meas tran vdout1_29ck410 FIND v(dout1_29) AT=210.025n

.meas tran vdout1_30ck410 FIND v(dout1_30) AT=210.025n

.meas tran vdout1_31ck410 FIND v(dout1_31) AT=210.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_19ck420 FIND v(dout1_19) AT=215.025n

.meas tran vdout1_20ck420 FIND v(dout1_20) AT=215.025n

.meas tran vdout1_21ck420 FIND v(dout1_21) AT=215.025n

.meas tran vdout1_22ck420 FIND v(dout1_22) AT=215.025n

.meas tran vdout1_23ck420 FIND v(dout1_23) AT=215.025n

.meas tran vdout1_24ck420 FIND v(dout1_24) AT=215.025n

.meas tran vdout1_25ck420 FIND v(dout1_25) AT=215.025n

.meas tran vdout1_26ck420 FIND v(dout1_26) AT=215.025n

.meas tran vdout1_27ck420 FIND v(dout1_27) AT=215.025n

.meas tran vdout1_28ck420 FIND v(dout1_28) AT=215.025n

.meas tran vdout1_29ck420 FIND v(dout1_29) AT=215.025n

.meas tran vdout1_30ck420 FIND v(dout1_30) AT=215.025n

.meas tran vdout1_31ck420 FIND v(dout1_31) AT=215.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_16ck460 FIND v(dout1_16) AT=235.025n

.meas tran vdout1_17ck460 FIND v(dout1_17) AT=235.025n

.meas tran vdout1_18ck460 FIND v(dout1_18) AT=235.025n

.meas tran vdout1_19ck460 FIND v(dout1_19) AT=235.025n

.meas tran vdout1_20ck460 FIND v(dout1_20) AT=235.025n

.meas tran vdout1_21ck460 FIND v(dout1_21) AT=235.025n

.meas tran vdout1_22ck460 FIND v(dout1_22) AT=235.025n

.meas tran vdout1_23ck460 FIND v(dout1_23) AT=235.025n

.meas tran vdout1_24ck460 FIND v(dout1_24) AT=235.025n

.meas tran vdout1_25ck460 FIND v(dout1_25) AT=235.025n

.meas tran vdout1_26ck460 FIND v(dout1_26) AT=235.025n

.meas tran vdout1_27ck460 FIND v(dout1_27) AT=235.025n

.meas tran vdout1_28ck460 FIND v(dout1_28) AT=235.025n

.meas tran vdout1_29ck460 FIND v(dout1_29) AT=235.025n

.meas tran vdout1_30ck460 FIND v(dout1_30) AT=235.025n

.meas tran vdout1_31ck460 FIND v(dout1_31) AT=235.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_22ck480 FIND v(dout1_22) AT=245.025n

.meas tran vdout1_23ck480 FIND v(dout1_23) AT=245.025n

.meas tran vdout1_24ck480 FIND v(dout1_24) AT=245.025n

.meas tran vdout1_25ck480 FIND v(dout1_25) AT=245.025n

.meas tran vdout1_26ck480 FIND v(dout1_26) AT=245.025n

.meas tran vdout1_27ck480 FIND v(dout1_27) AT=245.025n

.meas tran vdout1_28ck480 FIND v(dout1_28) AT=245.025n

.meas tran vdout1_29ck480 FIND v(dout1_29) AT=245.025n

.meas tran vdout1_30ck480 FIND v(dout1_30) AT=245.025n

.meas tran vdout1_31ck480 FIND v(dout1_31) AT=245.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_22ck510 FIND v(dout1_22) AT=260.025n

.meas tran vdout1_23ck510 FIND v(dout1_23) AT=260.025n

.meas tran vdout1_24ck510 FIND v(dout1_24) AT=260.025n

.meas tran vdout1_25ck510 FIND v(dout1_25) AT=260.025n

.meas tran vdout1_26ck510 FIND v(dout1_26) AT=260.025n

.meas tran vdout1_27ck510 FIND v(dout1_27) AT=260.025n

.meas tran vdout1_28ck510 FIND v(dout1_28) AT=260.025n

.meas tran vdout1_29ck510 FIND v(dout1_29) AT=260.025n

.meas tran vdout1_30ck510 FIND v(dout1_30) AT=260.025n

.meas tran vdout1_31ck510 FIND v(dout1_31) AT=260.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_8ck520 FIND v(dout1_8) AT=265.025n

.meas tran vdout1_9ck520 FIND v(dout1_9) AT=265.025n

.meas tran vdout1_10ck520 FIND v(dout1_10) AT=265.025n

.meas tran vdout1_11ck520 FIND v(dout1_11) AT=265.025n

.meas tran vdout1_12ck520 FIND v(dout1_12) AT=265.025n

.meas tran vdout1_13ck520 FIND v(dout1_13) AT=265.025n

.meas tran vdout1_14ck520 FIND v(dout1_14) AT=265.025n

.meas tran vdout1_15ck520 FIND v(dout1_15) AT=265.025n

.meas tran vdout1_16ck520 FIND v(dout1_16) AT=265.025n

.meas tran vdout1_17ck520 FIND v(dout1_17) AT=265.025n

.meas tran vdout1_18ck520 FIND v(dout1_18) AT=265.025n

.meas tran vdout1_19ck520 FIND v(dout1_19) AT=265.025n

.meas tran vdout1_20ck520 FIND v(dout1_20) AT=265.025n

.meas tran vdout1_21ck520 FIND v(dout1_21) AT=265.025n

.meas tran vdout1_22ck520 FIND v(dout1_22) AT=265.025n

.meas tran vdout1_23ck520 FIND v(dout1_23) AT=265.025n

.meas tran vdout1_24ck520 FIND v(dout1_24) AT=265.025n

.meas tran vdout1_25ck520 FIND v(dout1_25) AT=265.025n

.meas tran vdout1_26ck520 FIND v(dout1_26) AT=265.025n

.meas tran vdout1_27ck520 FIND v(dout1_27) AT=265.025n

.meas tran vdout1_28ck520 FIND v(dout1_28) AT=265.025n

.meas tran vdout1_29ck520 FIND v(dout1_29) AT=265.025n

.meas tran vdout1_30ck520 FIND v(dout1_30) AT=265.025n

.meas tran vdout1_31ck520 FIND v(dout1_31) AT=265.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_22ck530 FIND v(dout1_22) AT=270.025n

.meas tran vdout1_23ck530 FIND v(dout1_23) AT=270.025n

.meas tran vdout1_24ck530 FIND v(dout1_24) AT=270.025n

.meas tran vdout1_25ck530 FIND v(dout1_25) AT=270.025n

.meas tran vdout1_26ck530 FIND v(dout1_26) AT=270.025n

.meas tran vdout1_27ck530 FIND v(dout1_27) AT=270.025n

.meas tran vdout1_28ck530 FIND v(dout1_28) AT=270.025n

.meas tran vdout1_29ck530 FIND v(dout1_29) AT=270.025n

.meas tran vdout1_30ck530 FIND v(dout1_30) AT=270.025n

.meas tran vdout1_31ck530 FIND v(dout1_31) AT=270.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_0ck560 FIND v(dout1_0) AT=285.025n

.meas tran vdout1_1ck560 FIND v(dout1_1) AT=285.025n

.meas tran vdout1_2ck560 FIND v(dout1_2) AT=285.025n

.meas tran vdout1_3ck560 FIND v(dout1_3) AT=285.025n

.meas tran vdout1_4ck560 FIND v(dout1_4) AT=285.025n

.meas tran vdout1_5ck560 FIND v(dout1_5) AT=285.025n

.meas tran vdout1_6ck560 FIND v(dout1_6) AT=285.025n

.meas tran vdout1_7ck560 FIND v(dout1_7) AT=285.025n

.meas tran vdout1_8ck560 FIND v(dout1_8) AT=285.025n

.meas tran vdout1_9ck560 FIND v(dout1_9) AT=285.025n

.meas tran vdout1_10ck560 FIND v(dout1_10) AT=285.025n

.meas tran vdout1_11ck560 FIND v(dout1_11) AT=285.025n

.meas tran vdout1_12ck560 FIND v(dout1_12) AT=285.025n

.meas tran vdout1_13ck560 FIND v(dout1_13) AT=285.025n

.meas tran vdout1_14ck560 FIND v(dout1_14) AT=285.025n

.meas tran vdout1_15ck560 FIND v(dout1_15) AT=285.025n

.meas tran vdout1_16ck560 FIND v(dout1_16) AT=285.025n

.meas tran vdout1_17ck560 FIND v(dout1_17) AT=285.025n

.meas tran vdout1_18ck560 FIND v(dout1_18) AT=285.025n

.meas tran vdout1_19ck560 FIND v(dout1_19) AT=285.025n

.meas tran vdout1_20ck560 FIND v(dout1_20) AT=285.025n

.meas tran vdout1_21ck560 FIND v(dout1_21) AT=285.025n

.meas tran vdout1_22ck560 FIND v(dout1_22) AT=285.025n

.meas tran vdout1_23ck560 FIND v(dout1_23) AT=285.025n

.meas tran vdout1_24ck560 FIND v(dout1_24) AT=285.025n

.meas tran vdout1_25ck560 FIND v(dout1_25) AT=285.025n

.meas tran vdout1_26ck560 FIND v(dout1_26) AT=285.025n

.meas tran vdout1_27ck560 FIND v(dout1_27) AT=285.025n

.meas tran vdout1_28ck560 FIND v(dout1_28) AT=285.025n

.meas tran vdout1_29ck560 FIND v(dout1_29) AT=285.025n

.meas tran vdout1_30ck560 FIND v(dout1_30) AT=285.025n

.meas tran vdout1_31ck560 FIND v(dout1_31) AT=285.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_23ck580 FIND v(dout1_23) AT=295.025n

.meas tran vdout1_24ck580 FIND v(dout1_24) AT=295.025n

.meas tran vdout1_25ck580 FIND v(dout1_25) AT=295.025n

.meas tran vdout1_26ck580 FIND v(dout1_26) AT=295.025n

.meas tran vdout1_27ck580 FIND v(dout1_27) AT=295.025n

.meas tran vdout1_28ck580 FIND v(dout1_28) AT=295.025n

.meas tran vdout1_29ck580 FIND v(dout1_29) AT=295.025n

.meas tran vdout1_30ck580 FIND v(dout1_30) AT=295.025n

.meas tran vdout1_31ck580 FIND v(dout1_31) AT=295.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_22ck610 FIND v(dout1_22) AT=310.025n

.meas tran vdout1_23ck610 FIND v(dout1_23) AT=310.025n

.meas tran vdout1_24ck610 FIND v(dout1_24) AT=310.025n

.meas tran vdout1_25ck610 FIND v(dout1_25) AT=310.025n

.meas tran vdout1_26ck610 FIND v(dout1_26) AT=310.025n

.meas tran vdout1_27ck610 FIND v(dout1_27) AT=310.025n

.meas tran vdout1_28ck610 FIND v(dout1_28) AT=310.025n

.meas tran vdout1_29ck610 FIND v(dout1_29) AT=310.025n

.meas tran vdout1_30ck610 FIND v(dout1_30) AT=310.025n

.meas tran vdout1_31ck610 FIND v(dout1_31) AT=310.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_8ck620 FIND v(dout1_8) AT=315.025n

.meas tran vdout1_9ck620 FIND v(dout1_9) AT=315.025n

.meas tran vdout1_10ck620 FIND v(dout1_10) AT=315.025n

.meas tran vdout1_11ck620 FIND v(dout1_11) AT=315.025n

.meas tran vdout1_12ck620 FIND v(dout1_12) AT=315.025n

.meas tran vdout1_13ck620 FIND v(dout1_13) AT=315.025n

.meas tran vdout1_14ck620 FIND v(dout1_14) AT=315.025n

.meas tran vdout1_15ck620 FIND v(dout1_15) AT=315.025n

.meas tran vdout1_16ck620 FIND v(dout1_16) AT=315.025n

.meas tran vdout1_17ck620 FIND v(dout1_17) AT=315.025n

.meas tran vdout1_18ck620 FIND v(dout1_18) AT=315.025n

.meas tran vdout1_19ck620 FIND v(dout1_19) AT=315.025n

.meas tran vdout1_20ck620 FIND v(dout1_20) AT=315.025n

.meas tran vdout1_21ck620 FIND v(dout1_21) AT=315.025n

.meas tran vdout1_22ck620 FIND v(dout1_22) AT=315.025n

.meas tran vdout1_23ck620 FIND v(dout1_23) AT=315.025n

.meas tran vdout1_24ck620 FIND v(dout1_24) AT=315.025n

.meas tran vdout1_25ck620 FIND v(dout1_25) AT=315.025n

.meas tran vdout1_26ck620 FIND v(dout1_26) AT=315.025n

.meas tran vdout1_27ck620 FIND v(dout1_27) AT=315.025n

.meas tran vdout1_28ck620 FIND v(dout1_28) AT=315.025n

.meas tran vdout1_29ck620 FIND v(dout1_29) AT=315.025n

.meas tran vdout1_30ck620 FIND v(dout1_30) AT=315.025n

.meas tran vdout1_31ck620 FIND v(dout1_31) AT=315.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_19ck640 FIND v(dout1_19) AT=325.025n

.meas tran vdout1_20ck640 FIND v(dout1_20) AT=325.025n

.meas tran vdout1_21ck640 FIND v(dout1_21) AT=325.025n

.meas tran vdout1_22ck640 FIND v(dout1_22) AT=325.025n

.meas tran vdout1_23ck640 FIND v(dout1_23) AT=325.025n

.meas tran vdout1_24ck640 FIND v(dout1_24) AT=325.025n

.meas tran vdout1_25ck640 FIND v(dout1_25) AT=325.025n

.meas tran vdout1_26ck640 FIND v(dout1_26) AT=325.025n

.meas tran vdout1_27ck640 FIND v(dout1_27) AT=325.025n

.meas tran vdout1_28ck640 FIND v(dout1_28) AT=325.025n

.meas tran vdout1_29ck640 FIND v(dout1_29) AT=325.025n

.meas tran vdout1_30ck640 FIND v(dout1_30) AT=325.025n

.meas tran vdout1_31ck640 FIND v(dout1_31) AT=325.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_22ck660 FIND v(dout1_22) AT=335.025n

.meas tran vdout1_23ck660 FIND v(dout1_23) AT=335.025n

.meas tran vdout1_24ck660 FIND v(dout1_24) AT=335.025n

.meas tran vdout1_25ck660 FIND v(dout1_25) AT=335.025n

.meas tran vdout1_26ck660 FIND v(dout1_26) AT=335.025n

.meas tran vdout1_27ck660 FIND v(dout1_27) AT=335.025n

.meas tran vdout1_28ck660 FIND v(dout1_28) AT=335.025n

.meas tran vdout1_29ck660 FIND v(dout1_29) AT=335.025n

.meas tran vdout1_30ck660 FIND v(dout1_30) AT=335.025n

.meas tran vdout1_31ck660 FIND v(dout1_31) AT=335.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_19ck680 FIND v(dout1_19) AT=345.025n

.meas tran vdout1_20ck680 FIND v(dout1_20) AT=345.025n

.meas tran vdout1_21ck680 FIND v(dout1_21) AT=345.025n

.meas tran vdout1_22ck680 FIND v(dout1_22) AT=345.025n

.meas tran vdout1_23ck680 FIND v(dout1_23) AT=345.025n

.meas tran vdout1_24ck680 FIND v(dout1_24) AT=345.025n

.meas tran vdout1_25ck680 FIND v(dout1_25) AT=345.025n

.meas tran vdout1_26ck680 FIND v(dout1_26) AT=345.025n

.meas tran vdout1_27ck680 FIND v(dout1_27) AT=345.025n

.meas tran vdout1_28ck680 FIND v(dout1_28) AT=345.025n

.meas tran vdout1_29ck680 FIND v(dout1_29) AT=345.025n

.meas tran vdout1_30ck680 FIND v(dout1_30) AT=345.025n

.meas tran vdout1_31ck680 FIND v(dout1_31) AT=345.025n

.meas tran vdout1_0ck690 FIND v(dout1_0) AT=350.025n

.meas tran vdout1_1ck690 FIND v(dout1_1) AT=350.025n

.meas tran vdout1_2ck690 FIND v(dout1_2) AT=350.025n

.meas tran vdout1_3ck690 FIND v(dout1_3) AT=350.025n

.meas tran vdout1_4ck690 FIND v(dout1_4) AT=350.025n

.meas tran vdout1_5ck690 FIND v(dout1_5) AT=350.025n

.meas tran vdout1_6ck690 FIND v(dout1_6) AT=350.025n

.meas tran vdout1_7ck690 FIND v(dout1_7) AT=350.025n

.meas tran vdout1_8ck690 FIND v(dout1_8) AT=350.025n

.meas tran vdout1_9ck690 FIND v(dout1_9) AT=350.025n

.meas tran vdout1_10ck690 FIND v(dout1_10) AT=350.025n

.meas tran vdout1_11ck690 FIND v(dout1_11) AT=350.025n

.meas tran vdout1_12ck690 FIND v(dout1_12) AT=350.025n

.meas tran vdout1_13ck690 FIND v(dout1_13) AT=350.025n

.meas tran vdout1_14ck690 FIND v(dout1_14) AT=350.025n

.meas tran vdout1_15ck690 FIND v(dout1_15) AT=350.025n

.meas tran vdout1_16ck690 FIND v(dout1_16) AT=350.025n

.meas tran vdout1_17ck690 FIND v(dout1_17) AT=350.025n

.meas tran vdout1_18ck690 FIND v(dout1_18) AT=350.025n

.meas tran vdout1_19ck690 FIND v(dout1_19) AT=350.025n

.meas tran vdout1_20ck690 FIND v(dout1_20) AT=350.025n

.meas tran vdout1_21ck690 FIND v(dout1_21) AT=350.025n

.meas tran vdout1_22ck690 FIND v(dout1_22) AT=350.025n

.meas tran vdout1_23ck690 FIND v(dout1_23) AT=350.025n

.meas tran vdout1_24ck690 FIND v(dout1_24) AT=350.025n

.meas tran vdout1_25ck690 FIND v(dout1_25) AT=350.025n

.meas tran vdout1_26ck690 FIND v(dout1_26) AT=350.025n

.meas tran vdout1_27ck690 FIND v(dout1_27) AT=350.025n

.meas tran vdout1_28ck690 FIND v(dout1_28) AT=350.025n

.meas tran vdout1_29ck690 FIND v(dout1_29) AT=350.025n

.meas tran vdout1_30ck690 FIND v(dout1_30) AT=350.025n

.meas tran vdout1_31ck690 FIND v(dout1_31) AT=350.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_22ck720 FIND v(dout1_22) AT=365.025n

.meas tran vdout1_23ck720 FIND v(dout1_23) AT=365.025n

.meas tran vdout1_24ck720 FIND v(dout1_24) AT=365.025n

.meas tran vdout1_25ck720 FIND v(dout1_25) AT=365.025n

.meas tran vdout1_26ck720 FIND v(dout1_26) AT=365.025n

.meas tran vdout1_27ck720 FIND v(dout1_27) AT=365.025n

.meas tran vdout1_28ck720 FIND v(dout1_28) AT=365.025n

.meas tran vdout1_29ck720 FIND v(dout1_29) AT=365.025n

.meas tran vdout1_30ck720 FIND v(dout1_30) AT=365.025n

.meas tran vdout1_31ck720 FIND v(dout1_31) AT=365.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_17ck730 FIND v(dout1_17) AT=370.025n

.meas tran vdout1_18ck730 FIND v(dout1_18) AT=370.025n

.meas tran vdout1_19ck730 FIND v(dout1_19) AT=370.025n

.meas tran vdout1_20ck730 FIND v(dout1_20) AT=370.025n

.meas tran vdout1_21ck730 FIND v(dout1_21) AT=370.025n

.meas tran vdout1_22ck730 FIND v(dout1_22) AT=370.025n

.meas tran vdout1_23ck730 FIND v(dout1_23) AT=370.025n

.meas tran vdout1_24ck730 FIND v(dout1_24) AT=370.025n

.meas tran vdout1_25ck730 FIND v(dout1_25) AT=370.025n

.meas tran vdout1_26ck730 FIND v(dout1_26) AT=370.025n

.meas tran vdout1_27ck730 FIND v(dout1_27) AT=370.025n

.meas tran vdout1_28ck730 FIND v(dout1_28) AT=370.025n

.meas tran vdout1_29ck730 FIND v(dout1_29) AT=370.025n

.meas tran vdout1_30ck730 FIND v(dout1_30) AT=370.025n

.meas tran vdout1_31ck730 FIND v(dout1_31) AT=370.025n

.meas tran vdout1_0ck750 FIND v(dout1_0) AT=380.025n

.meas tran vdout1_1ck750 FIND v(dout1_1) AT=380.025n

.meas tran vdout1_2ck750 FIND v(dout1_2) AT=380.025n

.meas tran vdout1_3ck750 FIND v(dout1_3) AT=380.025n

.meas tran vdout1_4ck750 FIND v(dout1_4) AT=380.025n

.meas tran vdout1_5ck750 FIND v(dout1_5) AT=380.025n

.meas tran vdout1_6ck750 FIND v(dout1_6) AT=380.025n

.meas tran vdout1_7ck750 FIND v(dout1_7) AT=380.025n

.meas tran vdout1_8ck750 FIND v(dout1_8) AT=380.025n

.meas tran vdout1_9ck750 FIND v(dout1_9) AT=380.025n

.meas tran vdout1_10ck750 FIND v(dout1_10) AT=380.025n

.meas tran vdout1_11ck750 FIND v(dout1_11) AT=380.025n

.meas tran vdout1_12ck750 FIND v(dout1_12) AT=380.025n

.meas tran vdout1_13ck750 FIND v(dout1_13) AT=380.025n

.meas tran vdout1_14ck750 FIND v(dout1_14) AT=380.025n

.meas tran vdout1_15ck750 FIND v(dout1_15) AT=380.025n

.meas tran vdout1_16ck750 FIND v(dout1_16) AT=380.025n

.meas tran vdout1_17ck750 FIND v(dout1_17) AT=380.025n

.meas tran vdout1_18ck750 FIND v(dout1_18) AT=380.025n

.meas tran vdout1_19ck750 FIND v(dout1_19) AT=380.025n

.meas tran vdout1_20ck750 FIND v(dout1_20) AT=380.025n

.meas tran vdout1_21ck750 FIND v(dout1_21) AT=380.025n

.meas tran vdout1_22ck750 FIND v(dout1_22) AT=380.025n

.meas tran vdout1_23ck750 FIND v(dout1_23) AT=380.025n

.meas tran vdout1_24ck750 FIND v(dout1_24) AT=380.025n

.meas tran vdout1_25ck750 FIND v(dout1_25) AT=380.025n

.meas tran vdout1_26ck750 FIND v(dout1_26) AT=380.025n

.meas tran vdout1_27ck750 FIND v(dout1_27) AT=380.025n

.meas tran vdout1_28ck750 FIND v(dout1_28) AT=380.025n

.meas tran vdout1_29ck750 FIND v(dout1_29) AT=380.025n

.meas tran vdout1_30ck750 FIND v(dout1_30) AT=380.025n

.meas tran vdout1_31ck750 FIND v(dout1_31) AT=380.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_23ck770 FIND v(dout1_23) AT=390.025n

.meas tran vdout1_24ck770 FIND v(dout1_24) AT=390.025n

.meas tran vdout1_25ck770 FIND v(dout1_25) AT=390.025n

.meas tran vdout1_26ck770 FIND v(dout1_26) AT=390.025n

.meas tran vdout1_27ck770 FIND v(dout1_27) AT=390.025n

.meas tran vdout1_28ck770 FIND v(dout1_28) AT=390.025n

.meas tran vdout1_29ck770 FIND v(dout1_29) AT=390.025n

.meas tran vdout1_30ck770 FIND v(dout1_30) AT=390.025n

.meas tran vdout1_31ck770 FIND v(dout1_31) AT=390.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_8ck800 FIND v(dout1_8) AT=405.025n

.meas tran vdout1_9ck800 FIND v(dout1_9) AT=405.025n

.meas tran vdout1_10ck800 FIND v(dout1_10) AT=405.025n

.meas tran vdout1_11ck800 FIND v(dout1_11) AT=405.025n

.meas tran vdout1_12ck800 FIND v(dout1_12) AT=405.025n

.meas tran vdout1_13ck800 FIND v(dout1_13) AT=405.025n

.meas tran vdout1_14ck800 FIND v(dout1_14) AT=405.025n

.meas tran vdout1_15ck800 FIND v(dout1_15) AT=405.025n

.meas tran vdout1_16ck800 FIND v(dout1_16) AT=405.025n

.meas tran vdout1_17ck800 FIND v(dout1_17) AT=405.025n

.meas tran vdout1_18ck800 FIND v(dout1_18) AT=405.025n

.meas tran vdout1_19ck800 FIND v(dout1_19) AT=405.025n

.meas tran vdout1_20ck800 FIND v(dout1_20) AT=405.025n

.meas tran vdout1_21ck800 FIND v(dout1_21) AT=405.025n

.meas tran vdout1_22ck800 FIND v(dout1_22) AT=405.025n

.meas tran vdout1_23ck800 FIND v(dout1_23) AT=405.025n

.meas tran vdout1_24ck800 FIND v(dout1_24) AT=405.025n

.meas tran vdout1_25ck800 FIND v(dout1_25) AT=405.025n

.meas tran vdout1_26ck800 FIND v(dout1_26) AT=405.025n

.meas tran vdout1_27ck800 FIND v(dout1_27) AT=405.025n

.meas tran vdout1_28ck800 FIND v(dout1_28) AT=405.025n

.meas tran vdout1_29ck800 FIND v(dout1_29) AT=405.025n

.meas tran vdout1_30ck800 FIND v(dout1_30) AT=405.025n

.meas tran vdout1_31ck800 FIND v(dout1_31) AT=405.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_16ck820 FIND v(dout1_16) AT=415.025n

.meas tran vdout1_17ck820 FIND v(dout1_17) AT=415.025n

.meas tran vdout1_18ck820 FIND v(dout1_18) AT=415.025n

.meas tran vdout1_19ck820 FIND v(dout1_19) AT=415.025n

.meas tran vdout1_20ck820 FIND v(dout1_20) AT=415.025n

.meas tran vdout1_21ck820 FIND v(dout1_21) AT=415.025n

.meas tran vdout1_22ck820 FIND v(dout1_22) AT=415.025n

.meas tran vdout1_23ck820 FIND v(dout1_23) AT=415.025n

.meas tran vdout1_24ck820 FIND v(dout1_24) AT=415.025n

.meas tran vdout1_25ck820 FIND v(dout1_25) AT=415.025n

.meas tran vdout1_26ck820 FIND v(dout1_26) AT=415.025n

.meas tran vdout1_27ck820 FIND v(dout1_27) AT=415.025n

.meas tran vdout1_28ck820 FIND v(dout1_28) AT=415.025n

.meas tran vdout1_29ck820 FIND v(dout1_29) AT=415.025n

.meas tran vdout1_30ck820 FIND v(dout1_30) AT=415.025n

.meas tran vdout1_31ck820 FIND v(dout1_31) AT=415.025n

.meas tran vdout1_0ck840 FIND v(dout1_0) AT=425.025n

.meas tran vdout1_1ck840 FIND v(dout1_1) AT=425.025n

.meas tran vdout1_2ck840 FIND v(dout1_2) AT=425.025n

.meas tran vdout1_3ck840 FIND v(dout1_3) AT=425.025n

.meas tran vdout1_4ck840 FIND v(dout1_4) AT=425.025n

.meas tran vdout1_5ck840 FIND v(dout1_5) AT=425.025n

.meas tran vdout1_6ck840 FIND v(dout1_6) AT=425.025n

.meas tran vdout1_7ck840 FIND v(dout1_7) AT=425.025n

.meas tran vdout1_8ck840 FIND v(dout1_8) AT=425.025n

.meas tran vdout1_9ck840 FIND v(dout1_9) AT=425.025n

.meas tran vdout1_10ck840 FIND v(dout1_10) AT=425.025n

.meas tran vdout1_11ck840 FIND v(dout1_11) AT=425.025n

.meas tran vdout1_12ck840 FIND v(dout1_12) AT=425.025n

.meas tran vdout1_13ck840 FIND v(dout1_13) AT=425.025n

.meas tran vdout1_14ck840 FIND v(dout1_14) AT=425.025n

.meas tran vdout1_15ck840 FIND v(dout1_15) AT=425.025n

.meas tran vdout1_16ck840 FIND v(dout1_16) AT=425.025n

.meas tran vdout1_17ck840 FIND v(dout1_17) AT=425.025n

.meas tran vdout1_18ck840 FIND v(dout1_18) AT=425.025n

.meas tran vdout1_19ck840 FIND v(dout1_19) AT=425.025n

.meas tran vdout1_20ck840 FIND v(dout1_20) AT=425.025n

.meas tran vdout1_21ck840 FIND v(dout1_21) AT=425.025n

.meas tran vdout1_22ck840 FIND v(dout1_22) AT=425.025n

.meas tran vdout1_23ck840 FIND v(dout1_23) AT=425.025n

.meas tran vdout1_24ck840 FIND v(dout1_24) AT=425.025n

.meas tran vdout1_25ck840 FIND v(dout1_25) AT=425.025n

.meas tran vdout1_26ck840 FIND v(dout1_26) AT=425.025n

.meas tran vdout1_27ck840 FIND v(dout1_27) AT=425.025n

.meas tran vdout1_28ck840 FIND v(dout1_28) AT=425.025n

.meas tran vdout1_29ck840 FIND v(dout1_29) AT=425.025n

.meas tran vdout1_30ck840 FIND v(dout1_30) AT=425.025n

.meas tran vdout1_31ck840 FIND v(dout1_31) AT=425.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_19ck850 FIND v(dout1_19) AT=430.025n

.meas tran vdout1_20ck850 FIND v(dout1_20) AT=430.025n

.meas tran vdout1_21ck850 FIND v(dout1_21) AT=430.025n

.meas tran vdout1_22ck850 FIND v(dout1_22) AT=430.025n

.meas tran vdout1_23ck850 FIND v(dout1_23) AT=430.025n

.meas tran vdout1_24ck850 FIND v(dout1_24) AT=430.025n

.meas tran vdout1_25ck850 FIND v(dout1_25) AT=430.025n

.meas tran vdout1_26ck850 FIND v(dout1_26) AT=430.025n

.meas tran vdout1_27ck850 FIND v(dout1_27) AT=430.025n

.meas tran vdout1_28ck850 FIND v(dout1_28) AT=430.025n

.meas tran vdout1_29ck850 FIND v(dout1_29) AT=430.025n

.meas tran vdout1_30ck850 FIND v(dout1_30) AT=430.025n

.meas tran vdout1_31ck850 FIND v(dout1_31) AT=430.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_16ck920 FIND v(dout1_16) AT=465.025n

.meas tran vdout1_17ck920 FIND v(dout1_17) AT=465.025n

.meas tran vdout1_18ck920 FIND v(dout1_18) AT=465.025n

.meas tran vdout1_19ck920 FIND v(dout1_19) AT=465.025n

.meas tran vdout1_20ck920 FIND v(dout1_20) AT=465.025n

.meas tran vdout1_21ck920 FIND v(dout1_21) AT=465.025n

.meas tran vdout1_22ck920 FIND v(dout1_22) AT=465.025n

.meas tran vdout1_23ck920 FIND v(dout1_23) AT=465.025n

.meas tran vdout1_24ck920 FIND v(dout1_24) AT=465.025n

.meas tran vdout1_25ck920 FIND v(dout1_25) AT=465.025n

.meas tran vdout1_26ck920 FIND v(dout1_26) AT=465.025n

.meas tran vdout1_27ck920 FIND v(dout1_27) AT=465.025n

.meas tran vdout1_28ck920 FIND v(dout1_28) AT=465.025n

.meas tran vdout1_29ck920 FIND v(dout1_29) AT=465.025n

.meas tran vdout1_30ck920 FIND v(dout1_30) AT=465.025n

.meas tran vdout1_31ck920 FIND v(dout1_31) AT=465.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_16ck980 FIND v(dout1_16) AT=495.025n

.meas tran vdout1_17ck980 FIND v(dout1_17) AT=495.025n

.meas tran vdout1_18ck980 FIND v(dout1_18) AT=495.025n

.meas tran vdout1_19ck980 FIND v(dout1_19) AT=495.025n

.meas tran vdout1_20ck980 FIND v(dout1_20) AT=495.025n

.meas tran vdout1_21ck980 FIND v(dout1_21) AT=495.025n

.meas tran vdout1_22ck980 FIND v(dout1_22) AT=495.025n

.meas tran vdout1_23ck980 FIND v(dout1_23) AT=495.025n

.meas tran vdout1_24ck980 FIND v(dout1_24) AT=495.025n

.meas tran vdout1_25ck980 FIND v(dout1_25) AT=495.025n

.meas tran vdout1_26ck980 FIND v(dout1_26) AT=495.025n

.meas tran vdout1_27ck980 FIND v(dout1_27) AT=495.025n

.meas tran vdout1_28ck980 FIND v(dout1_28) AT=495.025n

.meas tran vdout1_29ck980 FIND v(dout1_29) AT=495.025n

.meas tran vdout1_30ck980 FIND v(dout1_30) AT=495.025n

.meas tran vdout1_31ck980 FIND v(dout1_31) AT=495.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_17ck1020 FIND v(dout1_17) AT=515.025n

.meas tran vdout1_18ck1020 FIND v(dout1_18) AT=515.025n

.meas tran vdout1_19ck1020 FIND v(dout1_19) AT=515.025n

.meas tran vdout1_20ck1020 FIND v(dout1_20) AT=515.025n

.meas tran vdout1_21ck1020 FIND v(dout1_21) AT=515.025n

.meas tran vdout1_22ck1020 FIND v(dout1_22) AT=515.025n

.meas tran vdout1_23ck1020 FIND v(dout1_23) AT=515.025n

.meas tran vdout1_24ck1020 FIND v(dout1_24) AT=515.025n

.meas tran vdout1_25ck1020 FIND v(dout1_25) AT=515.025n

.meas tran vdout1_26ck1020 FIND v(dout1_26) AT=515.025n

.meas tran vdout1_27ck1020 FIND v(dout1_27) AT=515.025n

.meas tran vdout1_28ck1020 FIND v(dout1_28) AT=515.025n

.meas tran vdout1_29ck1020 FIND v(dout1_29) AT=515.025n

.meas tran vdout1_30ck1020 FIND v(dout1_30) AT=515.025n

.meas tran vdout1_31ck1020 FIND v(dout1_31) AT=515.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_16ck1030 FIND v(dout1_16) AT=520.025n

.meas tran vdout1_17ck1030 FIND v(dout1_17) AT=520.025n

.meas tran vdout1_18ck1030 FIND v(dout1_18) AT=520.025n

.meas tran vdout1_19ck1030 FIND v(dout1_19) AT=520.025n

.meas tran vdout1_20ck1030 FIND v(dout1_20) AT=520.025n

.meas tran vdout1_21ck1030 FIND v(dout1_21) AT=520.025n

.meas tran vdout1_22ck1030 FIND v(dout1_22) AT=520.025n

.meas tran vdout1_23ck1030 FIND v(dout1_23) AT=520.025n

.meas tran vdout1_24ck1030 FIND v(dout1_24) AT=520.025n

.meas tran vdout1_25ck1030 FIND v(dout1_25) AT=520.025n

.meas tran vdout1_26ck1030 FIND v(dout1_26) AT=520.025n

.meas tran vdout1_27ck1030 FIND v(dout1_27) AT=520.025n

.meas tran vdout1_28ck1030 FIND v(dout1_28) AT=520.025n

.meas tran vdout1_29ck1030 FIND v(dout1_29) AT=520.025n

.meas tran vdout1_30ck1030 FIND v(dout1_30) AT=520.025n

.meas tran vdout1_31ck1030 FIND v(dout1_31) AT=520.025n

.meas tran vdout1_0ck1040 FIND v(dout1_0) AT=525.025n

.meas tran vdout1_1ck1040 FIND v(dout1_1) AT=525.025n

.meas tran vdout1_2ck1040 FIND v(dout1_2) AT=525.025n

.meas tran vdout1_3ck1040 FIND v(dout1_3) AT=525.025n

.meas tran vdout1_4ck1040 FIND v(dout1_4) AT=525.025n

.meas tran vdout1_5ck1040 FIND v(dout1_5) AT=525.025n

.meas tran vdout1_6ck1040 FIND v(dout1_6) AT=525.025n

.meas tran vdout1_7ck1040 FIND v(dout1_7) AT=525.025n

.meas tran vdout1_8ck1040 FIND v(dout1_8) AT=525.025n

.meas tran vdout1_9ck1040 FIND v(dout1_9) AT=525.025n

.meas tran vdout1_10ck1040 FIND v(dout1_10) AT=525.025n

.meas tran vdout1_11ck1040 FIND v(dout1_11) AT=525.025n

.meas tran vdout1_12ck1040 FIND v(dout1_12) AT=525.025n

.meas tran vdout1_13ck1040 FIND v(dout1_13) AT=525.025n

.meas tran vdout1_14ck1040 FIND v(dout1_14) AT=525.025n

.meas tran vdout1_15ck1040 FIND v(dout1_15) AT=525.025n

.meas tran vdout1_16ck1040 FIND v(dout1_16) AT=525.025n

.meas tran vdout1_17ck1040 FIND v(dout1_17) AT=525.025n

.meas tran vdout1_18ck1040 FIND v(dout1_18) AT=525.025n

.meas tran vdout1_19ck1040 FIND v(dout1_19) AT=525.025n

.meas tran vdout1_20ck1040 FIND v(dout1_20) AT=525.025n

.meas tran vdout1_21ck1040 FIND v(dout1_21) AT=525.025n

.meas tran vdout1_22ck1040 FIND v(dout1_22) AT=525.025n

.meas tran vdout1_23ck1040 FIND v(dout1_23) AT=525.025n

.meas tran vdout1_24ck1040 FIND v(dout1_24) AT=525.025n

.meas tran vdout1_25ck1040 FIND v(dout1_25) AT=525.025n

.meas tran vdout1_26ck1040 FIND v(dout1_26) AT=525.025n

.meas tran vdout1_27ck1040 FIND v(dout1_27) AT=525.025n

.meas tran vdout1_28ck1040 FIND v(dout1_28) AT=525.025n

.meas tran vdout1_29ck1040 FIND v(dout1_29) AT=525.025n

.meas tran vdout1_30ck1040 FIND v(dout1_30) AT=525.025n

.meas tran vdout1_31ck1040 FIND v(dout1_31) AT=525.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_22ck1060 FIND v(dout1_22) AT=535.025n

.meas tran vdout1_23ck1060 FIND v(dout1_23) AT=535.025n

.meas tran vdout1_24ck1060 FIND v(dout1_24) AT=535.025n

.meas tran vdout1_25ck1060 FIND v(dout1_25) AT=535.025n

.meas tran vdout1_26ck1060 FIND v(dout1_26) AT=535.025n

.meas tran vdout1_27ck1060 FIND v(dout1_27) AT=535.025n

.meas tran vdout1_28ck1060 FIND v(dout1_28) AT=535.025n

.meas tran vdout1_29ck1060 FIND v(dout1_29) AT=535.025n

.meas tran vdout1_30ck1060 FIND v(dout1_30) AT=535.025n

.meas tran vdout1_31ck1060 FIND v(dout1_31) AT=535.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_19ck1080 FIND v(dout1_19) AT=545.025n

.meas tran vdout1_20ck1080 FIND v(dout1_20) AT=545.025n

.meas tran vdout1_21ck1080 FIND v(dout1_21) AT=545.025n

.meas tran vdout1_22ck1080 FIND v(dout1_22) AT=545.025n

.meas tran vdout1_23ck1080 FIND v(dout1_23) AT=545.025n

.meas tran vdout1_24ck1080 FIND v(dout1_24) AT=545.025n

.meas tran vdout1_25ck1080 FIND v(dout1_25) AT=545.025n

.meas tran vdout1_26ck1080 FIND v(dout1_26) AT=545.025n

.meas tran vdout1_27ck1080 FIND v(dout1_27) AT=545.025n

.meas tran vdout1_28ck1080 FIND v(dout1_28) AT=545.025n

.meas tran vdout1_29ck1080 FIND v(dout1_29) AT=545.025n

.meas tran vdout1_30ck1080 FIND v(dout1_30) AT=545.025n

.meas tran vdout1_31ck1080 FIND v(dout1_31) AT=545.025n

.meas tran vdout1_0ck1140 FIND v(dout1_0) AT=575.025n

.meas tran vdout1_1ck1140 FIND v(dout1_1) AT=575.025n

.meas tran vdout1_2ck1140 FIND v(dout1_2) AT=575.025n

.meas tran vdout1_3ck1140 FIND v(dout1_3) AT=575.025n

.meas tran vdout1_4ck1140 FIND v(dout1_4) AT=575.025n

.meas tran vdout1_5ck1140 FIND v(dout1_5) AT=575.025n

.meas tran vdout1_6ck1140 FIND v(dout1_6) AT=575.025n

.meas tran vdout1_7ck1140 FIND v(dout1_7) AT=575.025n

.meas tran vdout1_8ck1140 FIND v(dout1_8) AT=575.025n

.meas tran vdout1_9ck1140 FIND v(dout1_9) AT=575.025n

.meas tran vdout1_10ck1140 FIND v(dout1_10) AT=575.025n

.meas tran vdout1_11ck1140 FIND v(dout1_11) AT=575.025n

.meas tran vdout1_12ck1140 FIND v(dout1_12) AT=575.025n

.meas tran vdout1_13ck1140 FIND v(dout1_13) AT=575.025n

.meas tran vdout1_14ck1140 FIND v(dout1_14) AT=575.025n

.meas tran vdout1_15ck1140 FIND v(dout1_15) AT=575.025n

.meas tran vdout1_16ck1140 FIND v(dout1_16) AT=575.025n

.meas tran vdout1_17ck1140 FIND v(dout1_17) AT=575.025n

.meas tran vdout1_18ck1140 FIND v(dout1_18) AT=575.025n

.meas tran vdout1_19ck1140 FIND v(dout1_19) AT=575.025n

.meas tran vdout1_20ck1140 FIND v(dout1_20) AT=575.025n

.meas tran vdout1_21ck1140 FIND v(dout1_21) AT=575.025n

.meas tran vdout1_22ck1140 FIND v(dout1_22) AT=575.025n

.meas tran vdout1_23ck1140 FIND v(dout1_23) AT=575.025n

.meas tran vdout1_24ck1140 FIND v(dout1_24) AT=575.025n

.meas tran vdout1_25ck1140 FIND v(dout1_25) AT=575.025n

.meas tran vdout1_26ck1140 FIND v(dout1_26) AT=575.025n

.meas tran vdout1_27ck1140 FIND v(dout1_27) AT=575.025n

.meas tran vdout1_28ck1140 FIND v(dout1_28) AT=575.025n

.meas tran vdout1_29ck1140 FIND v(dout1_29) AT=575.025n

.meas tran vdout1_30ck1140 FIND v(dout1_30) AT=575.025n

.meas tran vdout1_31ck1140 FIND v(dout1_31) AT=575.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_8ck1180 FIND v(dout1_8) AT=595.025n

.meas tran vdout1_9ck1180 FIND v(dout1_9) AT=595.025n

.meas tran vdout1_10ck1180 FIND v(dout1_10) AT=595.025n

.meas tran vdout1_11ck1180 FIND v(dout1_11) AT=595.025n

.meas tran vdout1_12ck1180 FIND v(dout1_12) AT=595.025n

.meas tran vdout1_13ck1180 FIND v(dout1_13) AT=595.025n

.meas tran vdout1_14ck1180 FIND v(dout1_14) AT=595.025n

.meas tran vdout1_15ck1180 FIND v(dout1_15) AT=595.025n

.meas tran vdout1_16ck1180 FIND v(dout1_16) AT=595.025n

.meas tran vdout1_17ck1180 FIND v(dout1_17) AT=595.025n

.meas tran vdout1_18ck1180 FIND v(dout1_18) AT=595.025n

.meas tran vdout1_19ck1180 FIND v(dout1_19) AT=595.025n

.meas tran vdout1_20ck1180 FIND v(dout1_20) AT=595.025n

.meas tran vdout1_21ck1180 FIND v(dout1_21) AT=595.025n

.meas tran vdout1_22ck1180 FIND v(dout1_22) AT=595.025n

.meas tran vdout1_23ck1180 FIND v(dout1_23) AT=595.025n

.meas tran vdout1_24ck1180 FIND v(dout1_24) AT=595.025n

.meas tran vdout1_25ck1180 FIND v(dout1_25) AT=595.025n

.meas tran vdout1_26ck1180 FIND v(dout1_26) AT=595.025n

.meas tran vdout1_27ck1180 FIND v(dout1_27) AT=595.025n

.meas tran vdout1_28ck1180 FIND v(dout1_28) AT=595.025n

.meas tran vdout1_29ck1180 FIND v(dout1_29) AT=595.025n

.meas tran vdout1_30ck1180 FIND v(dout1_30) AT=595.025n

.meas tran vdout1_31ck1180 FIND v(dout1_31) AT=595.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_16ck1190 FIND v(dout1_16) AT=600.025n

.meas tran vdout1_17ck1190 FIND v(dout1_17) AT=600.025n

.meas tran vdout1_18ck1190 FIND v(dout1_18) AT=600.025n

.meas tran vdout1_19ck1190 FIND v(dout1_19) AT=600.025n

.meas tran vdout1_20ck1190 FIND v(dout1_20) AT=600.025n

.meas tran vdout1_21ck1190 FIND v(dout1_21) AT=600.025n

.meas tran vdout1_22ck1190 FIND v(dout1_22) AT=600.025n

.meas tran vdout1_23ck1190 FIND v(dout1_23) AT=600.025n

.meas tran vdout1_24ck1190 FIND v(dout1_24) AT=600.025n

.meas tran vdout1_25ck1190 FIND v(dout1_25) AT=600.025n

.meas tran vdout1_26ck1190 FIND v(dout1_26) AT=600.025n

.meas tran vdout1_27ck1190 FIND v(dout1_27) AT=600.025n

.meas tran vdout1_28ck1190 FIND v(dout1_28) AT=600.025n

.meas tran vdout1_29ck1190 FIND v(dout1_29) AT=600.025n

.meas tran vdout1_30ck1190 FIND v(dout1_30) AT=600.025n

.meas tran vdout1_31ck1190 FIND v(dout1_31) AT=600.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_23ck1200 FIND v(dout1_23) AT=605.025n

.meas tran vdout1_24ck1200 FIND v(dout1_24) AT=605.025n

.meas tran vdout1_25ck1200 FIND v(dout1_25) AT=605.025n

.meas tran vdout1_26ck1200 FIND v(dout1_26) AT=605.025n

.meas tran vdout1_27ck1200 FIND v(dout1_27) AT=605.025n

.meas tran vdout1_28ck1200 FIND v(dout1_28) AT=605.025n

.meas tran vdout1_29ck1200 FIND v(dout1_29) AT=605.025n

.meas tran vdout1_30ck1200 FIND v(dout1_30) AT=605.025n

.meas tran vdout1_31ck1200 FIND v(dout1_31) AT=605.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_19ck1240 FIND v(dout1_19) AT=625.025n

.meas tran vdout1_20ck1240 FIND v(dout1_20) AT=625.025n

.meas tran vdout1_21ck1240 FIND v(dout1_21) AT=625.025n

.meas tran vdout1_22ck1240 FIND v(dout1_22) AT=625.025n

.meas tran vdout1_23ck1240 FIND v(dout1_23) AT=625.025n

.meas tran vdout1_24ck1240 FIND v(dout1_24) AT=625.025n

.meas tran vdout1_25ck1240 FIND v(dout1_25) AT=625.025n

.meas tran vdout1_26ck1240 FIND v(dout1_26) AT=625.025n

.meas tran vdout1_27ck1240 FIND v(dout1_27) AT=625.025n

.meas tran vdout1_28ck1240 FIND v(dout1_28) AT=625.025n

.meas tran vdout1_29ck1240 FIND v(dout1_29) AT=625.025n

.meas tran vdout1_30ck1240 FIND v(dout1_30) AT=625.025n

.meas tran vdout1_31ck1240 FIND v(dout1_31) AT=625.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_22ck1280 FIND v(dout1_22) AT=645.025n

.meas tran vdout1_23ck1280 FIND v(dout1_23) AT=645.025n

.meas tran vdout1_24ck1280 FIND v(dout1_24) AT=645.025n

.meas tran vdout1_25ck1280 FIND v(dout1_25) AT=645.025n

.meas tran vdout1_26ck1280 FIND v(dout1_26) AT=645.025n

.meas tran vdout1_27ck1280 FIND v(dout1_27) AT=645.025n

.meas tran vdout1_28ck1280 FIND v(dout1_28) AT=645.025n

.meas tran vdout1_29ck1280 FIND v(dout1_29) AT=645.025n

.meas tran vdout1_30ck1280 FIND v(dout1_30) AT=645.025n

.meas tran vdout1_31ck1280 FIND v(dout1_31) AT=645.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_22ck1300 FIND v(dout1_22) AT=655.025n

.meas tran vdout1_23ck1300 FIND v(dout1_23) AT=655.025n

.meas tran vdout1_24ck1300 FIND v(dout1_24) AT=655.025n

.meas tran vdout1_25ck1300 FIND v(dout1_25) AT=655.025n

.meas tran vdout1_26ck1300 FIND v(dout1_26) AT=655.025n

.meas tran vdout1_27ck1300 FIND v(dout1_27) AT=655.025n

.meas tran vdout1_28ck1300 FIND v(dout1_28) AT=655.025n

.meas tran vdout1_29ck1300 FIND v(dout1_29) AT=655.025n

.meas tran vdout1_30ck1300 FIND v(dout1_30) AT=655.025n

.meas tran vdout1_31ck1300 FIND v(dout1_31) AT=655.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_19ck1310 FIND v(dout1_19) AT=660.025n

.meas tran vdout1_20ck1310 FIND v(dout1_20) AT=660.025n

.meas tran vdout1_21ck1310 FIND v(dout1_21) AT=660.025n

.meas tran vdout1_22ck1310 FIND v(dout1_22) AT=660.025n

.meas tran vdout1_23ck1310 FIND v(dout1_23) AT=660.025n

.meas tran vdout1_24ck1310 FIND v(dout1_24) AT=660.025n

.meas tran vdout1_25ck1310 FIND v(dout1_25) AT=660.025n

.meas tran vdout1_26ck1310 FIND v(dout1_26) AT=660.025n

.meas tran vdout1_27ck1310 FIND v(dout1_27) AT=660.025n

.meas tran vdout1_28ck1310 FIND v(dout1_28) AT=660.025n

.meas tran vdout1_29ck1310 FIND v(dout1_29) AT=660.025n

.meas tran vdout1_30ck1310 FIND v(dout1_30) AT=660.025n

.meas tran vdout1_31ck1310 FIND v(dout1_31) AT=660.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_0ck1440 FIND v(dout1_0) AT=725.025n

.meas tran vdout1_1ck1440 FIND v(dout1_1) AT=725.025n

.meas tran vdout1_2ck1440 FIND v(dout1_2) AT=725.025n

.meas tran vdout1_3ck1440 FIND v(dout1_3) AT=725.025n

.meas tran vdout1_4ck1440 FIND v(dout1_4) AT=725.025n

.meas tran vdout1_5ck1440 FIND v(dout1_5) AT=725.025n

.meas tran vdout1_6ck1440 FIND v(dout1_6) AT=725.025n

.meas tran vdout1_7ck1440 FIND v(dout1_7) AT=725.025n

.meas tran vdout1_8ck1440 FIND v(dout1_8) AT=725.025n

.meas tran vdout1_9ck1440 FIND v(dout1_9) AT=725.025n

.meas tran vdout1_10ck1440 FIND v(dout1_10) AT=725.025n

.meas tran vdout1_11ck1440 FIND v(dout1_11) AT=725.025n

.meas tran vdout1_12ck1440 FIND v(dout1_12) AT=725.025n

.meas tran vdout1_13ck1440 FIND v(dout1_13) AT=725.025n

.meas tran vdout1_14ck1440 FIND v(dout1_14) AT=725.025n

.meas tran vdout1_15ck1440 FIND v(dout1_15) AT=725.025n

.meas tran vdout1_16ck1440 FIND v(dout1_16) AT=725.025n

.meas tran vdout1_17ck1440 FIND v(dout1_17) AT=725.025n

.meas tran vdout1_18ck1440 FIND v(dout1_18) AT=725.025n

.meas tran vdout1_19ck1440 FIND v(dout1_19) AT=725.025n

.meas tran vdout1_20ck1440 FIND v(dout1_20) AT=725.025n

.meas tran vdout1_21ck1440 FIND v(dout1_21) AT=725.025n

.meas tran vdout1_22ck1440 FIND v(dout1_22) AT=725.025n

.meas tran vdout1_23ck1440 FIND v(dout1_23) AT=725.025n

.meas tran vdout1_24ck1440 FIND v(dout1_24) AT=725.025n

.meas tran vdout1_25ck1440 FIND v(dout1_25) AT=725.025n

.meas tran vdout1_26ck1440 FIND v(dout1_26) AT=725.025n

.meas tran vdout1_27ck1440 FIND v(dout1_27) AT=725.025n

.meas tran vdout1_28ck1440 FIND v(dout1_28) AT=725.025n

.meas tran vdout1_29ck1440 FIND v(dout1_29) AT=725.025n

.meas tran vdout1_30ck1440 FIND v(dout1_30) AT=725.025n

.meas tran vdout1_31ck1440 FIND v(dout1_31) AT=725.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_22ck1460 FIND v(dout1_22) AT=735.025n

.meas tran vdout1_23ck1460 FIND v(dout1_23) AT=735.025n

.meas tran vdout1_24ck1460 FIND v(dout1_24) AT=735.025n

.meas tran vdout1_25ck1460 FIND v(dout1_25) AT=735.025n

.meas tran vdout1_26ck1460 FIND v(dout1_26) AT=735.025n

.meas tran vdout1_27ck1460 FIND v(dout1_27) AT=735.025n

.meas tran vdout1_28ck1460 FIND v(dout1_28) AT=735.025n

.meas tran vdout1_29ck1460 FIND v(dout1_29) AT=735.025n

.meas tran vdout1_30ck1460 FIND v(dout1_30) AT=735.025n

.meas tran vdout1_31ck1460 FIND v(dout1_31) AT=735.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_22ck1490 FIND v(dout1_22) AT=750.025n

.meas tran vdout1_23ck1490 FIND v(dout1_23) AT=750.025n

.meas tran vdout1_24ck1490 FIND v(dout1_24) AT=750.025n

.meas tran vdout1_25ck1490 FIND v(dout1_25) AT=750.025n

.meas tran vdout1_26ck1490 FIND v(dout1_26) AT=750.025n

.meas tran vdout1_27ck1490 FIND v(dout1_27) AT=750.025n

.meas tran vdout1_28ck1490 FIND v(dout1_28) AT=750.025n

.meas tran vdout1_29ck1490 FIND v(dout1_29) AT=750.025n

.meas tran vdout1_30ck1490 FIND v(dout1_30) AT=750.025n

.meas tran vdout1_31ck1490 FIND v(dout1_31) AT=750.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_22ck1500 FIND v(dout1_22) AT=755.025n

.meas tran vdout1_23ck1500 FIND v(dout1_23) AT=755.025n

.meas tran vdout1_24ck1500 FIND v(dout1_24) AT=755.025n

.meas tran vdout1_25ck1500 FIND v(dout1_25) AT=755.025n

.meas tran vdout1_26ck1500 FIND v(dout1_26) AT=755.025n

.meas tran vdout1_27ck1500 FIND v(dout1_27) AT=755.025n

.meas tran vdout1_28ck1500 FIND v(dout1_28) AT=755.025n

.meas tran vdout1_29ck1500 FIND v(dout1_29) AT=755.025n

.meas tran vdout1_30ck1500 FIND v(dout1_30) AT=755.025n

.meas tran vdout1_31ck1500 FIND v(dout1_31) AT=755.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_23ck1540 FIND v(dout1_23) AT=775.025n

.meas tran vdout1_24ck1540 FIND v(dout1_24) AT=775.025n

.meas tran vdout1_25ck1540 FIND v(dout1_25) AT=775.025n

.meas tran vdout1_26ck1540 FIND v(dout1_26) AT=775.025n

.meas tran vdout1_27ck1540 FIND v(dout1_27) AT=775.025n

.meas tran vdout1_28ck1540 FIND v(dout1_28) AT=775.025n

.meas tran vdout1_29ck1540 FIND v(dout1_29) AT=775.025n

.meas tran vdout1_30ck1540 FIND v(dout1_30) AT=775.025n

.meas tran vdout1_31ck1540 FIND v(dout1_31) AT=775.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_17ck1570 FIND v(dout1_17) AT=790.025n

.meas tran vdout1_18ck1570 FIND v(dout1_18) AT=790.025n

.meas tran vdout1_19ck1570 FIND v(dout1_19) AT=790.025n

.meas tran vdout1_20ck1570 FIND v(dout1_20) AT=790.025n

.meas tran vdout1_21ck1570 FIND v(dout1_21) AT=790.025n

.meas tran vdout1_22ck1570 FIND v(dout1_22) AT=790.025n

.meas tran vdout1_23ck1570 FIND v(dout1_23) AT=790.025n

.meas tran vdout1_24ck1570 FIND v(dout1_24) AT=790.025n

.meas tran vdout1_25ck1570 FIND v(dout1_25) AT=790.025n

.meas tran vdout1_26ck1570 FIND v(dout1_26) AT=790.025n

.meas tran vdout1_27ck1570 FIND v(dout1_27) AT=790.025n

.meas tran vdout1_28ck1570 FIND v(dout1_28) AT=790.025n

.meas tran vdout1_29ck1570 FIND v(dout1_29) AT=790.025n

.meas tran vdout1_30ck1570 FIND v(dout1_30) AT=790.025n

.meas tran vdout1_31ck1570 FIND v(dout1_31) AT=790.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_19ck1590 FIND v(dout1_19) AT=800.025n

.meas tran vdout1_20ck1590 FIND v(dout1_20) AT=800.025n

.meas tran vdout1_21ck1590 FIND v(dout1_21) AT=800.025n

.meas tran vdout1_22ck1590 FIND v(dout1_22) AT=800.025n

.meas tran vdout1_23ck1590 FIND v(dout1_23) AT=800.025n

.meas tran vdout1_24ck1590 FIND v(dout1_24) AT=800.025n

.meas tran vdout1_25ck1590 FIND v(dout1_25) AT=800.025n

.meas tran vdout1_26ck1590 FIND v(dout1_26) AT=800.025n

.meas tran vdout1_27ck1590 FIND v(dout1_27) AT=800.025n

.meas tran vdout1_28ck1590 FIND v(dout1_28) AT=800.025n

.meas tran vdout1_29ck1590 FIND v(dout1_29) AT=800.025n

.meas tran vdout1_30ck1590 FIND v(dout1_30) AT=800.025n

.meas tran vdout1_31ck1590 FIND v(dout1_31) AT=800.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_16ck1620 FIND v(dout1_16) AT=815.025n

.meas tran vdout1_17ck1620 FIND v(dout1_17) AT=815.025n

.meas tran vdout1_18ck1620 FIND v(dout1_18) AT=815.025n

.meas tran vdout1_19ck1620 FIND v(dout1_19) AT=815.025n

.meas tran vdout1_20ck1620 FIND v(dout1_20) AT=815.025n

.meas tran vdout1_21ck1620 FIND v(dout1_21) AT=815.025n

.meas tran vdout1_22ck1620 FIND v(dout1_22) AT=815.025n

.meas tran vdout1_23ck1620 FIND v(dout1_23) AT=815.025n

.meas tran vdout1_24ck1620 FIND v(dout1_24) AT=815.025n

.meas tran vdout1_25ck1620 FIND v(dout1_25) AT=815.025n

.meas tran vdout1_26ck1620 FIND v(dout1_26) AT=815.025n

.meas tran vdout1_27ck1620 FIND v(dout1_27) AT=815.025n

.meas tran vdout1_28ck1620 FIND v(dout1_28) AT=815.025n

.meas tran vdout1_29ck1620 FIND v(dout1_29) AT=815.025n

.meas tran vdout1_30ck1620 FIND v(dout1_30) AT=815.025n

.meas tran vdout1_31ck1620 FIND v(dout1_31) AT=815.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_17ck1640 FIND v(dout1_17) AT=825.025n

.meas tran vdout1_18ck1640 FIND v(dout1_18) AT=825.025n

.meas tran vdout1_19ck1640 FIND v(dout1_19) AT=825.025n

.meas tran vdout1_20ck1640 FIND v(dout1_20) AT=825.025n

.meas tran vdout1_21ck1640 FIND v(dout1_21) AT=825.025n

.meas tran vdout1_22ck1640 FIND v(dout1_22) AT=825.025n

.meas tran vdout1_23ck1640 FIND v(dout1_23) AT=825.025n

.meas tran vdout1_24ck1640 FIND v(dout1_24) AT=825.025n

.meas tran vdout1_25ck1640 FIND v(dout1_25) AT=825.025n

.meas tran vdout1_26ck1640 FIND v(dout1_26) AT=825.025n

.meas tran vdout1_27ck1640 FIND v(dout1_27) AT=825.025n

.meas tran vdout1_28ck1640 FIND v(dout1_28) AT=825.025n

.meas tran vdout1_29ck1640 FIND v(dout1_29) AT=825.025n

.meas tran vdout1_30ck1640 FIND v(dout1_30) AT=825.025n

.meas tran vdout1_31ck1640 FIND v(dout1_31) AT=825.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_16ck1730 FIND v(dout1_16) AT=870.025n

.meas tran vdout1_17ck1730 FIND v(dout1_17) AT=870.025n

.meas tran vdout1_18ck1730 FIND v(dout1_18) AT=870.025n

.meas tran vdout1_19ck1730 FIND v(dout1_19) AT=870.025n

.meas tran vdout1_20ck1730 FIND v(dout1_20) AT=870.025n

.meas tran vdout1_21ck1730 FIND v(dout1_21) AT=870.025n

.meas tran vdout1_22ck1730 FIND v(dout1_22) AT=870.025n

.meas tran vdout1_23ck1730 FIND v(dout1_23) AT=870.025n

.meas tran vdout1_24ck1730 FIND v(dout1_24) AT=870.025n

.meas tran vdout1_25ck1730 FIND v(dout1_25) AT=870.025n

.meas tran vdout1_26ck1730 FIND v(dout1_26) AT=870.025n

.meas tran vdout1_27ck1730 FIND v(dout1_27) AT=870.025n

.meas tran vdout1_28ck1730 FIND v(dout1_28) AT=870.025n

.meas tran vdout1_29ck1730 FIND v(dout1_29) AT=870.025n

.meas tran vdout1_30ck1730 FIND v(dout1_30) AT=870.025n

.meas tran vdout1_31ck1730 FIND v(dout1_31) AT=870.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_17ck1810 FIND v(dout1_17) AT=910.025n

.meas tran vdout1_18ck1810 FIND v(dout1_18) AT=910.025n

.meas tran vdout1_19ck1810 FIND v(dout1_19) AT=910.025n

.meas tran vdout1_20ck1810 FIND v(dout1_20) AT=910.025n

.meas tran vdout1_21ck1810 FIND v(dout1_21) AT=910.025n

.meas tran vdout1_22ck1810 FIND v(dout1_22) AT=910.025n

.meas tran vdout1_23ck1810 FIND v(dout1_23) AT=910.025n

.meas tran vdout1_24ck1810 FIND v(dout1_24) AT=910.025n

.meas tran vdout1_25ck1810 FIND v(dout1_25) AT=910.025n

.meas tran vdout1_26ck1810 FIND v(dout1_26) AT=910.025n

.meas tran vdout1_27ck1810 FIND v(dout1_27) AT=910.025n

.meas tran vdout1_28ck1810 FIND v(dout1_28) AT=910.025n

.meas tran vdout1_29ck1810 FIND v(dout1_29) AT=910.025n

.meas tran vdout1_30ck1810 FIND v(dout1_30) AT=910.025n

.meas tran vdout1_31ck1810 FIND v(dout1_31) AT=910.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_16ck1820 FIND v(dout1_16) AT=915.025n

.meas tran vdout1_17ck1820 FIND v(dout1_17) AT=915.025n

.meas tran vdout1_18ck1820 FIND v(dout1_18) AT=915.025n

.meas tran vdout1_19ck1820 FIND v(dout1_19) AT=915.025n

.meas tran vdout1_20ck1820 FIND v(dout1_20) AT=915.025n

.meas tran vdout1_21ck1820 FIND v(dout1_21) AT=915.025n

.meas tran vdout1_22ck1820 FIND v(dout1_22) AT=915.025n

.meas tran vdout1_23ck1820 FIND v(dout1_23) AT=915.025n

.meas tran vdout1_24ck1820 FIND v(dout1_24) AT=915.025n

.meas tran vdout1_25ck1820 FIND v(dout1_25) AT=915.025n

.meas tran vdout1_26ck1820 FIND v(dout1_26) AT=915.025n

.meas tran vdout1_27ck1820 FIND v(dout1_27) AT=915.025n

.meas tran vdout1_28ck1820 FIND v(dout1_28) AT=915.025n

.meas tran vdout1_29ck1820 FIND v(dout1_29) AT=915.025n

.meas tran vdout1_30ck1820 FIND v(dout1_30) AT=915.025n

.meas tran vdout1_31ck1820 FIND v(dout1_31) AT=915.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_23ck1830 FIND v(dout1_23) AT=920.025n

.meas tran vdout1_24ck1830 FIND v(dout1_24) AT=920.025n

.meas tran vdout1_25ck1830 FIND v(dout1_25) AT=920.025n

.meas tran vdout1_26ck1830 FIND v(dout1_26) AT=920.025n

.meas tran vdout1_27ck1830 FIND v(dout1_27) AT=920.025n

.meas tran vdout1_28ck1830 FIND v(dout1_28) AT=920.025n

.meas tran vdout1_29ck1830 FIND v(dout1_29) AT=920.025n

.meas tran vdout1_30ck1830 FIND v(dout1_30) AT=920.025n

.meas tran vdout1_31ck1830 FIND v(dout1_31) AT=920.025n

.meas tran vdout1_0ck1870 FIND v(dout1_0) AT=940.025n

.meas tran vdout1_1ck1870 FIND v(dout1_1) AT=940.025n

.meas tran vdout1_2ck1870 FIND v(dout1_2) AT=940.025n

.meas tran vdout1_3ck1870 FIND v(dout1_3) AT=940.025n

.meas tran vdout1_4ck1870 FIND v(dout1_4) AT=940.025n

.meas tran vdout1_5ck1870 FIND v(dout1_5) AT=940.025n

.meas tran vdout1_6ck1870 FIND v(dout1_6) AT=940.025n

.meas tran vdout1_7ck1870 FIND v(dout1_7) AT=940.025n

.meas tran vdout1_8ck1870 FIND v(dout1_8) AT=940.025n

.meas tran vdout1_9ck1870 FIND v(dout1_9) AT=940.025n

.meas tran vdout1_10ck1870 FIND v(dout1_10) AT=940.025n

.meas tran vdout1_11ck1870 FIND v(dout1_11) AT=940.025n

.meas tran vdout1_12ck1870 FIND v(dout1_12) AT=940.025n

.meas tran vdout1_13ck1870 FIND v(dout1_13) AT=940.025n

.meas tran vdout1_14ck1870 FIND v(dout1_14) AT=940.025n

.meas tran vdout1_15ck1870 FIND v(dout1_15) AT=940.025n

.meas tran vdout1_16ck1870 FIND v(dout1_16) AT=940.025n

.meas tran vdout1_17ck1870 FIND v(dout1_17) AT=940.025n

.meas tran vdout1_18ck1870 FIND v(dout1_18) AT=940.025n

.meas tran vdout1_19ck1870 FIND v(dout1_19) AT=940.025n

.meas tran vdout1_20ck1870 FIND v(dout1_20) AT=940.025n

.meas tran vdout1_21ck1870 FIND v(dout1_21) AT=940.025n

.meas tran vdout1_22ck1870 FIND v(dout1_22) AT=940.025n

.meas tran vdout1_23ck1870 FIND v(dout1_23) AT=940.025n

.meas tran vdout1_24ck1870 FIND v(dout1_24) AT=940.025n

.meas tran vdout1_25ck1870 FIND v(dout1_25) AT=940.025n

.meas tran vdout1_26ck1870 FIND v(dout1_26) AT=940.025n

.meas tran vdout1_27ck1870 FIND v(dout1_27) AT=940.025n

.meas tran vdout1_28ck1870 FIND v(dout1_28) AT=940.025n

.meas tran vdout1_29ck1870 FIND v(dout1_29) AT=940.025n

.meas tran vdout1_30ck1870 FIND v(dout1_30) AT=940.025n

.meas tran vdout1_31ck1870 FIND v(dout1_31) AT=940.025n

.meas tran vdout1_0ck1880 FIND v(dout1_0) AT=945.025n

.meas tran vdout1_1ck1880 FIND v(dout1_1) AT=945.025n

.meas tran vdout1_2ck1880 FIND v(dout1_2) AT=945.025n

.meas tran vdout1_3ck1880 FIND v(dout1_3) AT=945.025n

.meas tran vdout1_4ck1880 FIND v(dout1_4) AT=945.025n

.meas tran vdout1_5ck1880 FIND v(dout1_5) AT=945.025n

.meas tran vdout1_6ck1880 FIND v(dout1_6) AT=945.025n

.meas tran vdout1_7ck1880 FIND v(dout1_7) AT=945.025n

.meas tran vdout1_8ck1880 FIND v(dout1_8) AT=945.025n

.meas tran vdout1_9ck1880 FIND v(dout1_9) AT=945.025n

.meas tran vdout1_10ck1880 FIND v(dout1_10) AT=945.025n

.meas tran vdout1_11ck1880 FIND v(dout1_11) AT=945.025n

.meas tran vdout1_12ck1880 FIND v(dout1_12) AT=945.025n

.meas tran vdout1_13ck1880 FIND v(dout1_13) AT=945.025n

.meas tran vdout1_14ck1880 FIND v(dout1_14) AT=945.025n

.meas tran vdout1_15ck1880 FIND v(dout1_15) AT=945.025n

.meas tran vdout1_16ck1880 FIND v(dout1_16) AT=945.025n

.meas tran vdout1_17ck1880 FIND v(dout1_17) AT=945.025n

.meas tran vdout1_18ck1880 FIND v(dout1_18) AT=945.025n

.meas tran vdout1_19ck1880 FIND v(dout1_19) AT=945.025n

.meas tran vdout1_20ck1880 FIND v(dout1_20) AT=945.025n

.meas tran vdout1_21ck1880 FIND v(dout1_21) AT=945.025n

.meas tran vdout1_22ck1880 FIND v(dout1_22) AT=945.025n

.meas tran vdout1_23ck1880 FIND v(dout1_23) AT=945.025n

.meas tran vdout1_24ck1880 FIND v(dout1_24) AT=945.025n

.meas tran vdout1_25ck1880 FIND v(dout1_25) AT=945.025n

.meas tran vdout1_26ck1880 FIND v(dout1_26) AT=945.025n

.meas tran vdout1_27ck1880 FIND v(dout1_27) AT=945.025n

.meas tran vdout1_28ck1880 FIND v(dout1_28) AT=945.025n

.meas tran vdout1_29ck1880 FIND v(dout1_29) AT=945.025n

.meas tran vdout1_30ck1880 FIND v(dout1_30) AT=945.025n

.meas tran vdout1_31ck1880 FIND v(dout1_31) AT=945.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_23ck1910 FIND v(dout1_23) AT=960.025n

.meas tran vdout1_24ck1910 FIND v(dout1_24) AT=960.025n

.meas tran vdout1_25ck1910 FIND v(dout1_25) AT=960.025n

.meas tran vdout1_26ck1910 FIND v(dout1_26) AT=960.025n

.meas tran vdout1_27ck1910 FIND v(dout1_27) AT=960.025n

.meas tran vdout1_28ck1910 FIND v(dout1_28) AT=960.025n

.meas tran vdout1_29ck1910 FIND v(dout1_29) AT=960.025n

.meas tran vdout1_30ck1910 FIND v(dout1_30) AT=960.025n

.meas tran vdout1_31ck1910 FIND v(dout1_31) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_23ck1920 FIND v(dout1_23) AT=965.025n

.meas tran vdout1_24ck1920 FIND v(dout1_24) AT=965.025n

.meas tran vdout1_25ck1920 FIND v(dout1_25) AT=965.025n

.meas tran vdout1_26ck1920 FIND v(dout1_26) AT=965.025n

.meas tran vdout1_27ck1920 FIND v(dout1_27) AT=965.025n

.meas tran vdout1_28ck1920 FIND v(dout1_28) AT=965.025n

.meas tran vdout1_29ck1920 FIND v(dout1_29) AT=965.025n

.meas tran vdout1_30ck1920 FIND v(dout1_30) AT=965.025n

.meas tran vdout1_31ck1920 FIND v(dout1_31) AT=965.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_17ck1930 FIND v(dout1_17) AT=970.025n

.meas tran vdout1_18ck1930 FIND v(dout1_18) AT=970.025n

.meas tran vdout1_19ck1930 FIND v(dout1_19) AT=970.025n

.meas tran vdout1_20ck1930 FIND v(dout1_20) AT=970.025n

.meas tran vdout1_21ck1930 FIND v(dout1_21) AT=970.025n

.meas tran vdout1_22ck1930 FIND v(dout1_22) AT=970.025n

.meas tran vdout1_23ck1930 FIND v(dout1_23) AT=970.025n

.meas tran vdout1_24ck1930 FIND v(dout1_24) AT=970.025n

.meas tran vdout1_25ck1930 FIND v(dout1_25) AT=970.025n

.meas tran vdout1_26ck1930 FIND v(dout1_26) AT=970.025n

.meas tran vdout1_27ck1930 FIND v(dout1_27) AT=970.025n

.meas tran vdout1_28ck1930 FIND v(dout1_28) AT=970.025n

.meas tran vdout1_29ck1930 FIND v(dout1_29) AT=970.025n

.meas tran vdout1_30ck1930 FIND v(dout1_30) AT=970.025n

.meas tran vdout1_31ck1930 FIND v(dout1_31) AT=970.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_0ck1960 FIND v(dout1_0) AT=985.025n

.meas tran vdout1_1ck1960 FIND v(dout1_1) AT=985.025n

.meas tran vdout1_2ck1960 FIND v(dout1_2) AT=985.025n

.meas tran vdout1_3ck1960 FIND v(dout1_3) AT=985.025n

.meas tran vdout1_4ck1960 FIND v(dout1_4) AT=985.025n

.meas tran vdout1_5ck1960 FIND v(dout1_5) AT=985.025n

.meas tran vdout1_6ck1960 FIND v(dout1_6) AT=985.025n

.meas tran vdout1_7ck1960 FIND v(dout1_7) AT=985.025n

.meas tran vdout1_8ck1960 FIND v(dout1_8) AT=985.025n

.meas tran vdout1_9ck1960 FIND v(dout1_9) AT=985.025n

.meas tran vdout1_10ck1960 FIND v(dout1_10) AT=985.025n

.meas tran vdout1_11ck1960 FIND v(dout1_11) AT=985.025n

.meas tran vdout1_12ck1960 FIND v(dout1_12) AT=985.025n

.meas tran vdout1_13ck1960 FIND v(dout1_13) AT=985.025n

.meas tran vdout1_14ck1960 FIND v(dout1_14) AT=985.025n

.meas tran vdout1_15ck1960 FIND v(dout1_15) AT=985.025n

.meas tran vdout1_16ck1960 FIND v(dout1_16) AT=985.025n

.meas tran vdout1_17ck1960 FIND v(dout1_17) AT=985.025n

.meas tran vdout1_18ck1960 FIND v(dout1_18) AT=985.025n

.meas tran vdout1_19ck1960 FIND v(dout1_19) AT=985.025n

.meas tran vdout1_20ck1960 FIND v(dout1_20) AT=985.025n

.meas tran vdout1_21ck1960 FIND v(dout1_21) AT=985.025n

.meas tran vdout1_22ck1960 FIND v(dout1_22) AT=985.025n

.meas tran vdout1_23ck1960 FIND v(dout1_23) AT=985.025n

.meas tran vdout1_24ck1960 FIND v(dout1_24) AT=985.025n

.meas tran vdout1_25ck1960 FIND v(dout1_25) AT=985.025n

.meas tran vdout1_26ck1960 FIND v(dout1_26) AT=985.025n

.meas tran vdout1_27ck1960 FIND v(dout1_27) AT=985.025n

.meas tran vdout1_28ck1960 FIND v(dout1_28) AT=985.025n

.meas tran vdout1_29ck1960 FIND v(dout1_29) AT=985.025n

.meas tran vdout1_30ck1960 FIND v(dout1_30) AT=985.025n

.meas tran vdout1_31ck1960 FIND v(dout1_31) AT=985.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_16ck1980 FIND v(dout1_16) AT=995.025n

.meas tran vdout1_17ck1980 FIND v(dout1_17) AT=995.025n

.meas tran vdout1_18ck1980 FIND v(dout1_18) AT=995.025n

.meas tran vdout1_19ck1980 FIND v(dout1_19) AT=995.025n

.meas tran vdout1_20ck1980 FIND v(dout1_20) AT=995.025n

.meas tran vdout1_21ck1980 FIND v(dout1_21) AT=995.025n

.meas tran vdout1_22ck1980 FIND v(dout1_22) AT=995.025n

.meas tran vdout1_23ck1980 FIND v(dout1_23) AT=995.025n

.meas tran vdout1_24ck1980 FIND v(dout1_24) AT=995.025n

.meas tran vdout1_25ck1980 FIND v(dout1_25) AT=995.025n

.meas tran vdout1_26ck1980 FIND v(dout1_26) AT=995.025n

.meas tran vdout1_27ck1980 FIND v(dout1_27) AT=995.025n

.meas tran vdout1_28ck1980 FIND v(dout1_28) AT=995.025n

.meas tran vdout1_29ck1980 FIND v(dout1_29) AT=995.025n

.meas tran vdout1_30ck1980 FIND v(dout1_30) AT=995.025n

.meas tran vdout1_31ck1980 FIND v(dout1_31) AT=995.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_17ck1990 FIND v(dout1_17) AT=1000.025n

.meas tran vdout1_18ck1990 FIND v(dout1_18) AT=1000.025n

.meas tran vdout1_19ck1990 FIND v(dout1_19) AT=1000.025n

.meas tran vdout1_20ck1990 FIND v(dout1_20) AT=1000.025n

.meas tran vdout1_21ck1990 FIND v(dout1_21) AT=1000.025n

.meas tran vdout1_22ck1990 FIND v(dout1_22) AT=1000.025n

.meas tran vdout1_23ck1990 FIND v(dout1_23) AT=1000.025n

.meas tran vdout1_24ck1990 FIND v(dout1_24) AT=1000.025n

.meas tran vdout1_25ck1990 FIND v(dout1_25) AT=1000.025n

.meas tran vdout1_26ck1990 FIND v(dout1_26) AT=1000.025n

.meas tran vdout1_27ck1990 FIND v(dout1_27) AT=1000.025n

.meas tran vdout1_28ck1990 FIND v(dout1_28) AT=1000.025n

.meas tran vdout1_29ck1990 FIND v(dout1_29) AT=1000.025n

.meas tran vdout1_30ck1990 FIND v(dout1_30) AT=1000.025n

.meas tran vdout1_31ck1990 FIND v(dout1_31) AT=1000.025n

.meas tran vdout1_0ck2000 FIND v(dout1_0) AT=1005.025n

.meas tran vdout1_1ck2000 FIND v(dout1_1) AT=1005.025n

.meas tran vdout1_2ck2000 FIND v(dout1_2) AT=1005.025n

.meas tran vdout1_3ck2000 FIND v(dout1_3) AT=1005.025n

.meas tran vdout1_4ck2000 FIND v(dout1_4) AT=1005.025n

.meas tran vdout1_5ck2000 FIND v(dout1_5) AT=1005.025n

.meas tran vdout1_6ck2000 FIND v(dout1_6) AT=1005.025n

.meas tran vdout1_7ck2000 FIND v(dout1_7) AT=1005.025n

.meas tran vdout1_8ck2000 FIND v(dout1_8) AT=1005.025n

.meas tran vdout1_9ck2000 FIND v(dout1_9) AT=1005.025n

.meas tran vdout1_10ck2000 FIND v(dout1_10) AT=1005.025n

.meas tran vdout1_11ck2000 FIND v(dout1_11) AT=1005.025n

.meas tran vdout1_12ck2000 FIND v(dout1_12) AT=1005.025n

.meas tran vdout1_13ck2000 FIND v(dout1_13) AT=1005.025n

.meas tran vdout1_14ck2000 FIND v(dout1_14) AT=1005.025n

.meas tran vdout1_15ck2000 FIND v(dout1_15) AT=1005.025n

.meas tran vdout1_16ck2000 FIND v(dout1_16) AT=1005.025n

.meas tran vdout1_17ck2000 FIND v(dout1_17) AT=1005.025n

.meas tran vdout1_18ck2000 FIND v(dout1_18) AT=1005.025n

.meas tran vdout1_19ck2000 FIND v(dout1_19) AT=1005.025n

.meas tran vdout1_20ck2000 FIND v(dout1_20) AT=1005.025n

.meas tran vdout1_21ck2000 FIND v(dout1_21) AT=1005.025n

.meas tran vdout1_22ck2000 FIND v(dout1_22) AT=1005.025n

.meas tran vdout1_23ck2000 FIND v(dout1_23) AT=1005.025n

.meas tran vdout1_24ck2000 FIND v(dout1_24) AT=1005.025n

.meas tran vdout1_25ck2000 FIND v(dout1_25) AT=1005.025n

.meas tran vdout1_26ck2000 FIND v(dout1_26) AT=1005.025n

.meas tran vdout1_27ck2000 FIND v(dout1_27) AT=1005.025n

.meas tran vdout1_28ck2000 FIND v(dout1_28) AT=1005.025n

.meas tran vdout1_29ck2000 FIND v(dout1_29) AT=1005.025n

.meas tran vdout1_30ck2000 FIND v(dout1_30) AT=1005.025n

.meas tran vdout1_31ck2000 FIND v(dout1_31) AT=1005.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_17ck2010 FIND v(dout1_17) AT=1010.025n

.meas tran vdout1_18ck2010 FIND v(dout1_18) AT=1010.025n

.meas tran vdout1_19ck2010 FIND v(dout1_19) AT=1010.025n

.meas tran vdout1_20ck2010 FIND v(dout1_20) AT=1010.025n

.meas tran vdout1_21ck2010 FIND v(dout1_21) AT=1010.025n

.meas tran vdout1_22ck2010 FIND v(dout1_22) AT=1010.025n

.meas tran vdout1_23ck2010 FIND v(dout1_23) AT=1010.025n

.meas tran vdout1_24ck2010 FIND v(dout1_24) AT=1010.025n

.meas tran vdout1_25ck2010 FIND v(dout1_25) AT=1010.025n

.meas tran vdout1_26ck2010 FIND v(dout1_26) AT=1010.025n

.meas tran vdout1_27ck2010 FIND v(dout1_27) AT=1010.025n

.meas tran vdout1_28ck2010 FIND v(dout1_28) AT=1010.025n

.meas tran vdout1_29ck2010 FIND v(dout1_29) AT=1010.025n

.meas tran vdout1_30ck2010 FIND v(dout1_30) AT=1010.025n

.meas tran vdout1_31ck2010 FIND v(dout1_31) AT=1010.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n

.meas tran vdout1_22ck2030 FIND v(dout1_22) AT=1020.025n

.meas tran vdout1_23ck2030 FIND v(dout1_23) AT=1020.025n

.meas tran vdout1_24ck2030 FIND v(dout1_24) AT=1020.025n

.meas tran vdout1_25ck2030 FIND v(dout1_25) AT=1020.025n

.meas tran vdout1_26ck2030 FIND v(dout1_26) AT=1020.025n

.meas tran vdout1_27ck2030 FIND v(dout1_27) AT=1020.025n

.meas tran vdout1_28ck2030 FIND v(dout1_28) AT=1020.025n

.meas tran vdout1_29ck2030 FIND v(dout1_29) AT=1020.025n

.meas tran vdout1_30ck2030 FIND v(dout1_30) AT=1020.025n

.meas tran vdout1_31ck2030 FIND v(dout1_31) AT=1020.025n

.meas tran vdout1_0ck2040 FIND v(dout1_0) AT=1025.025n

.meas tran vdout1_1ck2040 FIND v(dout1_1) AT=1025.025n

.meas tran vdout1_2ck2040 FIND v(dout1_2) AT=1025.025n

.meas tran vdout1_3ck2040 FIND v(dout1_3) AT=1025.025n

.meas tran vdout1_4ck2040 FIND v(dout1_4) AT=1025.025n

.meas tran vdout1_5ck2040 FIND v(dout1_5) AT=1025.025n

.meas tran vdout1_6ck2040 FIND v(dout1_6) AT=1025.025n

.meas tran vdout1_7ck2040 FIND v(dout1_7) AT=1025.025n

.meas tran vdout1_8ck2040 FIND v(dout1_8) AT=1025.025n

.meas tran vdout1_9ck2040 FIND v(dout1_9) AT=1025.025n

.meas tran vdout1_10ck2040 FIND v(dout1_10) AT=1025.025n

.meas tran vdout1_11ck2040 FIND v(dout1_11) AT=1025.025n

.meas tran vdout1_12ck2040 FIND v(dout1_12) AT=1025.025n

.meas tran vdout1_13ck2040 FIND v(dout1_13) AT=1025.025n

.meas tran vdout1_14ck2040 FIND v(dout1_14) AT=1025.025n

.meas tran vdout1_15ck2040 FIND v(dout1_15) AT=1025.025n

.meas tran vdout1_16ck2040 FIND v(dout1_16) AT=1025.025n

.meas tran vdout1_17ck2040 FIND v(dout1_17) AT=1025.025n

.meas tran vdout1_18ck2040 FIND v(dout1_18) AT=1025.025n

.meas tran vdout1_19ck2040 FIND v(dout1_19) AT=1025.025n

.meas tran vdout1_20ck2040 FIND v(dout1_20) AT=1025.025n

.meas tran vdout1_21ck2040 FIND v(dout1_21) AT=1025.025n

.meas tran vdout1_22ck2040 FIND v(dout1_22) AT=1025.025n

.meas tran vdout1_23ck2040 FIND v(dout1_23) AT=1025.025n

.meas tran vdout1_24ck2040 FIND v(dout1_24) AT=1025.025n

.meas tran vdout1_25ck2040 FIND v(dout1_25) AT=1025.025n

.meas tran vdout1_26ck2040 FIND v(dout1_26) AT=1025.025n

.meas tran vdout1_27ck2040 FIND v(dout1_27) AT=1025.025n

.meas tran vdout1_28ck2040 FIND v(dout1_28) AT=1025.025n

.meas tran vdout1_29ck2040 FIND v(dout1_29) AT=1025.025n

.meas tran vdout1_30ck2040 FIND v(dout1_30) AT=1025.025n

.meas tran vdout1_31ck2040 FIND v(dout1_31) AT=1025.025n
