.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_32ck40 FIND v(dout1_32) AT=25.025n

.meas tran vdout1_33ck40 FIND v(dout1_33) AT=25.025n

.meas tran vdout1_34ck40 FIND v(dout1_34) AT=25.025n

.meas tran vdout1_35ck40 FIND v(dout1_35) AT=25.025n

.meas tran vdout1_36ck40 FIND v(dout1_36) AT=25.025n

.meas tran vdout1_37ck40 FIND v(dout1_37) AT=25.025n

.meas tran vdout1_38ck40 FIND v(dout1_38) AT=25.025n

.meas tran vdout1_39ck40 FIND v(dout1_39) AT=25.025n

.meas tran vdout1_40ck40 FIND v(dout1_40) AT=25.025n

.meas tran vdout1_41ck40 FIND v(dout1_41) AT=25.025n

.meas tran vdout1_42ck40 FIND v(dout1_42) AT=25.025n

.meas tran vdout1_43ck40 FIND v(dout1_43) AT=25.025n

.meas tran vdout1_44ck40 FIND v(dout1_44) AT=25.025n

.meas tran vdout1_45ck40 FIND v(dout1_45) AT=25.025n

.meas tran vdout1_46ck40 FIND v(dout1_46) AT=25.025n

.meas tran vdout1_47ck40 FIND v(dout1_47) AT=25.025n

.meas tran vdout1_48ck40 FIND v(dout1_48) AT=25.025n

.meas tran vdout1_49ck40 FIND v(dout1_49) AT=25.025n

.meas tran vdout1_50ck40 FIND v(dout1_50) AT=25.025n

.meas tran vdout1_51ck40 FIND v(dout1_51) AT=25.025n

.meas tran vdout1_52ck40 FIND v(dout1_52) AT=25.025n

.meas tran vdout1_53ck40 FIND v(dout1_53) AT=25.025n

.meas tran vdout1_54ck40 FIND v(dout1_54) AT=25.025n

.meas tran vdout1_55ck40 FIND v(dout1_55) AT=25.025n

.meas tran vdout1_56ck40 FIND v(dout1_56) AT=25.025n

.meas tran vdout1_57ck40 FIND v(dout1_57) AT=25.025n

.meas tran vdout1_58ck40 FIND v(dout1_58) AT=25.025n

.meas tran vdout1_59ck40 FIND v(dout1_59) AT=25.025n

.meas tran vdout1_60ck40 FIND v(dout1_60) AT=25.025n

.meas tran vdout1_61ck40 FIND v(dout1_61) AT=25.025n

.meas tran vdout1_62ck40 FIND v(dout1_62) AT=25.025n

.meas tran vdout1_63ck40 FIND v(dout1_63) AT=25.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_17ck80 FIND v(dout1_17) AT=45.025n

.meas tran vdout1_18ck80 FIND v(dout1_18) AT=45.025n

.meas tran vdout1_19ck80 FIND v(dout1_19) AT=45.025n

.meas tran vdout1_20ck80 FIND v(dout1_20) AT=45.025n

.meas tran vdout1_21ck80 FIND v(dout1_21) AT=45.025n

.meas tran vdout1_22ck80 FIND v(dout1_22) AT=45.025n

.meas tran vdout1_23ck80 FIND v(dout1_23) AT=45.025n

.meas tran vdout1_24ck80 FIND v(dout1_24) AT=45.025n

.meas tran vdout1_25ck80 FIND v(dout1_25) AT=45.025n

.meas tran vdout1_26ck80 FIND v(dout1_26) AT=45.025n

.meas tran vdout1_27ck80 FIND v(dout1_27) AT=45.025n

.meas tran vdout1_28ck80 FIND v(dout1_28) AT=45.025n

.meas tran vdout1_29ck80 FIND v(dout1_29) AT=45.025n

.meas tran vdout1_30ck80 FIND v(dout1_30) AT=45.025n

.meas tran vdout1_31ck80 FIND v(dout1_31) AT=45.025n

.meas tran vdout1_32ck80 FIND v(dout1_32) AT=45.025n

.meas tran vdout1_33ck80 FIND v(dout1_33) AT=45.025n

.meas tran vdout1_34ck80 FIND v(dout1_34) AT=45.025n

.meas tran vdout1_35ck80 FIND v(dout1_35) AT=45.025n

.meas tran vdout1_36ck80 FIND v(dout1_36) AT=45.025n

.meas tran vdout1_37ck80 FIND v(dout1_37) AT=45.025n

.meas tran vdout1_38ck80 FIND v(dout1_38) AT=45.025n

.meas tran vdout1_39ck80 FIND v(dout1_39) AT=45.025n

.meas tran vdout1_40ck80 FIND v(dout1_40) AT=45.025n

.meas tran vdout1_41ck80 FIND v(dout1_41) AT=45.025n

.meas tran vdout1_42ck80 FIND v(dout1_42) AT=45.025n

.meas tran vdout1_43ck80 FIND v(dout1_43) AT=45.025n

.meas tran vdout1_44ck80 FIND v(dout1_44) AT=45.025n

.meas tran vdout1_45ck80 FIND v(dout1_45) AT=45.025n

.meas tran vdout1_46ck80 FIND v(dout1_46) AT=45.025n

.meas tran vdout1_47ck80 FIND v(dout1_47) AT=45.025n

.meas tran vdout1_48ck80 FIND v(dout1_48) AT=45.025n

.meas tran vdout1_49ck80 FIND v(dout1_49) AT=45.025n

.meas tran vdout1_50ck80 FIND v(dout1_50) AT=45.025n

.meas tran vdout1_51ck80 FIND v(dout1_51) AT=45.025n

.meas tran vdout1_52ck80 FIND v(dout1_52) AT=45.025n

.meas tran vdout1_53ck80 FIND v(dout1_53) AT=45.025n

.meas tran vdout1_54ck80 FIND v(dout1_54) AT=45.025n

.meas tran vdout1_55ck80 FIND v(dout1_55) AT=45.025n

.meas tran vdout1_56ck80 FIND v(dout1_56) AT=45.025n

.meas tran vdout1_57ck80 FIND v(dout1_57) AT=45.025n

.meas tran vdout1_58ck80 FIND v(dout1_58) AT=45.025n

.meas tran vdout1_59ck80 FIND v(dout1_59) AT=45.025n

.meas tran vdout1_60ck80 FIND v(dout1_60) AT=45.025n

.meas tran vdout1_61ck80 FIND v(dout1_61) AT=45.025n

.meas tran vdout1_62ck80 FIND v(dout1_62) AT=45.025n

.meas tran vdout1_63ck80 FIND v(dout1_63) AT=45.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_32ck130 FIND v(dout1_32) AT=70.025n

.meas tran vdout1_33ck130 FIND v(dout1_33) AT=70.025n

.meas tran vdout1_34ck130 FIND v(dout1_34) AT=70.025n

.meas tran vdout1_35ck130 FIND v(dout1_35) AT=70.025n

.meas tran vdout1_36ck130 FIND v(dout1_36) AT=70.025n

.meas tran vdout1_37ck130 FIND v(dout1_37) AT=70.025n

.meas tran vdout1_38ck130 FIND v(dout1_38) AT=70.025n

.meas tran vdout1_39ck130 FIND v(dout1_39) AT=70.025n

.meas tran vdout1_40ck130 FIND v(dout1_40) AT=70.025n

.meas tran vdout1_41ck130 FIND v(dout1_41) AT=70.025n

.meas tran vdout1_42ck130 FIND v(dout1_42) AT=70.025n

.meas tran vdout1_43ck130 FIND v(dout1_43) AT=70.025n

.meas tran vdout1_44ck130 FIND v(dout1_44) AT=70.025n

.meas tran vdout1_45ck130 FIND v(dout1_45) AT=70.025n

.meas tran vdout1_46ck130 FIND v(dout1_46) AT=70.025n

.meas tran vdout1_47ck130 FIND v(dout1_47) AT=70.025n

.meas tran vdout1_48ck130 FIND v(dout1_48) AT=70.025n

.meas tran vdout1_49ck130 FIND v(dout1_49) AT=70.025n

.meas tran vdout1_50ck130 FIND v(dout1_50) AT=70.025n

.meas tran vdout1_51ck130 FIND v(dout1_51) AT=70.025n

.meas tran vdout1_52ck130 FIND v(dout1_52) AT=70.025n

.meas tran vdout1_53ck130 FIND v(dout1_53) AT=70.025n

.meas tran vdout1_54ck130 FIND v(dout1_54) AT=70.025n

.meas tran vdout1_55ck130 FIND v(dout1_55) AT=70.025n

.meas tran vdout1_56ck130 FIND v(dout1_56) AT=70.025n

.meas tran vdout1_57ck130 FIND v(dout1_57) AT=70.025n

.meas tran vdout1_58ck130 FIND v(dout1_58) AT=70.025n

.meas tran vdout1_59ck130 FIND v(dout1_59) AT=70.025n

.meas tran vdout1_60ck130 FIND v(dout1_60) AT=70.025n

.meas tran vdout1_61ck130 FIND v(dout1_61) AT=70.025n

.meas tran vdout1_62ck130 FIND v(dout1_62) AT=70.025n

.meas tran vdout1_63ck130 FIND v(dout1_63) AT=70.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_22ck140 FIND v(dout1_22) AT=75.025n

.meas tran vdout1_23ck140 FIND v(dout1_23) AT=75.025n

.meas tran vdout1_24ck140 FIND v(dout1_24) AT=75.025n

.meas tran vdout1_25ck140 FIND v(dout1_25) AT=75.025n

.meas tran vdout1_26ck140 FIND v(dout1_26) AT=75.025n

.meas tran vdout1_27ck140 FIND v(dout1_27) AT=75.025n

.meas tran vdout1_28ck140 FIND v(dout1_28) AT=75.025n

.meas tran vdout1_29ck140 FIND v(dout1_29) AT=75.025n

.meas tran vdout1_30ck140 FIND v(dout1_30) AT=75.025n

.meas tran vdout1_31ck140 FIND v(dout1_31) AT=75.025n

.meas tran vdout1_32ck140 FIND v(dout1_32) AT=75.025n

.meas tran vdout1_33ck140 FIND v(dout1_33) AT=75.025n

.meas tran vdout1_34ck140 FIND v(dout1_34) AT=75.025n

.meas tran vdout1_35ck140 FIND v(dout1_35) AT=75.025n

.meas tran vdout1_36ck140 FIND v(dout1_36) AT=75.025n

.meas tran vdout1_37ck140 FIND v(dout1_37) AT=75.025n

.meas tran vdout1_38ck140 FIND v(dout1_38) AT=75.025n

.meas tran vdout1_39ck140 FIND v(dout1_39) AT=75.025n

.meas tran vdout1_40ck140 FIND v(dout1_40) AT=75.025n

.meas tran vdout1_41ck140 FIND v(dout1_41) AT=75.025n

.meas tran vdout1_42ck140 FIND v(dout1_42) AT=75.025n

.meas tran vdout1_43ck140 FIND v(dout1_43) AT=75.025n

.meas tran vdout1_44ck140 FIND v(dout1_44) AT=75.025n

.meas tran vdout1_45ck140 FIND v(dout1_45) AT=75.025n

.meas tran vdout1_46ck140 FIND v(dout1_46) AT=75.025n

.meas tran vdout1_47ck140 FIND v(dout1_47) AT=75.025n

.meas tran vdout1_48ck140 FIND v(dout1_48) AT=75.025n

.meas tran vdout1_49ck140 FIND v(dout1_49) AT=75.025n

.meas tran vdout1_50ck140 FIND v(dout1_50) AT=75.025n

.meas tran vdout1_51ck140 FIND v(dout1_51) AT=75.025n

.meas tran vdout1_52ck140 FIND v(dout1_52) AT=75.025n

.meas tran vdout1_53ck140 FIND v(dout1_53) AT=75.025n

.meas tran vdout1_54ck140 FIND v(dout1_54) AT=75.025n

.meas tran vdout1_55ck140 FIND v(dout1_55) AT=75.025n

.meas tran vdout1_56ck140 FIND v(dout1_56) AT=75.025n

.meas tran vdout1_57ck140 FIND v(dout1_57) AT=75.025n

.meas tran vdout1_58ck140 FIND v(dout1_58) AT=75.025n

.meas tran vdout1_59ck140 FIND v(dout1_59) AT=75.025n

.meas tran vdout1_60ck140 FIND v(dout1_60) AT=75.025n

.meas tran vdout1_61ck140 FIND v(dout1_61) AT=75.025n

.meas tran vdout1_62ck140 FIND v(dout1_62) AT=75.025n

.meas tran vdout1_63ck140 FIND v(dout1_63) AT=75.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_22ck180 FIND v(dout1_22) AT=95.025n

.meas tran vdout1_23ck180 FIND v(dout1_23) AT=95.025n

.meas tran vdout1_24ck180 FIND v(dout1_24) AT=95.025n

.meas tran vdout1_25ck180 FIND v(dout1_25) AT=95.025n

.meas tran vdout1_26ck180 FIND v(dout1_26) AT=95.025n

.meas tran vdout1_27ck180 FIND v(dout1_27) AT=95.025n

.meas tran vdout1_28ck180 FIND v(dout1_28) AT=95.025n

.meas tran vdout1_29ck180 FIND v(dout1_29) AT=95.025n

.meas tran vdout1_30ck180 FIND v(dout1_30) AT=95.025n

.meas tran vdout1_31ck180 FIND v(dout1_31) AT=95.025n

.meas tran vdout1_32ck180 FIND v(dout1_32) AT=95.025n

.meas tran vdout1_33ck180 FIND v(dout1_33) AT=95.025n

.meas tran vdout1_34ck180 FIND v(dout1_34) AT=95.025n

.meas tran vdout1_35ck180 FIND v(dout1_35) AT=95.025n

.meas tran vdout1_36ck180 FIND v(dout1_36) AT=95.025n

.meas tran vdout1_37ck180 FIND v(dout1_37) AT=95.025n

.meas tran vdout1_38ck180 FIND v(dout1_38) AT=95.025n

.meas tran vdout1_39ck180 FIND v(dout1_39) AT=95.025n

.meas tran vdout1_40ck180 FIND v(dout1_40) AT=95.025n

.meas tran vdout1_41ck180 FIND v(dout1_41) AT=95.025n

.meas tran vdout1_42ck180 FIND v(dout1_42) AT=95.025n

.meas tran vdout1_43ck180 FIND v(dout1_43) AT=95.025n

.meas tran vdout1_44ck180 FIND v(dout1_44) AT=95.025n

.meas tran vdout1_45ck180 FIND v(dout1_45) AT=95.025n

.meas tran vdout1_46ck180 FIND v(dout1_46) AT=95.025n

.meas tran vdout1_47ck180 FIND v(dout1_47) AT=95.025n

.meas tran vdout1_48ck180 FIND v(dout1_48) AT=95.025n

.meas tran vdout1_49ck180 FIND v(dout1_49) AT=95.025n

.meas tran vdout1_50ck180 FIND v(dout1_50) AT=95.025n

.meas tran vdout1_51ck180 FIND v(dout1_51) AT=95.025n

.meas tran vdout1_52ck180 FIND v(dout1_52) AT=95.025n

.meas tran vdout1_53ck180 FIND v(dout1_53) AT=95.025n

.meas tran vdout1_54ck180 FIND v(dout1_54) AT=95.025n

.meas tran vdout1_55ck180 FIND v(dout1_55) AT=95.025n

.meas tran vdout1_56ck180 FIND v(dout1_56) AT=95.025n

.meas tran vdout1_57ck180 FIND v(dout1_57) AT=95.025n

.meas tran vdout1_58ck180 FIND v(dout1_58) AT=95.025n

.meas tran vdout1_59ck180 FIND v(dout1_59) AT=95.025n

.meas tran vdout1_60ck180 FIND v(dout1_60) AT=95.025n

.meas tran vdout1_61ck180 FIND v(dout1_61) AT=95.025n

.meas tran vdout1_62ck180 FIND v(dout1_62) AT=95.025n

.meas tran vdout1_63ck180 FIND v(dout1_63) AT=95.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_17ck240 FIND v(dout1_17) AT=125.025n

.meas tran vdout1_18ck240 FIND v(dout1_18) AT=125.025n

.meas tran vdout1_19ck240 FIND v(dout1_19) AT=125.025n

.meas tran vdout1_20ck240 FIND v(dout1_20) AT=125.025n

.meas tran vdout1_21ck240 FIND v(dout1_21) AT=125.025n

.meas tran vdout1_22ck240 FIND v(dout1_22) AT=125.025n

.meas tran vdout1_23ck240 FIND v(dout1_23) AT=125.025n

.meas tran vdout1_24ck240 FIND v(dout1_24) AT=125.025n

.meas tran vdout1_25ck240 FIND v(dout1_25) AT=125.025n

.meas tran vdout1_26ck240 FIND v(dout1_26) AT=125.025n

.meas tran vdout1_27ck240 FIND v(dout1_27) AT=125.025n

.meas tran vdout1_28ck240 FIND v(dout1_28) AT=125.025n

.meas tran vdout1_29ck240 FIND v(dout1_29) AT=125.025n

.meas tran vdout1_30ck240 FIND v(dout1_30) AT=125.025n

.meas tran vdout1_31ck240 FIND v(dout1_31) AT=125.025n

.meas tran vdout1_32ck240 FIND v(dout1_32) AT=125.025n

.meas tran vdout1_33ck240 FIND v(dout1_33) AT=125.025n

.meas tran vdout1_34ck240 FIND v(dout1_34) AT=125.025n

.meas tran vdout1_35ck240 FIND v(dout1_35) AT=125.025n

.meas tran vdout1_36ck240 FIND v(dout1_36) AT=125.025n

.meas tran vdout1_37ck240 FIND v(dout1_37) AT=125.025n

.meas tran vdout1_38ck240 FIND v(dout1_38) AT=125.025n

.meas tran vdout1_39ck240 FIND v(dout1_39) AT=125.025n

.meas tran vdout1_40ck240 FIND v(dout1_40) AT=125.025n

.meas tran vdout1_41ck240 FIND v(dout1_41) AT=125.025n

.meas tran vdout1_42ck240 FIND v(dout1_42) AT=125.025n

.meas tran vdout1_43ck240 FIND v(dout1_43) AT=125.025n

.meas tran vdout1_44ck240 FIND v(dout1_44) AT=125.025n

.meas tran vdout1_45ck240 FIND v(dout1_45) AT=125.025n

.meas tran vdout1_46ck240 FIND v(dout1_46) AT=125.025n

.meas tran vdout1_47ck240 FIND v(dout1_47) AT=125.025n

.meas tran vdout1_48ck240 FIND v(dout1_48) AT=125.025n

.meas tran vdout1_49ck240 FIND v(dout1_49) AT=125.025n

.meas tran vdout1_50ck240 FIND v(dout1_50) AT=125.025n

.meas tran vdout1_51ck240 FIND v(dout1_51) AT=125.025n

.meas tran vdout1_52ck240 FIND v(dout1_52) AT=125.025n

.meas tran vdout1_53ck240 FIND v(dout1_53) AT=125.025n

.meas tran vdout1_54ck240 FIND v(dout1_54) AT=125.025n

.meas tran vdout1_55ck240 FIND v(dout1_55) AT=125.025n

.meas tran vdout1_56ck240 FIND v(dout1_56) AT=125.025n

.meas tran vdout1_57ck240 FIND v(dout1_57) AT=125.025n

.meas tran vdout1_58ck240 FIND v(dout1_58) AT=125.025n

.meas tran vdout1_59ck240 FIND v(dout1_59) AT=125.025n

.meas tran vdout1_60ck240 FIND v(dout1_60) AT=125.025n

.meas tran vdout1_61ck240 FIND v(dout1_61) AT=125.025n

.meas tran vdout1_62ck240 FIND v(dout1_62) AT=125.025n

.meas tran vdout1_63ck240 FIND v(dout1_63) AT=125.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_17ck250 FIND v(dout1_17) AT=130.025n

.meas tran vdout1_18ck250 FIND v(dout1_18) AT=130.025n

.meas tran vdout1_19ck250 FIND v(dout1_19) AT=130.025n

.meas tran vdout1_20ck250 FIND v(dout1_20) AT=130.025n

.meas tran vdout1_21ck250 FIND v(dout1_21) AT=130.025n

.meas tran vdout1_22ck250 FIND v(dout1_22) AT=130.025n

.meas tran vdout1_23ck250 FIND v(dout1_23) AT=130.025n

.meas tran vdout1_24ck250 FIND v(dout1_24) AT=130.025n

.meas tran vdout1_25ck250 FIND v(dout1_25) AT=130.025n

.meas tran vdout1_26ck250 FIND v(dout1_26) AT=130.025n

.meas tran vdout1_27ck250 FIND v(dout1_27) AT=130.025n

.meas tran vdout1_28ck250 FIND v(dout1_28) AT=130.025n

.meas tran vdout1_29ck250 FIND v(dout1_29) AT=130.025n

.meas tran vdout1_30ck250 FIND v(dout1_30) AT=130.025n

.meas tran vdout1_31ck250 FIND v(dout1_31) AT=130.025n

.meas tran vdout1_32ck250 FIND v(dout1_32) AT=130.025n

.meas tran vdout1_33ck250 FIND v(dout1_33) AT=130.025n

.meas tran vdout1_34ck250 FIND v(dout1_34) AT=130.025n

.meas tran vdout1_35ck250 FIND v(dout1_35) AT=130.025n

.meas tran vdout1_36ck250 FIND v(dout1_36) AT=130.025n

.meas tran vdout1_37ck250 FIND v(dout1_37) AT=130.025n

.meas tran vdout1_38ck250 FIND v(dout1_38) AT=130.025n

.meas tran vdout1_39ck250 FIND v(dout1_39) AT=130.025n

.meas tran vdout1_40ck250 FIND v(dout1_40) AT=130.025n

.meas tran vdout1_41ck250 FIND v(dout1_41) AT=130.025n

.meas tran vdout1_42ck250 FIND v(dout1_42) AT=130.025n

.meas tran vdout1_43ck250 FIND v(dout1_43) AT=130.025n

.meas tran vdout1_44ck250 FIND v(dout1_44) AT=130.025n

.meas tran vdout1_45ck250 FIND v(dout1_45) AT=130.025n

.meas tran vdout1_46ck250 FIND v(dout1_46) AT=130.025n

.meas tran vdout1_47ck250 FIND v(dout1_47) AT=130.025n

.meas tran vdout1_48ck250 FIND v(dout1_48) AT=130.025n

.meas tran vdout1_49ck250 FIND v(dout1_49) AT=130.025n

.meas tran vdout1_50ck250 FIND v(dout1_50) AT=130.025n

.meas tran vdout1_51ck250 FIND v(dout1_51) AT=130.025n

.meas tran vdout1_52ck250 FIND v(dout1_52) AT=130.025n

.meas tran vdout1_53ck250 FIND v(dout1_53) AT=130.025n

.meas tran vdout1_54ck250 FIND v(dout1_54) AT=130.025n

.meas tran vdout1_55ck250 FIND v(dout1_55) AT=130.025n

.meas tran vdout1_56ck250 FIND v(dout1_56) AT=130.025n

.meas tran vdout1_57ck250 FIND v(dout1_57) AT=130.025n

.meas tran vdout1_58ck250 FIND v(dout1_58) AT=130.025n

.meas tran vdout1_59ck250 FIND v(dout1_59) AT=130.025n

.meas tran vdout1_60ck250 FIND v(dout1_60) AT=130.025n

.meas tran vdout1_61ck250 FIND v(dout1_61) AT=130.025n

.meas tran vdout1_62ck250 FIND v(dout1_62) AT=130.025n

.meas tran vdout1_63ck250 FIND v(dout1_63) AT=130.025n

.meas tran vdout1_0ck270 FIND v(dout1_0) AT=140.025n

.meas tran vdout1_1ck270 FIND v(dout1_1) AT=140.025n

.meas tran vdout1_2ck270 FIND v(dout1_2) AT=140.025n

.meas tran vdout1_3ck270 FIND v(dout1_3) AT=140.025n

.meas tran vdout1_4ck270 FIND v(dout1_4) AT=140.025n

.meas tran vdout1_5ck270 FIND v(dout1_5) AT=140.025n

.meas tran vdout1_6ck270 FIND v(dout1_6) AT=140.025n

.meas tran vdout1_7ck270 FIND v(dout1_7) AT=140.025n

.meas tran vdout1_8ck270 FIND v(dout1_8) AT=140.025n

.meas tran vdout1_9ck270 FIND v(dout1_9) AT=140.025n

.meas tran vdout1_10ck270 FIND v(dout1_10) AT=140.025n

.meas tran vdout1_11ck270 FIND v(dout1_11) AT=140.025n

.meas tran vdout1_12ck270 FIND v(dout1_12) AT=140.025n

.meas tran vdout1_13ck270 FIND v(dout1_13) AT=140.025n

.meas tran vdout1_14ck270 FIND v(dout1_14) AT=140.025n

.meas tran vdout1_15ck270 FIND v(dout1_15) AT=140.025n

.meas tran vdout1_16ck270 FIND v(dout1_16) AT=140.025n

.meas tran vdout1_17ck270 FIND v(dout1_17) AT=140.025n

.meas tran vdout1_18ck270 FIND v(dout1_18) AT=140.025n

.meas tran vdout1_19ck270 FIND v(dout1_19) AT=140.025n

.meas tran vdout1_20ck270 FIND v(dout1_20) AT=140.025n

.meas tran vdout1_21ck270 FIND v(dout1_21) AT=140.025n

.meas tran vdout1_22ck270 FIND v(dout1_22) AT=140.025n

.meas tran vdout1_23ck270 FIND v(dout1_23) AT=140.025n

.meas tran vdout1_24ck270 FIND v(dout1_24) AT=140.025n

.meas tran vdout1_25ck270 FIND v(dout1_25) AT=140.025n

.meas tran vdout1_26ck270 FIND v(dout1_26) AT=140.025n

.meas tran vdout1_27ck270 FIND v(dout1_27) AT=140.025n

.meas tran vdout1_28ck270 FIND v(dout1_28) AT=140.025n

.meas tran vdout1_29ck270 FIND v(dout1_29) AT=140.025n

.meas tran vdout1_30ck270 FIND v(dout1_30) AT=140.025n

.meas tran vdout1_31ck270 FIND v(dout1_31) AT=140.025n

.meas tran vdout1_32ck270 FIND v(dout1_32) AT=140.025n

.meas tran vdout1_33ck270 FIND v(dout1_33) AT=140.025n

.meas tran vdout1_34ck270 FIND v(dout1_34) AT=140.025n

.meas tran vdout1_35ck270 FIND v(dout1_35) AT=140.025n

.meas tran vdout1_36ck270 FIND v(dout1_36) AT=140.025n

.meas tran vdout1_37ck270 FIND v(dout1_37) AT=140.025n

.meas tran vdout1_38ck270 FIND v(dout1_38) AT=140.025n

.meas tran vdout1_39ck270 FIND v(dout1_39) AT=140.025n

.meas tran vdout1_40ck270 FIND v(dout1_40) AT=140.025n

.meas tran vdout1_41ck270 FIND v(dout1_41) AT=140.025n

.meas tran vdout1_42ck270 FIND v(dout1_42) AT=140.025n

.meas tran vdout1_43ck270 FIND v(dout1_43) AT=140.025n

.meas tran vdout1_44ck270 FIND v(dout1_44) AT=140.025n

.meas tran vdout1_45ck270 FIND v(dout1_45) AT=140.025n

.meas tran vdout1_46ck270 FIND v(dout1_46) AT=140.025n

.meas tran vdout1_47ck270 FIND v(dout1_47) AT=140.025n

.meas tran vdout1_48ck270 FIND v(dout1_48) AT=140.025n

.meas tran vdout1_49ck270 FIND v(dout1_49) AT=140.025n

.meas tran vdout1_50ck270 FIND v(dout1_50) AT=140.025n

.meas tran vdout1_51ck270 FIND v(dout1_51) AT=140.025n

.meas tran vdout1_52ck270 FIND v(dout1_52) AT=140.025n

.meas tran vdout1_53ck270 FIND v(dout1_53) AT=140.025n

.meas tran vdout1_54ck270 FIND v(dout1_54) AT=140.025n

.meas tran vdout1_55ck270 FIND v(dout1_55) AT=140.025n

.meas tran vdout1_56ck270 FIND v(dout1_56) AT=140.025n

.meas tran vdout1_57ck270 FIND v(dout1_57) AT=140.025n

.meas tran vdout1_58ck270 FIND v(dout1_58) AT=140.025n

.meas tran vdout1_59ck270 FIND v(dout1_59) AT=140.025n

.meas tran vdout1_60ck270 FIND v(dout1_60) AT=140.025n

.meas tran vdout1_61ck270 FIND v(dout1_61) AT=140.025n

.meas tran vdout1_62ck270 FIND v(dout1_62) AT=140.025n

.meas tran vdout1_63ck270 FIND v(dout1_63) AT=140.025n

.meas tran vdout1_0ck280 FIND v(dout1_0) AT=145.025n

.meas tran vdout1_1ck280 FIND v(dout1_1) AT=145.025n

.meas tran vdout1_2ck280 FIND v(dout1_2) AT=145.025n

.meas tran vdout1_3ck280 FIND v(dout1_3) AT=145.025n

.meas tran vdout1_4ck280 FIND v(dout1_4) AT=145.025n

.meas tran vdout1_5ck280 FIND v(dout1_5) AT=145.025n

.meas tran vdout1_6ck280 FIND v(dout1_6) AT=145.025n

.meas tran vdout1_7ck280 FIND v(dout1_7) AT=145.025n

.meas tran vdout1_8ck280 FIND v(dout1_8) AT=145.025n

.meas tran vdout1_9ck280 FIND v(dout1_9) AT=145.025n

.meas tran vdout1_10ck280 FIND v(dout1_10) AT=145.025n

.meas tran vdout1_11ck280 FIND v(dout1_11) AT=145.025n

.meas tran vdout1_12ck280 FIND v(dout1_12) AT=145.025n

.meas tran vdout1_13ck280 FIND v(dout1_13) AT=145.025n

.meas tran vdout1_14ck280 FIND v(dout1_14) AT=145.025n

.meas tran vdout1_15ck280 FIND v(dout1_15) AT=145.025n

.meas tran vdout1_16ck280 FIND v(dout1_16) AT=145.025n

.meas tran vdout1_17ck280 FIND v(dout1_17) AT=145.025n

.meas tran vdout1_18ck280 FIND v(dout1_18) AT=145.025n

.meas tran vdout1_19ck280 FIND v(dout1_19) AT=145.025n

.meas tran vdout1_20ck280 FIND v(dout1_20) AT=145.025n

.meas tran vdout1_21ck280 FIND v(dout1_21) AT=145.025n

.meas tran vdout1_22ck280 FIND v(dout1_22) AT=145.025n

.meas tran vdout1_23ck280 FIND v(dout1_23) AT=145.025n

.meas tran vdout1_24ck280 FIND v(dout1_24) AT=145.025n

.meas tran vdout1_25ck280 FIND v(dout1_25) AT=145.025n

.meas tran vdout1_26ck280 FIND v(dout1_26) AT=145.025n

.meas tran vdout1_27ck280 FIND v(dout1_27) AT=145.025n

.meas tran vdout1_28ck280 FIND v(dout1_28) AT=145.025n

.meas tran vdout1_29ck280 FIND v(dout1_29) AT=145.025n

.meas tran vdout1_30ck280 FIND v(dout1_30) AT=145.025n

.meas tran vdout1_31ck280 FIND v(dout1_31) AT=145.025n

.meas tran vdout1_32ck280 FIND v(dout1_32) AT=145.025n

.meas tran vdout1_33ck280 FIND v(dout1_33) AT=145.025n

.meas tran vdout1_34ck280 FIND v(dout1_34) AT=145.025n

.meas tran vdout1_35ck280 FIND v(dout1_35) AT=145.025n

.meas tran vdout1_36ck280 FIND v(dout1_36) AT=145.025n

.meas tran vdout1_37ck280 FIND v(dout1_37) AT=145.025n

.meas tran vdout1_38ck280 FIND v(dout1_38) AT=145.025n

.meas tran vdout1_39ck280 FIND v(dout1_39) AT=145.025n

.meas tran vdout1_40ck280 FIND v(dout1_40) AT=145.025n

.meas tran vdout1_41ck280 FIND v(dout1_41) AT=145.025n

.meas tran vdout1_42ck280 FIND v(dout1_42) AT=145.025n

.meas tran vdout1_43ck280 FIND v(dout1_43) AT=145.025n

.meas tran vdout1_44ck280 FIND v(dout1_44) AT=145.025n

.meas tran vdout1_45ck280 FIND v(dout1_45) AT=145.025n

.meas tran vdout1_46ck280 FIND v(dout1_46) AT=145.025n

.meas tran vdout1_47ck280 FIND v(dout1_47) AT=145.025n

.meas tran vdout1_48ck280 FIND v(dout1_48) AT=145.025n

.meas tran vdout1_49ck280 FIND v(dout1_49) AT=145.025n

.meas tran vdout1_50ck280 FIND v(dout1_50) AT=145.025n

.meas tran vdout1_51ck280 FIND v(dout1_51) AT=145.025n

.meas tran vdout1_52ck280 FIND v(dout1_52) AT=145.025n

.meas tran vdout1_53ck280 FIND v(dout1_53) AT=145.025n

.meas tran vdout1_54ck280 FIND v(dout1_54) AT=145.025n

.meas tran vdout1_55ck280 FIND v(dout1_55) AT=145.025n

.meas tran vdout1_56ck280 FIND v(dout1_56) AT=145.025n

.meas tran vdout1_57ck280 FIND v(dout1_57) AT=145.025n

.meas tran vdout1_58ck280 FIND v(dout1_58) AT=145.025n

.meas tran vdout1_59ck280 FIND v(dout1_59) AT=145.025n

.meas tran vdout1_60ck280 FIND v(dout1_60) AT=145.025n

.meas tran vdout1_61ck280 FIND v(dout1_61) AT=145.025n

.meas tran vdout1_62ck280 FIND v(dout1_62) AT=145.025n

.meas tran vdout1_63ck280 FIND v(dout1_63) AT=145.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_19ck290 FIND v(dout1_19) AT=150.025n

.meas tran vdout1_20ck290 FIND v(dout1_20) AT=150.025n

.meas tran vdout1_21ck290 FIND v(dout1_21) AT=150.025n

.meas tran vdout1_22ck290 FIND v(dout1_22) AT=150.025n

.meas tran vdout1_23ck290 FIND v(dout1_23) AT=150.025n

.meas tran vdout1_24ck290 FIND v(dout1_24) AT=150.025n

.meas tran vdout1_25ck290 FIND v(dout1_25) AT=150.025n

.meas tran vdout1_26ck290 FIND v(dout1_26) AT=150.025n

.meas tran vdout1_27ck290 FIND v(dout1_27) AT=150.025n

.meas tran vdout1_28ck290 FIND v(dout1_28) AT=150.025n

.meas tran vdout1_29ck290 FIND v(dout1_29) AT=150.025n

.meas tran vdout1_30ck290 FIND v(dout1_30) AT=150.025n

.meas tran vdout1_31ck290 FIND v(dout1_31) AT=150.025n

.meas tran vdout1_32ck290 FIND v(dout1_32) AT=150.025n

.meas tran vdout1_33ck290 FIND v(dout1_33) AT=150.025n

.meas tran vdout1_34ck290 FIND v(dout1_34) AT=150.025n

.meas tran vdout1_35ck290 FIND v(dout1_35) AT=150.025n

.meas tran vdout1_36ck290 FIND v(dout1_36) AT=150.025n

.meas tran vdout1_37ck290 FIND v(dout1_37) AT=150.025n

.meas tran vdout1_38ck290 FIND v(dout1_38) AT=150.025n

.meas tran vdout1_39ck290 FIND v(dout1_39) AT=150.025n

.meas tran vdout1_40ck290 FIND v(dout1_40) AT=150.025n

.meas tran vdout1_41ck290 FIND v(dout1_41) AT=150.025n

.meas tran vdout1_42ck290 FIND v(dout1_42) AT=150.025n

.meas tran vdout1_43ck290 FIND v(dout1_43) AT=150.025n

.meas tran vdout1_44ck290 FIND v(dout1_44) AT=150.025n

.meas tran vdout1_45ck290 FIND v(dout1_45) AT=150.025n

.meas tran vdout1_46ck290 FIND v(dout1_46) AT=150.025n

.meas tran vdout1_47ck290 FIND v(dout1_47) AT=150.025n

.meas tran vdout1_48ck290 FIND v(dout1_48) AT=150.025n

.meas tran vdout1_49ck290 FIND v(dout1_49) AT=150.025n

.meas tran vdout1_50ck290 FIND v(dout1_50) AT=150.025n

.meas tran vdout1_51ck290 FIND v(dout1_51) AT=150.025n

.meas tran vdout1_52ck290 FIND v(dout1_52) AT=150.025n

.meas tran vdout1_53ck290 FIND v(dout1_53) AT=150.025n

.meas tran vdout1_54ck290 FIND v(dout1_54) AT=150.025n

.meas tran vdout1_55ck290 FIND v(dout1_55) AT=150.025n

.meas tran vdout1_56ck290 FIND v(dout1_56) AT=150.025n

.meas tran vdout1_57ck290 FIND v(dout1_57) AT=150.025n

.meas tran vdout1_58ck290 FIND v(dout1_58) AT=150.025n

.meas tran vdout1_59ck290 FIND v(dout1_59) AT=150.025n

.meas tran vdout1_60ck290 FIND v(dout1_60) AT=150.025n

.meas tran vdout1_61ck290 FIND v(dout1_61) AT=150.025n

.meas tran vdout1_62ck290 FIND v(dout1_62) AT=150.025n

.meas tran vdout1_63ck290 FIND v(dout1_63) AT=150.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_23ck310 FIND v(dout1_23) AT=160.025n

.meas tran vdout1_24ck310 FIND v(dout1_24) AT=160.025n

.meas tran vdout1_25ck310 FIND v(dout1_25) AT=160.025n

.meas tran vdout1_26ck310 FIND v(dout1_26) AT=160.025n

.meas tran vdout1_27ck310 FIND v(dout1_27) AT=160.025n

.meas tran vdout1_28ck310 FIND v(dout1_28) AT=160.025n

.meas tran vdout1_29ck310 FIND v(dout1_29) AT=160.025n

.meas tran vdout1_30ck310 FIND v(dout1_30) AT=160.025n

.meas tran vdout1_31ck310 FIND v(dout1_31) AT=160.025n

.meas tran vdout1_32ck310 FIND v(dout1_32) AT=160.025n

.meas tran vdout1_33ck310 FIND v(dout1_33) AT=160.025n

.meas tran vdout1_34ck310 FIND v(dout1_34) AT=160.025n

.meas tran vdout1_35ck310 FIND v(dout1_35) AT=160.025n

.meas tran vdout1_36ck310 FIND v(dout1_36) AT=160.025n

.meas tran vdout1_37ck310 FIND v(dout1_37) AT=160.025n

.meas tran vdout1_38ck310 FIND v(dout1_38) AT=160.025n

.meas tran vdout1_39ck310 FIND v(dout1_39) AT=160.025n

.meas tran vdout1_40ck310 FIND v(dout1_40) AT=160.025n

.meas tran vdout1_41ck310 FIND v(dout1_41) AT=160.025n

.meas tran vdout1_42ck310 FIND v(dout1_42) AT=160.025n

.meas tran vdout1_43ck310 FIND v(dout1_43) AT=160.025n

.meas tran vdout1_44ck310 FIND v(dout1_44) AT=160.025n

.meas tran vdout1_45ck310 FIND v(dout1_45) AT=160.025n

.meas tran vdout1_46ck310 FIND v(dout1_46) AT=160.025n

.meas tran vdout1_47ck310 FIND v(dout1_47) AT=160.025n

.meas tran vdout1_48ck310 FIND v(dout1_48) AT=160.025n

.meas tran vdout1_49ck310 FIND v(dout1_49) AT=160.025n

.meas tran vdout1_50ck310 FIND v(dout1_50) AT=160.025n

.meas tran vdout1_51ck310 FIND v(dout1_51) AT=160.025n

.meas tran vdout1_52ck310 FIND v(dout1_52) AT=160.025n

.meas tran vdout1_53ck310 FIND v(dout1_53) AT=160.025n

.meas tran vdout1_54ck310 FIND v(dout1_54) AT=160.025n

.meas tran vdout1_55ck310 FIND v(dout1_55) AT=160.025n

.meas tran vdout1_56ck310 FIND v(dout1_56) AT=160.025n

.meas tran vdout1_57ck310 FIND v(dout1_57) AT=160.025n

.meas tran vdout1_58ck310 FIND v(dout1_58) AT=160.025n

.meas tran vdout1_59ck310 FIND v(dout1_59) AT=160.025n

.meas tran vdout1_60ck310 FIND v(dout1_60) AT=160.025n

.meas tran vdout1_61ck310 FIND v(dout1_61) AT=160.025n

.meas tran vdout1_62ck310 FIND v(dout1_62) AT=160.025n

.meas tran vdout1_63ck310 FIND v(dout1_63) AT=160.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_17ck330 FIND v(dout1_17) AT=170.025n

.meas tran vdout1_18ck330 FIND v(dout1_18) AT=170.025n

.meas tran vdout1_19ck330 FIND v(dout1_19) AT=170.025n

.meas tran vdout1_20ck330 FIND v(dout1_20) AT=170.025n

.meas tran vdout1_21ck330 FIND v(dout1_21) AT=170.025n

.meas tran vdout1_22ck330 FIND v(dout1_22) AT=170.025n

.meas tran vdout1_23ck330 FIND v(dout1_23) AT=170.025n

.meas tran vdout1_24ck330 FIND v(dout1_24) AT=170.025n

.meas tran vdout1_25ck330 FIND v(dout1_25) AT=170.025n

.meas tran vdout1_26ck330 FIND v(dout1_26) AT=170.025n

.meas tran vdout1_27ck330 FIND v(dout1_27) AT=170.025n

.meas tran vdout1_28ck330 FIND v(dout1_28) AT=170.025n

.meas tran vdout1_29ck330 FIND v(dout1_29) AT=170.025n

.meas tran vdout1_30ck330 FIND v(dout1_30) AT=170.025n

.meas tran vdout1_31ck330 FIND v(dout1_31) AT=170.025n

.meas tran vdout1_32ck330 FIND v(dout1_32) AT=170.025n

.meas tran vdout1_33ck330 FIND v(dout1_33) AT=170.025n

.meas tran vdout1_34ck330 FIND v(dout1_34) AT=170.025n

.meas tran vdout1_35ck330 FIND v(dout1_35) AT=170.025n

.meas tran vdout1_36ck330 FIND v(dout1_36) AT=170.025n

.meas tran vdout1_37ck330 FIND v(dout1_37) AT=170.025n

.meas tran vdout1_38ck330 FIND v(dout1_38) AT=170.025n

.meas tran vdout1_39ck330 FIND v(dout1_39) AT=170.025n

.meas tran vdout1_40ck330 FIND v(dout1_40) AT=170.025n

.meas tran vdout1_41ck330 FIND v(dout1_41) AT=170.025n

.meas tran vdout1_42ck330 FIND v(dout1_42) AT=170.025n

.meas tran vdout1_43ck330 FIND v(dout1_43) AT=170.025n

.meas tran vdout1_44ck330 FIND v(dout1_44) AT=170.025n

.meas tran vdout1_45ck330 FIND v(dout1_45) AT=170.025n

.meas tran vdout1_46ck330 FIND v(dout1_46) AT=170.025n

.meas tran vdout1_47ck330 FIND v(dout1_47) AT=170.025n

.meas tran vdout1_48ck330 FIND v(dout1_48) AT=170.025n

.meas tran vdout1_49ck330 FIND v(dout1_49) AT=170.025n

.meas tran vdout1_50ck330 FIND v(dout1_50) AT=170.025n

.meas tran vdout1_51ck330 FIND v(dout1_51) AT=170.025n

.meas tran vdout1_52ck330 FIND v(dout1_52) AT=170.025n

.meas tran vdout1_53ck330 FIND v(dout1_53) AT=170.025n

.meas tran vdout1_54ck330 FIND v(dout1_54) AT=170.025n

.meas tran vdout1_55ck330 FIND v(dout1_55) AT=170.025n

.meas tran vdout1_56ck330 FIND v(dout1_56) AT=170.025n

.meas tran vdout1_57ck330 FIND v(dout1_57) AT=170.025n

.meas tran vdout1_58ck330 FIND v(dout1_58) AT=170.025n

.meas tran vdout1_59ck330 FIND v(dout1_59) AT=170.025n

.meas tran vdout1_60ck330 FIND v(dout1_60) AT=170.025n

.meas tran vdout1_61ck330 FIND v(dout1_61) AT=170.025n

.meas tran vdout1_62ck330 FIND v(dout1_62) AT=170.025n

.meas tran vdout1_63ck330 FIND v(dout1_63) AT=170.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_22ck350 FIND v(dout1_22) AT=180.025n

.meas tran vdout1_23ck350 FIND v(dout1_23) AT=180.025n

.meas tran vdout1_24ck350 FIND v(dout1_24) AT=180.025n

.meas tran vdout1_25ck350 FIND v(dout1_25) AT=180.025n

.meas tran vdout1_26ck350 FIND v(dout1_26) AT=180.025n

.meas tran vdout1_27ck350 FIND v(dout1_27) AT=180.025n

.meas tran vdout1_28ck350 FIND v(dout1_28) AT=180.025n

.meas tran vdout1_29ck350 FIND v(dout1_29) AT=180.025n

.meas tran vdout1_30ck350 FIND v(dout1_30) AT=180.025n

.meas tran vdout1_31ck350 FIND v(dout1_31) AT=180.025n

.meas tran vdout1_32ck350 FIND v(dout1_32) AT=180.025n

.meas tran vdout1_33ck350 FIND v(dout1_33) AT=180.025n

.meas tran vdout1_34ck350 FIND v(dout1_34) AT=180.025n

.meas tran vdout1_35ck350 FIND v(dout1_35) AT=180.025n

.meas tran vdout1_36ck350 FIND v(dout1_36) AT=180.025n

.meas tran vdout1_37ck350 FIND v(dout1_37) AT=180.025n

.meas tran vdout1_38ck350 FIND v(dout1_38) AT=180.025n

.meas tran vdout1_39ck350 FIND v(dout1_39) AT=180.025n

.meas tran vdout1_40ck350 FIND v(dout1_40) AT=180.025n

.meas tran vdout1_41ck350 FIND v(dout1_41) AT=180.025n

.meas tran vdout1_42ck350 FIND v(dout1_42) AT=180.025n

.meas tran vdout1_43ck350 FIND v(dout1_43) AT=180.025n

.meas tran vdout1_44ck350 FIND v(dout1_44) AT=180.025n

.meas tran vdout1_45ck350 FIND v(dout1_45) AT=180.025n

.meas tran vdout1_46ck350 FIND v(dout1_46) AT=180.025n

.meas tran vdout1_47ck350 FIND v(dout1_47) AT=180.025n

.meas tran vdout1_48ck350 FIND v(dout1_48) AT=180.025n

.meas tran vdout1_49ck350 FIND v(dout1_49) AT=180.025n

.meas tran vdout1_50ck350 FIND v(dout1_50) AT=180.025n

.meas tran vdout1_51ck350 FIND v(dout1_51) AT=180.025n

.meas tran vdout1_52ck350 FIND v(dout1_52) AT=180.025n

.meas tran vdout1_53ck350 FIND v(dout1_53) AT=180.025n

.meas tran vdout1_54ck350 FIND v(dout1_54) AT=180.025n

.meas tran vdout1_55ck350 FIND v(dout1_55) AT=180.025n

.meas tran vdout1_56ck350 FIND v(dout1_56) AT=180.025n

.meas tran vdout1_57ck350 FIND v(dout1_57) AT=180.025n

.meas tran vdout1_58ck350 FIND v(dout1_58) AT=180.025n

.meas tran vdout1_59ck350 FIND v(dout1_59) AT=180.025n

.meas tran vdout1_60ck350 FIND v(dout1_60) AT=180.025n

.meas tran vdout1_61ck350 FIND v(dout1_61) AT=180.025n

.meas tran vdout1_62ck350 FIND v(dout1_62) AT=180.025n

.meas tran vdout1_63ck350 FIND v(dout1_63) AT=180.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_23ck360 FIND v(dout1_23) AT=185.025n

.meas tran vdout1_24ck360 FIND v(dout1_24) AT=185.025n

.meas tran vdout1_25ck360 FIND v(dout1_25) AT=185.025n

.meas tran vdout1_26ck360 FIND v(dout1_26) AT=185.025n

.meas tran vdout1_27ck360 FIND v(dout1_27) AT=185.025n

.meas tran vdout1_28ck360 FIND v(dout1_28) AT=185.025n

.meas tran vdout1_29ck360 FIND v(dout1_29) AT=185.025n

.meas tran vdout1_30ck360 FIND v(dout1_30) AT=185.025n

.meas tran vdout1_31ck360 FIND v(dout1_31) AT=185.025n

.meas tran vdout1_32ck360 FIND v(dout1_32) AT=185.025n

.meas tran vdout1_33ck360 FIND v(dout1_33) AT=185.025n

.meas tran vdout1_34ck360 FIND v(dout1_34) AT=185.025n

.meas tran vdout1_35ck360 FIND v(dout1_35) AT=185.025n

.meas tran vdout1_36ck360 FIND v(dout1_36) AT=185.025n

.meas tran vdout1_37ck360 FIND v(dout1_37) AT=185.025n

.meas tran vdout1_38ck360 FIND v(dout1_38) AT=185.025n

.meas tran vdout1_39ck360 FIND v(dout1_39) AT=185.025n

.meas tran vdout1_40ck360 FIND v(dout1_40) AT=185.025n

.meas tran vdout1_41ck360 FIND v(dout1_41) AT=185.025n

.meas tran vdout1_42ck360 FIND v(dout1_42) AT=185.025n

.meas tran vdout1_43ck360 FIND v(dout1_43) AT=185.025n

.meas tran vdout1_44ck360 FIND v(dout1_44) AT=185.025n

.meas tran vdout1_45ck360 FIND v(dout1_45) AT=185.025n

.meas tran vdout1_46ck360 FIND v(dout1_46) AT=185.025n

.meas tran vdout1_47ck360 FIND v(dout1_47) AT=185.025n

.meas tran vdout1_48ck360 FIND v(dout1_48) AT=185.025n

.meas tran vdout1_49ck360 FIND v(dout1_49) AT=185.025n

.meas tran vdout1_50ck360 FIND v(dout1_50) AT=185.025n

.meas tran vdout1_51ck360 FIND v(dout1_51) AT=185.025n

.meas tran vdout1_52ck360 FIND v(dout1_52) AT=185.025n

.meas tran vdout1_53ck360 FIND v(dout1_53) AT=185.025n

.meas tran vdout1_54ck360 FIND v(dout1_54) AT=185.025n

.meas tran vdout1_55ck360 FIND v(dout1_55) AT=185.025n

.meas tran vdout1_56ck360 FIND v(dout1_56) AT=185.025n

.meas tran vdout1_57ck360 FIND v(dout1_57) AT=185.025n

.meas tran vdout1_58ck360 FIND v(dout1_58) AT=185.025n

.meas tran vdout1_59ck360 FIND v(dout1_59) AT=185.025n

.meas tran vdout1_60ck360 FIND v(dout1_60) AT=185.025n

.meas tran vdout1_61ck360 FIND v(dout1_61) AT=185.025n

.meas tran vdout1_62ck360 FIND v(dout1_62) AT=185.025n

.meas tran vdout1_63ck360 FIND v(dout1_63) AT=185.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_8ck390 FIND v(dout1_8) AT=200.025n

.meas tran vdout1_9ck390 FIND v(dout1_9) AT=200.025n

.meas tran vdout1_10ck390 FIND v(dout1_10) AT=200.025n

.meas tran vdout1_11ck390 FIND v(dout1_11) AT=200.025n

.meas tran vdout1_12ck390 FIND v(dout1_12) AT=200.025n

.meas tran vdout1_13ck390 FIND v(dout1_13) AT=200.025n

.meas tran vdout1_14ck390 FIND v(dout1_14) AT=200.025n

.meas tran vdout1_15ck390 FIND v(dout1_15) AT=200.025n

.meas tran vdout1_16ck390 FIND v(dout1_16) AT=200.025n

.meas tran vdout1_17ck390 FIND v(dout1_17) AT=200.025n

.meas tran vdout1_18ck390 FIND v(dout1_18) AT=200.025n

.meas tran vdout1_19ck390 FIND v(dout1_19) AT=200.025n

.meas tran vdout1_20ck390 FIND v(dout1_20) AT=200.025n

.meas tran vdout1_21ck390 FIND v(dout1_21) AT=200.025n

.meas tran vdout1_22ck390 FIND v(dout1_22) AT=200.025n

.meas tran vdout1_23ck390 FIND v(dout1_23) AT=200.025n

.meas tran vdout1_24ck390 FIND v(dout1_24) AT=200.025n

.meas tran vdout1_25ck390 FIND v(dout1_25) AT=200.025n

.meas tran vdout1_26ck390 FIND v(dout1_26) AT=200.025n

.meas tran vdout1_27ck390 FIND v(dout1_27) AT=200.025n

.meas tran vdout1_28ck390 FIND v(dout1_28) AT=200.025n

.meas tran vdout1_29ck390 FIND v(dout1_29) AT=200.025n

.meas tran vdout1_30ck390 FIND v(dout1_30) AT=200.025n

.meas tran vdout1_31ck390 FIND v(dout1_31) AT=200.025n

.meas tran vdout1_32ck390 FIND v(dout1_32) AT=200.025n

.meas tran vdout1_33ck390 FIND v(dout1_33) AT=200.025n

.meas tran vdout1_34ck390 FIND v(dout1_34) AT=200.025n

.meas tran vdout1_35ck390 FIND v(dout1_35) AT=200.025n

.meas tran vdout1_36ck390 FIND v(dout1_36) AT=200.025n

.meas tran vdout1_37ck390 FIND v(dout1_37) AT=200.025n

.meas tran vdout1_38ck390 FIND v(dout1_38) AT=200.025n

.meas tran vdout1_39ck390 FIND v(dout1_39) AT=200.025n

.meas tran vdout1_40ck390 FIND v(dout1_40) AT=200.025n

.meas tran vdout1_41ck390 FIND v(dout1_41) AT=200.025n

.meas tran vdout1_42ck390 FIND v(dout1_42) AT=200.025n

.meas tran vdout1_43ck390 FIND v(dout1_43) AT=200.025n

.meas tran vdout1_44ck390 FIND v(dout1_44) AT=200.025n

.meas tran vdout1_45ck390 FIND v(dout1_45) AT=200.025n

.meas tran vdout1_46ck390 FIND v(dout1_46) AT=200.025n

.meas tran vdout1_47ck390 FIND v(dout1_47) AT=200.025n

.meas tran vdout1_48ck390 FIND v(dout1_48) AT=200.025n

.meas tran vdout1_49ck390 FIND v(dout1_49) AT=200.025n

.meas tran vdout1_50ck390 FIND v(dout1_50) AT=200.025n

.meas tran vdout1_51ck390 FIND v(dout1_51) AT=200.025n

.meas tran vdout1_52ck390 FIND v(dout1_52) AT=200.025n

.meas tran vdout1_53ck390 FIND v(dout1_53) AT=200.025n

.meas tran vdout1_54ck390 FIND v(dout1_54) AT=200.025n

.meas tran vdout1_55ck390 FIND v(dout1_55) AT=200.025n

.meas tran vdout1_56ck390 FIND v(dout1_56) AT=200.025n

.meas tran vdout1_57ck390 FIND v(dout1_57) AT=200.025n

.meas tran vdout1_58ck390 FIND v(dout1_58) AT=200.025n

.meas tran vdout1_59ck390 FIND v(dout1_59) AT=200.025n

.meas tran vdout1_60ck390 FIND v(dout1_60) AT=200.025n

.meas tran vdout1_61ck390 FIND v(dout1_61) AT=200.025n

.meas tran vdout1_62ck390 FIND v(dout1_62) AT=200.025n

.meas tran vdout1_63ck390 FIND v(dout1_63) AT=200.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_16ck440 FIND v(dout1_16) AT=225.025n

.meas tran vdout1_17ck440 FIND v(dout1_17) AT=225.025n

.meas tran vdout1_18ck440 FIND v(dout1_18) AT=225.025n

.meas tran vdout1_19ck440 FIND v(dout1_19) AT=225.025n

.meas tran vdout1_20ck440 FIND v(dout1_20) AT=225.025n

.meas tran vdout1_21ck440 FIND v(dout1_21) AT=225.025n

.meas tran vdout1_22ck440 FIND v(dout1_22) AT=225.025n

.meas tran vdout1_23ck440 FIND v(dout1_23) AT=225.025n

.meas tran vdout1_24ck440 FIND v(dout1_24) AT=225.025n

.meas tran vdout1_25ck440 FIND v(dout1_25) AT=225.025n

.meas tran vdout1_26ck440 FIND v(dout1_26) AT=225.025n

.meas tran vdout1_27ck440 FIND v(dout1_27) AT=225.025n

.meas tran vdout1_28ck440 FIND v(dout1_28) AT=225.025n

.meas tran vdout1_29ck440 FIND v(dout1_29) AT=225.025n

.meas tran vdout1_30ck440 FIND v(dout1_30) AT=225.025n

.meas tran vdout1_31ck440 FIND v(dout1_31) AT=225.025n

.meas tran vdout1_32ck440 FIND v(dout1_32) AT=225.025n

.meas tran vdout1_33ck440 FIND v(dout1_33) AT=225.025n

.meas tran vdout1_34ck440 FIND v(dout1_34) AT=225.025n

.meas tran vdout1_35ck440 FIND v(dout1_35) AT=225.025n

.meas tran vdout1_36ck440 FIND v(dout1_36) AT=225.025n

.meas tran vdout1_37ck440 FIND v(dout1_37) AT=225.025n

.meas tran vdout1_38ck440 FIND v(dout1_38) AT=225.025n

.meas tran vdout1_39ck440 FIND v(dout1_39) AT=225.025n

.meas tran vdout1_40ck440 FIND v(dout1_40) AT=225.025n

.meas tran vdout1_41ck440 FIND v(dout1_41) AT=225.025n

.meas tran vdout1_42ck440 FIND v(dout1_42) AT=225.025n

.meas tran vdout1_43ck440 FIND v(dout1_43) AT=225.025n

.meas tran vdout1_44ck440 FIND v(dout1_44) AT=225.025n

.meas tran vdout1_45ck440 FIND v(dout1_45) AT=225.025n

.meas tran vdout1_46ck440 FIND v(dout1_46) AT=225.025n

.meas tran vdout1_47ck440 FIND v(dout1_47) AT=225.025n

.meas tran vdout1_48ck440 FIND v(dout1_48) AT=225.025n

.meas tran vdout1_49ck440 FIND v(dout1_49) AT=225.025n

.meas tran vdout1_50ck440 FIND v(dout1_50) AT=225.025n

.meas tran vdout1_51ck440 FIND v(dout1_51) AT=225.025n

.meas tran vdout1_52ck440 FIND v(dout1_52) AT=225.025n

.meas tran vdout1_53ck440 FIND v(dout1_53) AT=225.025n

.meas tran vdout1_54ck440 FIND v(dout1_54) AT=225.025n

.meas tran vdout1_55ck440 FIND v(dout1_55) AT=225.025n

.meas tran vdout1_56ck440 FIND v(dout1_56) AT=225.025n

.meas tran vdout1_57ck440 FIND v(dout1_57) AT=225.025n

.meas tran vdout1_58ck440 FIND v(dout1_58) AT=225.025n

.meas tran vdout1_59ck440 FIND v(dout1_59) AT=225.025n

.meas tran vdout1_60ck440 FIND v(dout1_60) AT=225.025n

.meas tran vdout1_61ck440 FIND v(dout1_61) AT=225.025n

.meas tran vdout1_62ck440 FIND v(dout1_62) AT=225.025n

.meas tran vdout1_63ck440 FIND v(dout1_63) AT=225.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_32ck450 FIND v(dout1_32) AT=230.025n

.meas tran vdout1_33ck450 FIND v(dout1_33) AT=230.025n

.meas tran vdout1_34ck450 FIND v(dout1_34) AT=230.025n

.meas tran vdout1_35ck450 FIND v(dout1_35) AT=230.025n

.meas tran vdout1_36ck450 FIND v(dout1_36) AT=230.025n

.meas tran vdout1_37ck450 FIND v(dout1_37) AT=230.025n

.meas tran vdout1_38ck450 FIND v(dout1_38) AT=230.025n

.meas tran vdout1_39ck450 FIND v(dout1_39) AT=230.025n

.meas tran vdout1_40ck450 FIND v(dout1_40) AT=230.025n

.meas tran vdout1_41ck450 FIND v(dout1_41) AT=230.025n

.meas tran vdout1_42ck450 FIND v(dout1_42) AT=230.025n

.meas tran vdout1_43ck450 FIND v(dout1_43) AT=230.025n

.meas tran vdout1_44ck450 FIND v(dout1_44) AT=230.025n

.meas tran vdout1_45ck450 FIND v(dout1_45) AT=230.025n

.meas tran vdout1_46ck450 FIND v(dout1_46) AT=230.025n

.meas tran vdout1_47ck450 FIND v(dout1_47) AT=230.025n

.meas tran vdout1_48ck450 FIND v(dout1_48) AT=230.025n

.meas tran vdout1_49ck450 FIND v(dout1_49) AT=230.025n

.meas tran vdout1_50ck450 FIND v(dout1_50) AT=230.025n

.meas tran vdout1_51ck450 FIND v(dout1_51) AT=230.025n

.meas tran vdout1_52ck450 FIND v(dout1_52) AT=230.025n

.meas tran vdout1_53ck450 FIND v(dout1_53) AT=230.025n

.meas tran vdout1_54ck450 FIND v(dout1_54) AT=230.025n

.meas tran vdout1_55ck450 FIND v(dout1_55) AT=230.025n

.meas tran vdout1_56ck450 FIND v(dout1_56) AT=230.025n

.meas tran vdout1_57ck450 FIND v(dout1_57) AT=230.025n

.meas tran vdout1_58ck450 FIND v(dout1_58) AT=230.025n

.meas tran vdout1_59ck450 FIND v(dout1_59) AT=230.025n

.meas tran vdout1_60ck450 FIND v(dout1_60) AT=230.025n

.meas tran vdout1_61ck450 FIND v(dout1_61) AT=230.025n

.meas tran vdout1_62ck450 FIND v(dout1_62) AT=230.025n

.meas tran vdout1_63ck450 FIND v(dout1_63) AT=230.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_19ck490 FIND v(dout1_19) AT=250.025n

.meas tran vdout1_20ck490 FIND v(dout1_20) AT=250.025n

.meas tran vdout1_21ck490 FIND v(dout1_21) AT=250.025n

.meas tran vdout1_22ck490 FIND v(dout1_22) AT=250.025n

.meas tran vdout1_23ck490 FIND v(dout1_23) AT=250.025n

.meas tran vdout1_24ck490 FIND v(dout1_24) AT=250.025n

.meas tran vdout1_25ck490 FIND v(dout1_25) AT=250.025n

.meas tran vdout1_26ck490 FIND v(dout1_26) AT=250.025n

.meas tran vdout1_27ck490 FIND v(dout1_27) AT=250.025n

.meas tran vdout1_28ck490 FIND v(dout1_28) AT=250.025n

.meas tran vdout1_29ck490 FIND v(dout1_29) AT=250.025n

.meas tran vdout1_30ck490 FIND v(dout1_30) AT=250.025n

.meas tran vdout1_31ck490 FIND v(dout1_31) AT=250.025n

.meas tran vdout1_32ck490 FIND v(dout1_32) AT=250.025n

.meas tran vdout1_33ck490 FIND v(dout1_33) AT=250.025n

.meas tran vdout1_34ck490 FIND v(dout1_34) AT=250.025n

.meas tran vdout1_35ck490 FIND v(dout1_35) AT=250.025n

.meas tran vdout1_36ck490 FIND v(dout1_36) AT=250.025n

.meas tran vdout1_37ck490 FIND v(dout1_37) AT=250.025n

.meas tran vdout1_38ck490 FIND v(dout1_38) AT=250.025n

.meas tran vdout1_39ck490 FIND v(dout1_39) AT=250.025n

.meas tran vdout1_40ck490 FIND v(dout1_40) AT=250.025n

.meas tran vdout1_41ck490 FIND v(dout1_41) AT=250.025n

.meas tran vdout1_42ck490 FIND v(dout1_42) AT=250.025n

.meas tran vdout1_43ck490 FIND v(dout1_43) AT=250.025n

.meas tran vdout1_44ck490 FIND v(dout1_44) AT=250.025n

.meas tran vdout1_45ck490 FIND v(dout1_45) AT=250.025n

.meas tran vdout1_46ck490 FIND v(dout1_46) AT=250.025n

.meas tran vdout1_47ck490 FIND v(dout1_47) AT=250.025n

.meas tran vdout1_48ck490 FIND v(dout1_48) AT=250.025n

.meas tran vdout1_49ck490 FIND v(dout1_49) AT=250.025n

.meas tran vdout1_50ck490 FIND v(dout1_50) AT=250.025n

.meas tran vdout1_51ck490 FIND v(dout1_51) AT=250.025n

.meas tran vdout1_52ck490 FIND v(dout1_52) AT=250.025n

.meas tran vdout1_53ck490 FIND v(dout1_53) AT=250.025n

.meas tran vdout1_54ck490 FIND v(dout1_54) AT=250.025n

.meas tran vdout1_55ck490 FIND v(dout1_55) AT=250.025n

.meas tran vdout1_56ck490 FIND v(dout1_56) AT=250.025n

.meas tran vdout1_57ck490 FIND v(dout1_57) AT=250.025n

.meas tran vdout1_58ck490 FIND v(dout1_58) AT=250.025n

.meas tran vdout1_59ck490 FIND v(dout1_59) AT=250.025n

.meas tran vdout1_60ck490 FIND v(dout1_60) AT=250.025n

.meas tran vdout1_61ck490 FIND v(dout1_61) AT=250.025n

.meas tran vdout1_62ck490 FIND v(dout1_62) AT=250.025n

.meas tran vdout1_63ck490 FIND v(dout1_63) AT=250.025n

.meas tran vdout1_0ck500 FIND v(dout1_0) AT=255.025n

.meas tran vdout1_1ck500 FIND v(dout1_1) AT=255.025n

.meas tran vdout1_2ck500 FIND v(dout1_2) AT=255.025n

.meas tran vdout1_3ck500 FIND v(dout1_3) AT=255.025n

.meas tran vdout1_4ck500 FIND v(dout1_4) AT=255.025n

.meas tran vdout1_5ck500 FIND v(dout1_5) AT=255.025n

.meas tran vdout1_6ck500 FIND v(dout1_6) AT=255.025n

.meas tran vdout1_7ck500 FIND v(dout1_7) AT=255.025n

.meas tran vdout1_8ck500 FIND v(dout1_8) AT=255.025n

.meas tran vdout1_9ck500 FIND v(dout1_9) AT=255.025n

.meas tran vdout1_10ck500 FIND v(dout1_10) AT=255.025n

.meas tran vdout1_11ck500 FIND v(dout1_11) AT=255.025n

.meas tran vdout1_12ck500 FIND v(dout1_12) AT=255.025n

.meas tran vdout1_13ck500 FIND v(dout1_13) AT=255.025n

.meas tran vdout1_14ck500 FIND v(dout1_14) AT=255.025n

.meas tran vdout1_15ck500 FIND v(dout1_15) AT=255.025n

.meas tran vdout1_16ck500 FIND v(dout1_16) AT=255.025n

.meas tran vdout1_17ck500 FIND v(dout1_17) AT=255.025n

.meas tran vdout1_18ck500 FIND v(dout1_18) AT=255.025n

.meas tran vdout1_19ck500 FIND v(dout1_19) AT=255.025n

.meas tran vdout1_20ck500 FIND v(dout1_20) AT=255.025n

.meas tran vdout1_21ck500 FIND v(dout1_21) AT=255.025n

.meas tran vdout1_22ck500 FIND v(dout1_22) AT=255.025n

.meas tran vdout1_23ck500 FIND v(dout1_23) AT=255.025n

.meas tran vdout1_24ck500 FIND v(dout1_24) AT=255.025n

.meas tran vdout1_25ck500 FIND v(dout1_25) AT=255.025n

.meas tran vdout1_26ck500 FIND v(dout1_26) AT=255.025n

.meas tran vdout1_27ck500 FIND v(dout1_27) AT=255.025n

.meas tran vdout1_28ck500 FIND v(dout1_28) AT=255.025n

.meas tran vdout1_29ck500 FIND v(dout1_29) AT=255.025n

.meas tran vdout1_30ck500 FIND v(dout1_30) AT=255.025n

.meas tran vdout1_31ck500 FIND v(dout1_31) AT=255.025n

.meas tran vdout1_32ck500 FIND v(dout1_32) AT=255.025n

.meas tran vdout1_33ck500 FIND v(dout1_33) AT=255.025n

.meas tran vdout1_34ck500 FIND v(dout1_34) AT=255.025n

.meas tran vdout1_35ck500 FIND v(dout1_35) AT=255.025n

.meas tran vdout1_36ck500 FIND v(dout1_36) AT=255.025n

.meas tran vdout1_37ck500 FIND v(dout1_37) AT=255.025n

.meas tran vdout1_38ck500 FIND v(dout1_38) AT=255.025n

.meas tran vdout1_39ck500 FIND v(dout1_39) AT=255.025n

.meas tran vdout1_40ck500 FIND v(dout1_40) AT=255.025n

.meas tran vdout1_41ck500 FIND v(dout1_41) AT=255.025n

.meas tran vdout1_42ck500 FIND v(dout1_42) AT=255.025n

.meas tran vdout1_43ck500 FIND v(dout1_43) AT=255.025n

.meas tran vdout1_44ck500 FIND v(dout1_44) AT=255.025n

.meas tran vdout1_45ck500 FIND v(dout1_45) AT=255.025n

.meas tran vdout1_46ck500 FIND v(dout1_46) AT=255.025n

.meas tran vdout1_47ck500 FIND v(dout1_47) AT=255.025n

.meas tran vdout1_48ck500 FIND v(dout1_48) AT=255.025n

.meas tran vdout1_49ck500 FIND v(dout1_49) AT=255.025n

.meas tran vdout1_50ck500 FIND v(dout1_50) AT=255.025n

.meas tran vdout1_51ck500 FIND v(dout1_51) AT=255.025n

.meas tran vdout1_52ck500 FIND v(dout1_52) AT=255.025n

.meas tran vdout1_53ck500 FIND v(dout1_53) AT=255.025n

.meas tran vdout1_54ck500 FIND v(dout1_54) AT=255.025n

.meas tran vdout1_55ck500 FIND v(dout1_55) AT=255.025n

.meas tran vdout1_56ck500 FIND v(dout1_56) AT=255.025n

.meas tran vdout1_57ck500 FIND v(dout1_57) AT=255.025n

.meas tran vdout1_58ck500 FIND v(dout1_58) AT=255.025n

.meas tran vdout1_59ck500 FIND v(dout1_59) AT=255.025n

.meas tran vdout1_60ck500 FIND v(dout1_60) AT=255.025n

.meas tran vdout1_61ck500 FIND v(dout1_61) AT=255.025n

.meas tran vdout1_62ck500 FIND v(dout1_62) AT=255.025n

.meas tran vdout1_63ck500 FIND v(dout1_63) AT=255.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_22ck510 FIND v(dout1_22) AT=260.025n

.meas tran vdout1_23ck510 FIND v(dout1_23) AT=260.025n

.meas tran vdout1_24ck510 FIND v(dout1_24) AT=260.025n

.meas tran vdout1_25ck510 FIND v(dout1_25) AT=260.025n

.meas tran vdout1_26ck510 FIND v(dout1_26) AT=260.025n

.meas tran vdout1_27ck510 FIND v(dout1_27) AT=260.025n

.meas tran vdout1_28ck510 FIND v(dout1_28) AT=260.025n

.meas tran vdout1_29ck510 FIND v(dout1_29) AT=260.025n

.meas tran vdout1_30ck510 FIND v(dout1_30) AT=260.025n

.meas tran vdout1_31ck510 FIND v(dout1_31) AT=260.025n

.meas tran vdout1_32ck510 FIND v(dout1_32) AT=260.025n

.meas tran vdout1_33ck510 FIND v(dout1_33) AT=260.025n

.meas tran vdout1_34ck510 FIND v(dout1_34) AT=260.025n

.meas tran vdout1_35ck510 FIND v(dout1_35) AT=260.025n

.meas tran vdout1_36ck510 FIND v(dout1_36) AT=260.025n

.meas tran vdout1_37ck510 FIND v(dout1_37) AT=260.025n

.meas tran vdout1_38ck510 FIND v(dout1_38) AT=260.025n

.meas tran vdout1_39ck510 FIND v(dout1_39) AT=260.025n

.meas tran vdout1_40ck510 FIND v(dout1_40) AT=260.025n

.meas tran vdout1_41ck510 FIND v(dout1_41) AT=260.025n

.meas tran vdout1_42ck510 FIND v(dout1_42) AT=260.025n

.meas tran vdout1_43ck510 FIND v(dout1_43) AT=260.025n

.meas tran vdout1_44ck510 FIND v(dout1_44) AT=260.025n

.meas tran vdout1_45ck510 FIND v(dout1_45) AT=260.025n

.meas tran vdout1_46ck510 FIND v(dout1_46) AT=260.025n

.meas tran vdout1_47ck510 FIND v(dout1_47) AT=260.025n

.meas tran vdout1_48ck510 FIND v(dout1_48) AT=260.025n

.meas tran vdout1_49ck510 FIND v(dout1_49) AT=260.025n

.meas tran vdout1_50ck510 FIND v(dout1_50) AT=260.025n

.meas tran vdout1_51ck510 FIND v(dout1_51) AT=260.025n

.meas tran vdout1_52ck510 FIND v(dout1_52) AT=260.025n

.meas tran vdout1_53ck510 FIND v(dout1_53) AT=260.025n

.meas tran vdout1_54ck510 FIND v(dout1_54) AT=260.025n

.meas tran vdout1_55ck510 FIND v(dout1_55) AT=260.025n

.meas tran vdout1_56ck510 FIND v(dout1_56) AT=260.025n

.meas tran vdout1_57ck510 FIND v(dout1_57) AT=260.025n

.meas tran vdout1_58ck510 FIND v(dout1_58) AT=260.025n

.meas tran vdout1_59ck510 FIND v(dout1_59) AT=260.025n

.meas tran vdout1_60ck510 FIND v(dout1_60) AT=260.025n

.meas tran vdout1_61ck510 FIND v(dout1_61) AT=260.025n

.meas tran vdout1_62ck510 FIND v(dout1_62) AT=260.025n

.meas tran vdout1_63ck510 FIND v(dout1_63) AT=260.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_32ck540 FIND v(dout1_32) AT=275.025n

.meas tran vdout1_33ck540 FIND v(dout1_33) AT=275.025n

.meas tran vdout1_34ck540 FIND v(dout1_34) AT=275.025n

.meas tran vdout1_35ck540 FIND v(dout1_35) AT=275.025n

.meas tran vdout1_36ck540 FIND v(dout1_36) AT=275.025n

.meas tran vdout1_37ck540 FIND v(dout1_37) AT=275.025n

.meas tran vdout1_38ck540 FIND v(dout1_38) AT=275.025n

.meas tran vdout1_39ck540 FIND v(dout1_39) AT=275.025n

.meas tran vdout1_40ck540 FIND v(dout1_40) AT=275.025n

.meas tran vdout1_41ck540 FIND v(dout1_41) AT=275.025n

.meas tran vdout1_42ck540 FIND v(dout1_42) AT=275.025n

.meas tran vdout1_43ck540 FIND v(dout1_43) AT=275.025n

.meas tran vdout1_44ck540 FIND v(dout1_44) AT=275.025n

.meas tran vdout1_45ck540 FIND v(dout1_45) AT=275.025n

.meas tran vdout1_46ck540 FIND v(dout1_46) AT=275.025n

.meas tran vdout1_47ck540 FIND v(dout1_47) AT=275.025n

.meas tran vdout1_48ck540 FIND v(dout1_48) AT=275.025n

.meas tran vdout1_49ck540 FIND v(dout1_49) AT=275.025n

.meas tran vdout1_50ck540 FIND v(dout1_50) AT=275.025n

.meas tran vdout1_51ck540 FIND v(dout1_51) AT=275.025n

.meas tran vdout1_52ck540 FIND v(dout1_52) AT=275.025n

.meas tran vdout1_53ck540 FIND v(dout1_53) AT=275.025n

.meas tran vdout1_54ck540 FIND v(dout1_54) AT=275.025n

.meas tran vdout1_55ck540 FIND v(dout1_55) AT=275.025n

.meas tran vdout1_56ck540 FIND v(dout1_56) AT=275.025n

.meas tran vdout1_57ck540 FIND v(dout1_57) AT=275.025n

.meas tran vdout1_58ck540 FIND v(dout1_58) AT=275.025n

.meas tran vdout1_59ck540 FIND v(dout1_59) AT=275.025n

.meas tran vdout1_60ck540 FIND v(dout1_60) AT=275.025n

.meas tran vdout1_61ck540 FIND v(dout1_61) AT=275.025n

.meas tran vdout1_62ck540 FIND v(dout1_62) AT=275.025n

.meas tran vdout1_63ck540 FIND v(dout1_63) AT=275.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_23ck580 FIND v(dout1_23) AT=295.025n

.meas tran vdout1_24ck580 FIND v(dout1_24) AT=295.025n

.meas tran vdout1_25ck580 FIND v(dout1_25) AT=295.025n

.meas tran vdout1_26ck580 FIND v(dout1_26) AT=295.025n

.meas tran vdout1_27ck580 FIND v(dout1_27) AT=295.025n

.meas tran vdout1_28ck580 FIND v(dout1_28) AT=295.025n

.meas tran vdout1_29ck580 FIND v(dout1_29) AT=295.025n

.meas tran vdout1_30ck580 FIND v(dout1_30) AT=295.025n

.meas tran vdout1_31ck580 FIND v(dout1_31) AT=295.025n

.meas tran vdout1_32ck580 FIND v(dout1_32) AT=295.025n

.meas tran vdout1_33ck580 FIND v(dout1_33) AT=295.025n

.meas tran vdout1_34ck580 FIND v(dout1_34) AT=295.025n

.meas tran vdout1_35ck580 FIND v(dout1_35) AT=295.025n

.meas tran vdout1_36ck580 FIND v(dout1_36) AT=295.025n

.meas tran vdout1_37ck580 FIND v(dout1_37) AT=295.025n

.meas tran vdout1_38ck580 FIND v(dout1_38) AT=295.025n

.meas tran vdout1_39ck580 FIND v(dout1_39) AT=295.025n

.meas tran vdout1_40ck580 FIND v(dout1_40) AT=295.025n

.meas tran vdout1_41ck580 FIND v(dout1_41) AT=295.025n

.meas tran vdout1_42ck580 FIND v(dout1_42) AT=295.025n

.meas tran vdout1_43ck580 FIND v(dout1_43) AT=295.025n

.meas tran vdout1_44ck580 FIND v(dout1_44) AT=295.025n

.meas tran vdout1_45ck580 FIND v(dout1_45) AT=295.025n

.meas tran vdout1_46ck580 FIND v(dout1_46) AT=295.025n

.meas tran vdout1_47ck580 FIND v(dout1_47) AT=295.025n

.meas tran vdout1_48ck580 FIND v(dout1_48) AT=295.025n

.meas tran vdout1_49ck580 FIND v(dout1_49) AT=295.025n

.meas tran vdout1_50ck580 FIND v(dout1_50) AT=295.025n

.meas tran vdout1_51ck580 FIND v(dout1_51) AT=295.025n

.meas tran vdout1_52ck580 FIND v(dout1_52) AT=295.025n

.meas tran vdout1_53ck580 FIND v(dout1_53) AT=295.025n

.meas tran vdout1_54ck580 FIND v(dout1_54) AT=295.025n

.meas tran vdout1_55ck580 FIND v(dout1_55) AT=295.025n

.meas tran vdout1_56ck580 FIND v(dout1_56) AT=295.025n

.meas tran vdout1_57ck580 FIND v(dout1_57) AT=295.025n

.meas tran vdout1_58ck580 FIND v(dout1_58) AT=295.025n

.meas tran vdout1_59ck580 FIND v(dout1_59) AT=295.025n

.meas tran vdout1_60ck580 FIND v(dout1_60) AT=295.025n

.meas tran vdout1_61ck580 FIND v(dout1_61) AT=295.025n

.meas tran vdout1_62ck580 FIND v(dout1_62) AT=295.025n

.meas tran vdout1_63ck580 FIND v(dout1_63) AT=295.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_32ck600 FIND v(dout1_32) AT=305.025n

.meas tran vdout1_33ck600 FIND v(dout1_33) AT=305.025n

.meas tran vdout1_34ck600 FIND v(dout1_34) AT=305.025n

.meas tran vdout1_35ck600 FIND v(dout1_35) AT=305.025n

.meas tran vdout1_36ck600 FIND v(dout1_36) AT=305.025n

.meas tran vdout1_37ck600 FIND v(dout1_37) AT=305.025n

.meas tran vdout1_38ck600 FIND v(dout1_38) AT=305.025n

.meas tran vdout1_39ck600 FIND v(dout1_39) AT=305.025n

.meas tran vdout1_40ck600 FIND v(dout1_40) AT=305.025n

.meas tran vdout1_41ck600 FIND v(dout1_41) AT=305.025n

.meas tran vdout1_42ck600 FIND v(dout1_42) AT=305.025n

.meas tran vdout1_43ck600 FIND v(dout1_43) AT=305.025n

.meas tran vdout1_44ck600 FIND v(dout1_44) AT=305.025n

.meas tran vdout1_45ck600 FIND v(dout1_45) AT=305.025n

.meas tran vdout1_46ck600 FIND v(dout1_46) AT=305.025n

.meas tran vdout1_47ck600 FIND v(dout1_47) AT=305.025n

.meas tran vdout1_48ck600 FIND v(dout1_48) AT=305.025n

.meas tran vdout1_49ck600 FIND v(dout1_49) AT=305.025n

.meas tran vdout1_50ck600 FIND v(dout1_50) AT=305.025n

.meas tran vdout1_51ck600 FIND v(dout1_51) AT=305.025n

.meas tran vdout1_52ck600 FIND v(dout1_52) AT=305.025n

.meas tran vdout1_53ck600 FIND v(dout1_53) AT=305.025n

.meas tran vdout1_54ck600 FIND v(dout1_54) AT=305.025n

.meas tran vdout1_55ck600 FIND v(dout1_55) AT=305.025n

.meas tran vdout1_56ck600 FIND v(dout1_56) AT=305.025n

.meas tran vdout1_57ck600 FIND v(dout1_57) AT=305.025n

.meas tran vdout1_58ck600 FIND v(dout1_58) AT=305.025n

.meas tran vdout1_59ck600 FIND v(dout1_59) AT=305.025n

.meas tran vdout1_60ck600 FIND v(dout1_60) AT=305.025n

.meas tran vdout1_61ck600 FIND v(dout1_61) AT=305.025n

.meas tran vdout1_62ck600 FIND v(dout1_62) AT=305.025n

.meas tran vdout1_63ck600 FIND v(dout1_63) AT=305.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_8ck630 FIND v(dout1_8) AT=320.025n

.meas tran vdout1_9ck630 FIND v(dout1_9) AT=320.025n

.meas tran vdout1_10ck630 FIND v(dout1_10) AT=320.025n

.meas tran vdout1_11ck630 FIND v(dout1_11) AT=320.025n

.meas tran vdout1_12ck630 FIND v(dout1_12) AT=320.025n

.meas tran vdout1_13ck630 FIND v(dout1_13) AT=320.025n

.meas tran vdout1_14ck630 FIND v(dout1_14) AT=320.025n

.meas tran vdout1_15ck630 FIND v(dout1_15) AT=320.025n

.meas tran vdout1_16ck630 FIND v(dout1_16) AT=320.025n

.meas tran vdout1_17ck630 FIND v(dout1_17) AT=320.025n

.meas tran vdout1_18ck630 FIND v(dout1_18) AT=320.025n

.meas tran vdout1_19ck630 FIND v(dout1_19) AT=320.025n

.meas tran vdout1_20ck630 FIND v(dout1_20) AT=320.025n

.meas tran vdout1_21ck630 FIND v(dout1_21) AT=320.025n

.meas tran vdout1_22ck630 FIND v(dout1_22) AT=320.025n

.meas tran vdout1_23ck630 FIND v(dout1_23) AT=320.025n

.meas tran vdout1_24ck630 FIND v(dout1_24) AT=320.025n

.meas tran vdout1_25ck630 FIND v(dout1_25) AT=320.025n

.meas tran vdout1_26ck630 FIND v(dout1_26) AT=320.025n

.meas tran vdout1_27ck630 FIND v(dout1_27) AT=320.025n

.meas tran vdout1_28ck630 FIND v(dout1_28) AT=320.025n

.meas tran vdout1_29ck630 FIND v(dout1_29) AT=320.025n

.meas tran vdout1_30ck630 FIND v(dout1_30) AT=320.025n

.meas tran vdout1_31ck630 FIND v(dout1_31) AT=320.025n

.meas tran vdout1_32ck630 FIND v(dout1_32) AT=320.025n

.meas tran vdout1_33ck630 FIND v(dout1_33) AT=320.025n

.meas tran vdout1_34ck630 FIND v(dout1_34) AT=320.025n

.meas tran vdout1_35ck630 FIND v(dout1_35) AT=320.025n

.meas tran vdout1_36ck630 FIND v(dout1_36) AT=320.025n

.meas tran vdout1_37ck630 FIND v(dout1_37) AT=320.025n

.meas tran vdout1_38ck630 FIND v(dout1_38) AT=320.025n

.meas tran vdout1_39ck630 FIND v(dout1_39) AT=320.025n

.meas tran vdout1_40ck630 FIND v(dout1_40) AT=320.025n

.meas tran vdout1_41ck630 FIND v(dout1_41) AT=320.025n

.meas tran vdout1_42ck630 FIND v(dout1_42) AT=320.025n

.meas tran vdout1_43ck630 FIND v(dout1_43) AT=320.025n

.meas tran vdout1_44ck630 FIND v(dout1_44) AT=320.025n

.meas tran vdout1_45ck630 FIND v(dout1_45) AT=320.025n

.meas tran vdout1_46ck630 FIND v(dout1_46) AT=320.025n

.meas tran vdout1_47ck630 FIND v(dout1_47) AT=320.025n

.meas tran vdout1_48ck630 FIND v(dout1_48) AT=320.025n

.meas tran vdout1_49ck630 FIND v(dout1_49) AT=320.025n

.meas tran vdout1_50ck630 FIND v(dout1_50) AT=320.025n

.meas tran vdout1_51ck630 FIND v(dout1_51) AT=320.025n

.meas tran vdout1_52ck630 FIND v(dout1_52) AT=320.025n

.meas tran vdout1_53ck630 FIND v(dout1_53) AT=320.025n

.meas tran vdout1_54ck630 FIND v(dout1_54) AT=320.025n

.meas tran vdout1_55ck630 FIND v(dout1_55) AT=320.025n

.meas tran vdout1_56ck630 FIND v(dout1_56) AT=320.025n

.meas tran vdout1_57ck630 FIND v(dout1_57) AT=320.025n

.meas tran vdout1_58ck630 FIND v(dout1_58) AT=320.025n

.meas tran vdout1_59ck630 FIND v(dout1_59) AT=320.025n

.meas tran vdout1_60ck630 FIND v(dout1_60) AT=320.025n

.meas tran vdout1_61ck630 FIND v(dout1_61) AT=320.025n

.meas tran vdout1_62ck630 FIND v(dout1_62) AT=320.025n

.meas tran vdout1_63ck630 FIND v(dout1_63) AT=320.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_19ck670 FIND v(dout1_19) AT=340.025n

.meas tran vdout1_20ck670 FIND v(dout1_20) AT=340.025n

.meas tran vdout1_21ck670 FIND v(dout1_21) AT=340.025n

.meas tran vdout1_22ck670 FIND v(dout1_22) AT=340.025n

.meas tran vdout1_23ck670 FIND v(dout1_23) AT=340.025n

.meas tran vdout1_24ck670 FIND v(dout1_24) AT=340.025n

.meas tran vdout1_25ck670 FIND v(dout1_25) AT=340.025n

.meas tran vdout1_26ck670 FIND v(dout1_26) AT=340.025n

.meas tran vdout1_27ck670 FIND v(dout1_27) AT=340.025n

.meas tran vdout1_28ck670 FIND v(dout1_28) AT=340.025n

.meas tran vdout1_29ck670 FIND v(dout1_29) AT=340.025n

.meas tran vdout1_30ck670 FIND v(dout1_30) AT=340.025n

.meas tran vdout1_31ck670 FIND v(dout1_31) AT=340.025n

.meas tran vdout1_32ck670 FIND v(dout1_32) AT=340.025n

.meas tran vdout1_33ck670 FIND v(dout1_33) AT=340.025n

.meas tran vdout1_34ck670 FIND v(dout1_34) AT=340.025n

.meas tran vdout1_35ck670 FIND v(dout1_35) AT=340.025n

.meas tran vdout1_36ck670 FIND v(dout1_36) AT=340.025n

.meas tran vdout1_37ck670 FIND v(dout1_37) AT=340.025n

.meas tran vdout1_38ck670 FIND v(dout1_38) AT=340.025n

.meas tran vdout1_39ck670 FIND v(dout1_39) AT=340.025n

.meas tran vdout1_40ck670 FIND v(dout1_40) AT=340.025n

.meas tran vdout1_41ck670 FIND v(dout1_41) AT=340.025n

.meas tran vdout1_42ck670 FIND v(dout1_42) AT=340.025n

.meas tran vdout1_43ck670 FIND v(dout1_43) AT=340.025n

.meas tran vdout1_44ck670 FIND v(dout1_44) AT=340.025n

.meas tran vdout1_45ck670 FIND v(dout1_45) AT=340.025n

.meas tran vdout1_46ck670 FIND v(dout1_46) AT=340.025n

.meas tran vdout1_47ck670 FIND v(dout1_47) AT=340.025n

.meas tran vdout1_48ck670 FIND v(dout1_48) AT=340.025n

.meas tran vdout1_49ck670 FIND v(dout1_49) AT=340.025n

.meas tran vdout1_50ck670 FIND v(dout1_50) AT=340.025n

.meas tran vdout1_51ck670 FIND v(dout1_51) AT=340.025n

.meas tran vdout1_52ck670 FIND v(dout1_52) AT=340.025n

.meas tran vdout1_53ck670 FIND v(dout1_53) AT=340.025n

.meas tran vdout1_54ck670 FIND v(dout1_54) AT=340.025n

.meas tran vdout1_55ck670 FIND v(dout1_55) AT=340.025n

.meas tran vdout1_56ck670 FIND v(dout1_56) AT=340.025n

.meas tran vdout1_57ck670 FIND v(dout1_57) AT=340.025n

.meas tran vdout1_58ck670 FIND v(dout1_58) AT=340.025n

.meas tran vdout1_59ck670 FIND v(dout1_59) AT=340.025n

.meas tran vdout1_60ck670 FIND v(dout1_60) AT=340.025n

.meas tran vdout1_61ck670 FIND v(dout1_61) AT=340.025n

.meas tran vdout1_62ck670 FIND v(dout1_62) AT=340.025n

.meas tran vdout1_63ck670 FIND v(dout1_63) AT=340.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_17ck700 FIND v(dout1_17) AT=355.025n

.meas tran vdout1_18ck700 FIND v(dout1_18) AT=355.025n

.meas tran vdout1_19ck700 FIND v(dout1_19) AT=355.025n

.meas tran vdout1_20ck700 FIND v(dout1_20) AT=355.025n

.meas tran vdout1_21ck700 FIND v(dout1_21) AT=355.025n

.meas tran vdout1_22ck700 FIND v(dout1_22) AT=355.025n

.meas tran vdout1_23ck700 FIND v(dout1_23) AT=355.025n

.meas tran vdout1_24ck700 FIND v(dout1_24) AT=355.025n

.meas tran vdout1_25ck700 FIND v(dout1_25) AT=355.025n

.meas tran vdout1_26ck700 FIND v(dout1_26) AT=355.025n

.meas tran vdout1_27ck700 FIND v(dout1_27) AT=355.025n

.meas tran vdout1_28ck700 FIND v(dout1_28) AT=355.025n

.meas tran vdout1_29ck700 FIND v(dout1_29) AT=355.025n

.meas tran vdout1_30ck700 FIND v(dout1_30) AT=355.025n

.meas tran vdout1_31ck700 FIND v(dout1_31) AT=355.025n

.meas tran vdout1_32ck700 FIND v(dout1_32) AT=355.025n

.meas tran vdout1_33ck700 FIND v(dout1_33) AT=355.025n

.meas tran vdout1_34ck700 FIND v(dout1_34) AT=355.025n

.meas tran vdout1_35ck700 FIND v(dout1_35) AT=355.025n

.meas tran vdout1_36ck700 FIND v(dout1_36) AT=355.025n

.meas tran vdout1_37ck700 FIND v(dout1_37) AT=355.025n

.meas tran vdout1_38ck700 FIND v(dout1_38) AT=355.025n

.meas tran vdout1_39ck700 FIND v(dout1_39) AT=355.025n

.meas tran vdout1_40ck700 FIND v(dout1_40) AT=355.025n

.meas tran vdout1_41ck700 FIND v(dout1_41) AT=355.025n

.meas tran vdout1_42ck700 FIND v(dout1_42) AT=355.025n

.meas tran vdout1_43ck700 FIND v(dout1_43) AT=355.025n

.meas tran vdout1_44ck700 FIND v(dout1_44) AT=355.025n

.meas tran vdout1_45ck700 FIND v(dout1_45) AT=355.025n

.meas tran vdout1_46ck700 FIND v(dout1_46) AT=355.025n

.meas tran vdout1_47ck700 FIND v(dout1_47) AT=355.025n

.meas tran vdout1_48ck700 FIND v(dout1_48) AT=355.025n

.meas tran vdout1_49ck700 FIND v(dout1_49) AT=355.025n

.meas tran vdout1_50ck700 FIND v(dout1_50) AT=355.025n

.meas tran vdout1_51ck700 FIND v(dout1_51) AT=355.025n

.meas tran vdout1_52ck700 FIND v(dout1_52) AT=355.025n

.meas tran vdout1_53ck700 FIND v(dout1_53) AT=355.025n

.meas tran vdout1_54ck700 FIND v(dout1_54) AT=355.025n

.meas tran vdout1_55ck700 FIND v(dout1_55) AT=355.025n

.meas tran vdout1_56ck700 FIND v(dout1_56) AT=355.025n

.meas tran vdout1_57ck700 FIND v(dout1_57) AT=355.025n

.meas tran vdout1_58ck700 FIND v(dout1_58) AT=355.025n

.meas tran vdout1_59ck700 FIND v(dout1_59) AT=355.025n

.meas tran vdout1_60ck700 FIND v(dout1_60) AT=355.025n

.meas tran vdout1_61ck700 FIND v(dout1_61) AT=355.025n

.meas tran vdout1_62ck700 FIND v(dout1_62) AT=355.025n

.meas tran vdout1_63ck700 FIND v(dout1_63) AT=355.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_17ck730 FIND v(dout1_17) AT=370.025n

.meas tran vdout1_18ck730 FIND v(dout1_18) AT=370.025n

.meas tran vdout1_19ck730 FIND v(dout1_19) AT=370.025n

.meas tran vdout1_20ck730 FIND v(dout1_20) AT=370.025n

.meas tran vdout1_21ck730 FIND v(dout1_21) AT=370.025n

.meas tran vdout1_22ck730 FIND v(dout1_22) AT=370.025n

.meas tran vdout1_23ck730 FIND v(dout1_23) AT=370.025n

.meas tran vdout1_24ck730 FIND v(dout1_24) AT=370.025n

.meas tran vdout1_25ck730 FIND v(dout1_25) AT=370.025n

.meas tran vdout1_26ck730 FIND v(dout1_26) AT=370.025n

.meas tran vdout1_27ck730 FIND v(dout1_27) AT=370.025n

.meas tran vdout1_28ck730 FIND v(dout1_28) AT=370.025n

.meas tran vdout1_29ck730 FIND v(dout1_29) AT=370.025n

.meas tran vdout1_30ck730 FIND v(dout1_30) AT=370.025n

.meas tran vdout1_31ck730 FIND v(dout1_31) AT=370.025n

.meas tran vdout1_32ck730 FIND v(dout1_32) AT=370.025n

.meas tran vdout1_33ck730 FIND v(dout1_33) AT=370.025n

.meas tran vdout1_34ck730 FIND v(dout1_34) AT=370.025n

.meas tran vdout1_35ck730 FIND v(dout1_35) AT=370.025n

.meas tran vdout1_36ck730 FIND v(dout1_36) AT=370.025n

.meas tran vdout1_37ck730 FIND v(dout1_37) AT=370.025n

.meas tran vdout1_38ck730 FIND v(dout1_38) AT=370.025n

.meas tran vdout1_39ck730 FIND v(dout1_39) AT=370.025n

.meas tran vdout1_40ck730 FIND v(dout1_40) AT=370.025n

.meas tran vdout1_41ck730 FIND v(dout1_41) AT=370.025n

.meas tran vdout1_42ck730 FIND v(dout1_42) AT=370.025n

.meas tran vdout1_43ck730 FIND v(dout1_43) AT=370.025n

.meas tran vdout1_44ck730 FIND v(dout1_44) AT=370.025n

.meas tran vdout1_45ck730 FIND v(dout1_45) AT=370.025n

.meas tran vdout1_46ck730 FIND v(dout1_46) AT=370.025n

.meas tran vdout1_47ck730 FIND v(dout1_47) AT=370.025n

.meas tran vdout1_48ck730 FIND v(dout1_48) AT=370.025n

.meas tran vdout1_49ck730 FIND v(dout1_49) AT=370.025n

.meas tran vdout1_50ck730 FIND v(dout1_50) AT=370.025n

.meas tran vdout1_51ck730 FIND v(dout1_51) AT=370.025n

.meas tran vdout1_52ck730 FIND v(dout1_52) AT=370.025n

.meas tran vdout1_53ck730 FIND v(dout1_53) AT=370.025n

.meas tran vdout1_54ck730 FIND v(dout1_54) AT=370.025n

.meas tran vdout1_55ck730 FIND v(dout1_55) AT=370.025n

.meas tran vdout1_56ck730 FIND v(dout1_56) AT=370.025n

.meas tran vdout1_57ck730 FIND v(dout1_57) AT=370.025n

.meas tran vdout1_58ck730 FIND v(dout1_58) AT=370.025n

.meas tran vdout1_59ck730 FIND v(dout1_59) AT=370.025n

.meas tran vdout1_60ck730 FIND v(dout1_60) AT=370.025n

.meas tran vdout1_61ck730 FIND v(dout1_61) AT=370.025n

.meas tran vdout1_62ck730 FIND v(dout1_62) AT=370.025n

.meas tran vdout1_63ck730 FIND v(dout1_63) AT=370.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_22ck740 FIND v(dout1_22) AT=375.025n

.meas tran vdout1_23ck740 FIND v(dout1_23) AT=375.025n

.meas tran vdout1_24ck740 FIND v(dout1_24) AT=375.025n

.meas tran vdout1_25ck740 FIND v(dout1_25) AT=375.025n

.meas tran vdout1_26ck740 FIND v(dout1_26) AT=375.025n

.meas tran vdout1_27ck740 FIND v(dout1_27) AT=375.025n

.meas tran vdout1_28ck740 FIND v(dout1_28) AT=375.025n

.meas tran vdout1_29ck740 FIND v(dout1_29) AT=375.025n

.meas tran vdout1_30ck740 FIND v(dout1_30) AT=375.025n

.meas tran vdout1_31ck740 FIND v(dout1_31) AT=375.025n

.meas tran vdout1_32ck740 FIND v(dout1_32) AT=375.025n

.meas tran vdout1_33ck740 FIND v(dout1_33) AT=375.025n

.meas tran vdout1_34ck740 FIND v(dout1_34) AT=375.025n

.meas tran vdout1_35ck740 FIND v(dout1_35) AT=375.025n

.meas tran vdout1_36ck740 FIND v(dout1_36) AT=375.025n

.meas tran vdout1_37ck740 FIND v(dout1_37) AT=375.025n

.meas tran vdout1_38ck740 FIND v(dout1_38) AT=375.025n

.meas tran vdout1_39ck740 FIND v(dout1_39) AT=375.025n

.meas tran vdout1_40ck740 FIND v(dout1_40) AT=375.025n

.meas tran vdout1_41ck740 FIND v(dout1_41) AT=375.025n

.meas tran vdout1_42ck740 FIND v(dout1_42) AT=375.025n

.meas tran vdout1_43ck740 FIND v(dout1_43) AT=375.025n

.meas tran vdout1_44ck740 FIND v(dout1_44) AT=375.025n

.meas tran vdout1_45ck740 FIND v(dout1_45) AT=375.025n

.meas tran vdout1_46ck740 FIND v(dout1_46) AT=375.025n

.meas tran vdout1_47ck740 FIND v(dout1_47) AT=375.025n

.meas tran vdout1_48ck740 FIND v(dout1_48) AT=375.025n

.meas tran vdout1_49ck740 FIND v(dout1_49) AT=375.025n

.meas tran vdout1_50ck740 FIND v(dout1_50) AT=375.025n

.meas tran vdout1_51ck740 FIND v(dout1_51) AT=375.025n

.meas tran vdout1_52ck740 FIND v(dout1_52) AT=375.025n

.meas tran vdout1_53ck740 FIND v(dout1_53) AT=375.025n

.meas tran vdout1_54ck740 FIND v(dout1_54) AT=375.025n

.meas tran vdout1_55ck740 FIND v(dout1_55) AT=375.025n

.meas tran vdout1_56ck740 FIND v(dout1_56) AT=375.025n

.meas tran vdout1_57ck740 FIND v(dout1_57) AT=375.025n

.meas tran vdout1_58ck740 FIND v(dout1_58) AT=375.025n

.meas tran vdout1_59ck740 FIND v(dout1_59) AT=375.025n

.meas tran vdout1_60ck740 FIND v(dout1_60) AT=375.025n

.meas tran vdout1_61ck740 FIND v(dout1_61) AT=375.025n

.meas tran vdout1_62ck740 FIND v(dout1_62) AT=375.025n

.meas tran vdout1_63ck740 FIND v(dout1_63) AT=375.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_19ck760 FIND v(dout1_19) AT=385.025n

.meas tran vdout1_20ck760 FIND v(dout1_20) AT=385.025n

.meas tran vdout1_21ck760 FIND v(dout1_21) AT=385.025n

.meas tran vdout1_22ck760 FIND v(dout1_22) AT=385.025n

.meas tran vdout1_23ck760 FIND v(dout1_23) AT=385.025n

.meas tran vdout1_24ck760 FIND v(dout1_24) AT=385.025n

.meas tran vdout1_25ck760 FIND v(dout1_25) AT=385.025n

.meas tran vdout1_26ck760 FIND v(dout1_26) AT=385.025n

.meas tran vdout1_27ck760 FIND v(dout1_27) AT=385.025n

.meas tran vdout1_28ck760 FIND v(dout1_28) AT=385.025n

.meas tran vdout1_29ck760 FIND v(dout1_29) AT=385.025n

.meas tran vdout1_30ck760 FIND v(dout1_30) AT=385.025n

.meas tran vdout1_31ck760 FIND v(dout1_31) AT=385.025n

.meas tran vdout1_32ck760 FIND v(dout1_32) AT=385.025n

.meas tran vdout1_33ck760 FIND v(dout1_33) AT=385.025n

.meas tran vdout1_34ck760 FIND v(dout1_34) AT=385.025n

.meas tran vdout1_35ck760 FIND v(dout1_35) AT=385.025n

.meas tran vdout1_36ck760 FIND v(dout1_36) AT=385.025n

.meas tran vdout1_37ck760 FIND v(dout1_37) AT=385.025n

.meas tran vdout1_38ck760 FIND v(dout1_38) AT=385.025n

.meas tran vdout1_39ck760 FIND v(dout1_39) AT=385.025n

.meas tran vdout1_40ck760 FIND v(dout1_40) AT=385.025n

.meas tran vdout1_41ck760 FIND v(dout1_41) AT=385.025n

.meas tran vdout1_42ck760 FIND v(dout1_42) AT=385.025n

.meas tran vdout1_43ck760 FIND v(dout1_43) AT=385.025n

.meas tran vdout1_44ck760 FIND v(dout1_44) AT=385.025n

.meas tran vdout1_45ck760 FIND v(dout1_45) AT=385.025n

.meas tran vdout1_46ck760 FIND v(dout1_46) AT=385.025n

.meas tran vdout1_47ck760 FIND v(dout1_47) AT=385.025n

.meas tran vdout1_48ck760 FIND v(dout1_48) AT=385.025n

.meas tran vdout1_49ck760 FIND v(dout1_49) AT=385.025n

.meas tran vdout1_50ck760 FIND v(dout1_50) AT=385.025n

.meas tran vdout1_51ck760 FIND v(dout1_51) AT=385.025n

.meas tran vdout1_52ck760 FIND v(dout1_52) AT=385.025n

.meas tran vdout1_53ck760 FIND v(dout1_53) AT=385.025n

.meas tran vdout1_54ck760 FIND v(dout1_54) AT=385.025n

.meas tran vdout1_55ck760 FIND v(dout1_55) AT=385.025n

.meas tran vdout1_56ck760 FIND v(dout1_56) AT=385.025n

.meas tran vdout1_57ck760 FIND v(dout1_57) AT=385.025n

.meas tran vdout1_58ck760 FIND v(dout1_58) AT=385.025n

.meas tran vdout1_59ck760 FIND v(dout1_59) AT=385.025n

.meas tran vdout1_60ck760 FIND v(dout1_60) AT=385.025n

.meas tran vdout1_61ck760 FIND v(dout1_61) AT=385.025n

.meas tran vdout1_62ck760 FIND v(dout1_62) AT=385.025n

.meas tran vdout1_63ck760 FIND v(dout1_63) AT=385.025n

.meas tran vdout1_0ck790 FIND v(dout1_0) AT=400.025n

.meas tran vdout1_1ck790 FIND v(dout1_1) AT=400.025n

.meas tran vdout1_2ck790 FIND v(dout1_2) AT=400.025n

.meas tran vdout1_3ck790 FIND v(dout1_3) AT=400.025n

.meas tran vdout1_4ck790 FIND v(dout1_4) AT=400.025n

.meas tran vdout1_5ck790 FIND v(dout1_5) AT=400.025n

.meas tran vdout1_6ck790 FIND v(dout1_6) AT=400.025n

.meas tran vdout1_7ck790 FIND v(dout1_7) AT=400.025n

.meas tran vdout1_8ck790 FIND v(dout1_8) AT=400.025n

.meas tran vdout1_9ck790 FIND v(dout1_9) AT=400.025n

.meas tran vdout1_10ck790 FIND v(dout1_10) AT=400.025n

.meas tran vdout1_11ck790 FIND v(dout1_11) AT=400.025n

.meas tran vdout1_12ck790 FIND v(dout1_12) AT=400.025n

.meas tran vdout1_13ck790 FIND v(dout1_13) AT=400.025n

.meas tran vdout1_14ck790 FIND v(dout1_14) AT=400.025n

.meas tran vdout1_15ck790 FIND v(dout1_15) AT=400.025n

.meas tran vdout1_16ck790 FIND v(dout1_16) AT=400.025n

.meas tran vdout1_17ck790 FIND v(dout1_17) AT=400.025n

.meas tran vdout1_18ck790 FIND v(dout1_18) AT=400.025n

.meas tran vdout1_19ck790 FIND v(dout1_19) AT=400.025n

.meas tran vdout1_20ck790 FIND v(dout1_20) AT=400.025n

.meas tran vdout1_21ck790 FIND v(dout1_21) AT=400.025n

.meas tran vdout1_22ck790 FIND v(dout1_22) AT=400.025n

.meas tran vdout1_23ck790 FIND v(dout1_23) AT=400.025n

.meas tran vdout1_24ck790 FIND v(dout1_24) AT=400.025n

.meas tran vdout1_25ck790 FIND v(dout1_25) AT=400.025n

.meas tran vdout1_26ck790 FIND v(dout1_26) AT=400.025n

.meas tran vdout1_27ck790 FIND v(dout1_27) AT=400.025n

.meas tran vdout1_28ck790 FIND v(dout1_28) AT=400.025n

.meas tran vdout1_29ck790 FIND v(dout1_29) AT=400.025n

.meas tran vdout1_30ck790 FIND v(dout1_30) AT=400.025n

.meas tran vdout1_31ck790 FIND v(dout1_31) AT=400.025n

.meas tran vdout1_32ck790 FIND v(dout1_32) AT=400.025n

.meas tran vdout1_33ck790 FIND v(dout1_33) AT=400.025n

.meas tran vdout1_34ck790 FIND v(dout1_34) AT=400.025n

.meas tran vdout1_35ck790 FIND v(dout1_35) AT=400.025n

.meas tran vdout1_36ck790 FIND v(dout1_36) AT=400.025n

.meas tran vdout1_37ck790 FIND v(dout1_37) AT=400.025n

.meas tran vdout1_38ck790 FIND v(dout1_38) AT=400.025n

.meas tran vdout1_39ck790 FIND v(dout1_39) AT=400.025n

.meas tran vdout1_40ck790 FIND v(dout1_40) AT=400.025n

.meas tran vdout1_41ck790 FIND v(dout1_41) AT=400.025n

.meas tran vdout1_42ck790 FIND v(dout1_42) AT=400.025n

.meas tran vdout1_43ck790 FIND v(dout1_43) AT=400.025n

.meas tran vdout1_44ck790 FIND v(dout1_44) AT=400.025n

.meas tran vdout1_45ck790 FIND v(dout1_45) AT=400.025n

.meas tran vdout1_46ck790 FIND v(dout1_46) AT=400.025n

.meas tran vdout1_47ck790 FIND v(dout1_47) AT=400.025n

.meas tran vdout1_48ck790 FIND v(dout1_48) AT=400.025n

.meas tran vdout1_49ck790 FIND v(dout1_49) AT=400.025n

.meas tran vdout1_50ck790 FIND v(dout1_50) AT=400.025n

.meas tran vdout1_51ck790 FIND v(dout1_51) AT=400.025n

.meas tran vdout1_52ck790 FIND v(dout1_52) AT=400.025n

.meas tran vdout1_53ck790 FIND v(dout1_53) AT=400.025n

.meas tran vdout1_54ck790 FIND v(dout1_54) AT=400.025n

.meas tran vdout1_55ck790 FIND v(dout1_55) AT=400.025n

.meas tran vdout1_56ck790 FIND v(dout1_56) AT=400.025n

.meas tran vdout1_57ck790 FIND v(dout1_57) AT=400.025n

.meas tran vdout1_58ck790 FIND v(dout1_58) AT=400.025n

.meas tran vdout1_59ck790 FIND v(dout1_59) AT=400.025n

.meas tran vdout1_60ck790 FIND v(dout1_60) AT=400.025n

.meas tran vdout1_61ck790 FIND v(dout1_61) AT=400.025n

.meas tran vdout1_62ck790 FIND v(dout1_62) AT=400.025n

.meas tran vdout1_63ck790 FIND v(dout1_63) AT=400.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_8ck810 FIND v(dout1_8) AT=410.025n

.meas tran vdout1_9ck810 FIND v(dout1_9) AT=410.025n

.meas tran vdout1_10ck810 FIND v(dout1_10) AT=410.025n

.meas tran vdout1_11ck810 FIND v(dout1_11) AT=410.025n

.meas tran vdout1_12ck810 FIND v(dout1_12) AT=410.025n

.meas tran vdout1_13ck810 FIND v(dout1_13) AT=410.025n

.meas tran vdout1_14ck810 FIND v(dout1_14) AT=410.025n

.meas tran vdout1_15ck810 FIND v(dout1_15) AT=410.025n

.meas tran vdout1_16ck810 FIND v(dout1_16) AT=410.025n

.meas tran vdout1_17ck810 FIND v(dout1_17) AT=410.025n

.meas tran vdout1_18ck810 FIND v(dout1_18) AT=410.025n

.meas tran vdout1_19ck810 FIND v(dout1_19) AT=410.025n

.meas tran vdout1_20ck810 FIND v(dout1_20) AT=410.025n

.meas tran vdout1_21ck810 FIND v(dout1_21) AT=410.025n

.meas tran vdout1_22ck810 FIND v(dout1_22) AT=410.025n

.meas tran vdout1_23ck810 FIND v(dout1_23) AT=410.025n

.meas tran vdout1_24ck810 FIND v(dout1_24) AT=410.025n

.meas tran vdout1_25ck810 FIND v(dout1_25) AT=410.025n

.meas tran vdout1_26ck810 FIND v(dout1_26) AT=410.025n

.meas tran vdout1_27ck810 FIND v(dout1_27) AT=410.025n

.meas tran vdout1_28ck810 FIND v(dout1_28) AT=410.025n

.meas tran vdout1_29ck810 FIND v(dout1_29) AT=410.025n

.meas tran vdout1_30ck810 FIND v(dout1_30) AT=410.025n

.meas tran vdout1_31ck810 FIND v(dout1_31) AT=410.025n

.meas tran vdout1_32ck810 FIND v(dout1_32) AT=410.025n

.meas tran vdout1_33ck810 FIND v(dout1_33) AT=410.025n

.meas tran vdout1_34ck810 FIND v(dout1_34) AT=410.025n

.meas tran vdout1_35ck810 FIND v(dout1_35) AT=410.025n

.meas tran vdout1_36ck810 FIND v(dout1_36) AT=410.025n

.meas tran vdout1_37ck810 FIND v(dout1_37) AT=410.025n

.meas tran vdout1_38ck810 FIND v(dout1_38) AT=410.025n

.meas tran vdout1_39ck810 FIND v(dout1_39) AT=410.025n

.meas tran vdout1_40ck810 FIND v(dout1_40) AT=410.025n

.meas tran vdout1_41ck810 FIND v(dout1_41) AT=410.025n

.meas tran vdout1_42ck810 FIND v(dout1_42) AT=410.025n

.meas tran vdout1_43ck810 FIND v(dout1_43) AT=410.025n

.meas tran vdout1_44ck810 FIND v(dout1_44) AT=410.025n

.meas tran vdout1_45ck810 FIND v(dout1_45) AT=410.025n

.meas tran vdout1_46ck810 FIND v(dout1_46) AT=410.025n

.meas tran vdout1_47ck810 FIND v(dout1_47) AT=410.025n

.meas tran vdout1_48ck810 FIND v(dout1_48) AT=410.025n

.meas tran vdout1_49ck810 FIND v(dout1_49) AT=410.025n

.meas tran vdout1_50ck810 FIND v(dout1_50) AT=410.025n

.meas tran vdout1_51ck810 FIND v(dout1_51) AT=410.025n

.meas tran vdout1_52ck810 FIND v(dout1_52) AT=410.025n

.meas tran vdout1_53ck810 FIND v(dout1_53) AT=410.025n

.meas tran vdout1_54ck810 FIND v(dout1_54) AT=410.025n

.meas tran vdout1_55ck810 FIND v(dout1_55) AT=410.025n

.meas tran vdout1_56ck810 FIND v(dout1_56) AT=410.025n

.meas tran vdout1_57ck810 FIND v(dout1_57) AT=410.025n

.meas tran vdout1_58ck810 FIND v(dout1_58) AT=410.025n

.meas tran vdout1_59ck810 FIND v(dout1_59) AT=410.025n

.meas tran vdout1_60ck810 FIND v(dout1_60) AT=410.025n

.meas tran vdout1_61ck810 FIND v(dout1_61) AT=410.025n

.meas tran vdout1_62ck810 FIND v(dout1_62) AT=410.025n

.meas tran vdout1_63ck810 FIND v(dout1_63) AT=410.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_16ck820 FIND v(dout1_16) AT=415.025n

.meas tran vdout1_17ck820 FIND v(dout1_17) AT=415.025n

.meas tran vdout1_18ck820 FIND v(dout1_18) AT=415.025n

.meas tran vdout1_19ck820 FIND v(dout1_19) AT=415.025n

.meas tran vdout1_20ck820 FIND v(dout1_20) AT=415.025n

.meas tran vdout1_21ck820 FIND v(dout1_21) AT=415.025n

.meas tran vdout1_22ck820 FIND v(dout1_22) AT=415.025n

.meas tran vdout1_23ck820 FIND v(dout1_23) AT=415.025n

.meas tran vdout1_24ck820 FIND v(dout1_24) AT=415.025n

.meas tran vdout1_25ck820 FIND v(dout1_25) AT=415.025n

.meas tran vdout1_26ck820 FIND v(dout1_26) AT=415.025n

.meas tran vdout1_27ck820 FIND v(dout1_27) AT=415.025n

.meas tran vdout1_28ck820 FIND v(dout1_28) AT=415.025n

.meas tran vdout1_29ck820 FIND v(dout1_29) AT=415.025n

.meas tran vdout1_30ck820 FIND v(dout1_30) AT=415.025n

.meas tran vdout1_31ck820 FIND v(dout1_31) AT=415.025n

.meas tran vdout1_32ck820 FIND v(dout1_32) AT=415.025n

.meas tran vdout1_33ck820 FIND v(dout1_33) AT=415.025n

.meas tran vdout1_34ck820 FIND v(dout1_34) AT=415.025n

.meas tran vdout1_35ck820 FIND v(dout1_35) AT=415.025n

.meas tran vdout1_36ck820 FIND v(dout1_36) AT=415.025n

.meas tran vdout1_37ck820 FIND v(dout1_37) AT=415.025n

.meas tran vdout1_38ck820 FIND v(dout1_38) AT=415.025n

.meas tran vdout1_39ck820 FIND v(dout1_39) AT=415.025n

.meas tran vdout1_40ck820 FIND v(dout1_40) AT=415.025n

.meas tran vdout1_41ck820 FIND v(dout1_41) AT=415.025n

.meas tran vdout1_42ck820 FIND v(dout1_42) AT=415.025n

.meas tran vdout1_43ck820 FIND v(dout1_43) AT=415.025n

.meas tran vdout1_44ck820 FIND v(dout1_44) AT=415.025n

.meas tran vdout1_45ck820 FIND v(dout1_45) AT=415.025n

.meas tran vdout1_46ck820 FIND v(dout1_46) AT=415.025n

.meas tran vdout1_47ck820 FIND v(dout1_47) AT=415.025n

.meas tran vdout1_48ck820 FIND v(dout1_48) AT=415.025n

.meas tran vdout1_49ck820 FIND v(dout1_49) AT=415.025n

.meas tran vdout1_50ck820 FIND v(dout1_50) AT=415.025n

.meas tran vdout1_51ck820 FIND v(dout1_51) AT=415.025n

.meas tran vdout1_52ck820 FIND v(dout1_52) AT=415.025n

.meas tran vdout1_53ck820 FIND v(dout1_53) AT=415.025n

.meas tran vdout1_54ck820 FIND v(dout1_54) AT=415.025n

.meas tran vdout1_55ck820 FIND v(dout1_55) AT=415.025n

.meas tran vdout1_56ck820 FIND v(dout1_56) AT=415.025n

.meas tran vdout1_57ck820 FIND v(dout1_57) AT=415.025n

.meas tran vdout1_58ck820 FIND v(dout1_58) AT=415.025n

.meas tran vdout1_59ck820 FIND v(dout1_59) AT=415.025n

.meas tran vdout1_60ck820 FIND v(dout1_60) AT=415.025n

.meas tran vdout1_61ck820 FIND v(dout1_61) AT=415.025n

.meas tran vdout1_62ck820 FIND v(dout1_62) AT=415.025n

.meas tran vdout1_63ck820 FIND v(dout1_63) AT=415.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_32ck830 FIND v(dout1_32) AT=420.025n

.meas tran vdout1_33ck830 FIND v(dout1_33) AT=420.025n

.meas tran vdout1_34ck830 FIND v(dout1_34) AT=420.025n

.meas tran vdout1_35ck830 FIND v(dout1_35) AT=420.025n

.meas tran vdout1_36ck830 FIND v(dout1_36) AT=420.025n

.meas tran vdout1_37ck830 FIND v(dout1_37) AT=420.025n

.meas tran vdout1_38ck830 FIND v(dout1_38) AT=420.025n

.meas tran vdout1_39ck830 FIND v(dout1_39) AT=420.025n

.meas tran vdout1_40ck830 FIND v(dout1_40) AT=420.025n

.meas tran vdout1_41ck830 FIND v(dout1_41) AT=420.025n

.meas tran vdout1_42ck830 FIND v(dout1_42) AT=420.025n

.meas tran vdout1_43ck830 FIND v(dout1_43) AT=420.025n

.meas tran vdout1_44ck830 FIND v(dout1_44) AT=420.025n

.meas tran vdout1_45ck830 FIND v(dout1_45) AT=420.025n

.meas tran vdout1_46ck830 FIND v(dout1_46) AT=420.025n

.meas tran vdout1_47ck830 FIND v(dout1_47) AT=420.025n

.meas tran vdout1_48ck830 FIND v(dout1_48) AT=420.025n

.meas tran vdout1_49ck830 FIND v(dout1_49) AT=420.025n

.meas tran vdout1_50ck830 FIND v(dout1_50) AT=420.025n

.meas tran vdout1_51ck830 FIND v(dout1_51) AT=420.025n

.meas tran vdout1_52ck830 FIND v(dout1_52) AT=420.025n

.meas tran vdout1_53ck830 FIND v(dout1_53) AT=420.025n

.meas tran vdout1_54ck830 FIND v(dout1_54) AT=420.025n

.meas tran vdout1_55ck830 FIND v(dout1_55) AT=420.025n

.meas tran vdout1_56ck830 FIND v(dout1_56) AT=420.025n

.meas tran vdout1_57ck830 FIND v(dout1_57) AT=420.025n

.meas tran vdout1_58ck830 FIND v(dout1_58) AT=420.025n

.meas tran vdout1_59ck830 FIND v(dout1_59) AT=420.025n

.meas tran vdout1_60ck830 FIND v(dout1_60) AT=420.025n

.meas tran vdout1_61ck830 FIND v(dout1_61) AT=420.025n

.meas tran vdout1_62ck830 FIND v(dout1_62) AT=420.025n

.meas tran vdout1_63ck830 FIND v(dout1_63) AT=420.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_19ck850 FIND v(dout1_19) AT=430.025n

.meas tran vdout1_20ck850 FIND v(dout1_20) AT=430.025n

.meas tran vdout1_21ck850 FIND v(dout1_21) AT=430.025n

.meas tran vdout1_22ck850 FIND v(dout1_22) AT=430.025n

.meas tran vdout1_23ck850 FIND v(dout1_23) AT=430.025n

.meas tran vdout1_24ck850 FIND v(dout1_24) AT=430.025n

.meas tran vdout1_25ck850 FIND v(dout1_25) AT=430.025n

.meas tran vdout1_26ck850 FIND v(dout1_26) AT=430.025n

.meas tran vdout1_27ck850 FIND v(dout1_27) AT=430.025n

.meas tran vdout1_28ck850 FIND v(dout1_28) AT=430.025n

.meas tran vdout1_29ck850 FIND v(dout1_29) AT=430.025n

.meas tran vdout1_30ck850 FIND v(dout1_30) AT=430.025n

.meas tran vdout1_31ck850 FIND v(dout1_31) AT=430.025n

.meas tran vdout1_32ck850 FIND v(dout1_32) AT=430.025n

.meas tran vdout1_33ck850 FIND v(dout1_33) AT=430.025n

.meas tran vdout1_34ck850 FIND v(dout1_34) AT=430.025n

.meas tran vdout1_35ck850 FIND v(dout1_35) AT=430.025n

.meas tran vdout1_36ck850 FIND v(dout1_36) AT=430.025n

.meas tran vdout1_37ck850 FIND v(dout1_37) AT=430.025n

.meas tran vdout1_38ck850 FIND v(dout1_38) AT=430.025n

.meas tran vdout1_39ck850 FIND v(dout1_39) AT=430.025n

.meas tran vdout1_40ck850 FIND v(dout1_40) AT=430.025n

.meas tran vdout1_41ck850 FIND v(dout1_41) AT=430.025n

.meas tran vdout1_42ck850 FIND v(dout1_42) AT=430.025n

.meas tran vdout1_43ck850 FIND v(dout1_43) AT=430.025n

.meas tran vdout1_44ck850 FIND v(dout1_44) AT=430.025n

.meas tran vdout1_45ck850 FIND v(dout1_45) AT=430.025n

.meas tran vdout1_46ck850 FIND v(dout1_46) AT=430.025n

.meas tran vdout1_47ck850 FIND v(dout1_47) AT=430.025n

.meas tran vdout1_48ck850 FIND v(dout1_48) AT=430.025n

.meas tran vdout1_49ck850 FIND v(dout1_49) AT=430.025n

.meas tran vdout1_50ck850 FIND v(dout1_50) AT=430.025n

.meas tran vdout1_51ck850 FIND v(dout1_51) AT=430.025n

.meas tran vdout1_52ck850 FIND v(dout1_52) AT=430.025n

.meas tran vdout1_53ck850 FIND v(dout1_53) AT=430.025n

.meas tran vdout1_54ck850 FIND v(dout1_54) AT=430.025n

.meas tran vdout1_55ck850 FIND v(dout1_55) AT=430.025n

.meas tran vdout1_56ck850 FIND v(dout1_56) AT=430.025n

.meas tran vdout1_57ck850 FIND v(dout1_57) AT=430.025n

.meas tran vdout1_58ck850 FIND v(dout1_58) AT=430.025n

.meas tran vdout1_59ck850 FIND v(dout1_59) AT=430.025n

.meas tran vdout1_60ck850 FIND v(dout1_60) AT=430.025n

.meas tran vdout1_61ck850 FIND v(dout1_61) AT=430.025n

.meas tran vdout1_62ck850 FIND v(dout1_62) AT=430.025n

.meas tran vdout1_63ck850 FIND v(dout1_63) AT=430.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_32ck880 FIND v(dout1_32) AT=445.025n

.meas tran vdout1_33ck880 FIND v(dout1_33) AT=445.025n

.meas tran vdout1_34ck880 FIND v(dout1_34) AT=445.025n

.meas tran vdout1_35ck880 FIND v(dout1_35) AT=445.025n

.meas tran vdout1_36ck880 FIND v(dout1_36) AT=445.025n

.meas tran vdout1_37ck880 FIND v(dout1_37) AT=445.025n

.meas tran vdout1_38ck880 FIND v(dout1_38) AT=445.025n

.meas tran vdout1_39ck880 FIND v(dout1_39) AT=445.025n

.meas tran vdout1_40ck880 FIND v(dout1_40) AT=445.025n

.meas tran vdout1_41ck880 FIND v(dout1_41) AT=445.025n

.meas tran vdout1_42ck880 FIND v(dout1_42) AT=445.025n

.meas tran vdout1_43ck880 FIND v(dout1_43) AT=445.025n

.meas tran vdout1_44ck880 FIND v(dout1_44) AT=445.025n

.meas tran vdout1_45ck880 FIND v(dout1_45) AT=445.025n

.meas tran vdout1_46ck880 FIND v(dout1_46) AT=445.025n

.meas tran vdout1_47ck880 FIND v(dout1_47) AT=445.025n

.meas tran vdout1_48ck880 FIND v(dout1_48) AT=445.025n

.meas tran vdout1_49ck880 FIND v(dout1_49) AT=445.025n

.meas tran vdout1_50ck880 FIND v(dout1_50) AT=445.025n

.meas tran vdout1_51ck880 FIND v(dout1_51) AT=445.025n

.meas tran vdout1_52ck880 FIND v(dout1_52) AT=445.025n

.meas tran vdout1_53ck880 FIND v(dout1_53) AT=445.025n

.meas tran vdout1_54ck880 FIND v(dout1_54) AT=445.025n

.meas tran vdout1_55ck880 FIND v(dout1_55) AT=445.025n

.meas tran vdout1_56ck880 FIND v(dout1_56) AT=445.025n

.meas tran vdout1_57ck880 FIND v(dout1_57) AT=445.025n

.meas tran vdout1_58ck880 FIND v(dout1_58) AT=445.025n

.meas tran vdout1_59ck880 FIND v(dout1_59) AT=445.025n

.meas tran vdout1_60ck880 FIND v(dout1_60) AT=445.025n

.meas tran vdout1_61ck880 FIND v(dout1_61) AT=445.025n

.meas tran vdout1_62ck880 FIND v(dout1_62) AT=445.025n

.meas tran vdout1_63ck880 FIND v(dout1_63) AT=445.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_16ck890 FIND v(dout1_16) AT=450.025n

.meas tran vdout1_17ck890 FIND v(dout1_17) AT=450.025n

.meas tran vdout1_18ck890 FIND v(dout1_18) AT=450.025n

.meas tran vdout1_19ck890 FIND v(dout1_19) AT=450.025n

.meas tran vdout1_20ck890 FIND v(dout1_20) AT=450.025n

.meas tran vdout1_21ck890 FIND v(dout1_21) AT=450.025n

.meas tran vdout1_22ck890 FIND v(dout1_22) AT=450.025n

.meas tran vdout1_23ck890 FIND v(dout1_23) AT=450.025n

.meas tran vdout1_24ck890 FIND v(dout1_24) AT=450.025n

.meas tran vdout1_25ck890 FIND v(dout1_25) AT=450.025n

.meas tran vdout1_26ck890 FIND v(dout1_26) AT=450.025n

.meas tran vdout1_27ck890 FIND v(dout1_27) AT=450.025n

.meas tran vdout1_28ck890 FIND v(dout1_28) AT=450.025n

.meas tran vdout1_29ck890 FIND v(dout1_29) AT=450.025n

.meas tran vdout1_30ck890 FIND v(dout1_30) AT=450.025n

.meas tran vdout1_31ck890 FIND v(dout1_31) AT=450.025n

.meas tran vdout1_32ck890 FIND v(dout1_32) AT=450.025n

.meas tran vdout1_33ck890 FIND v(dout1_33) AT=450.025n

.meas tran vdout1_34ck890 FIND v(dout1_34) AT=450.025n

.meas tran vdout1_35ck890 FIND v(dout1_35) AT=450.025n

.meas tran vdout1_36ck890 FIND v(dout1_36) AT=450.025n

.meas tran vdout1_37ck890 FIND v(dout1_37) AT=450.025n

.meas tran vdout1_38ck890 FIND v(dout1_38) AT=450.025n

.meas tran vdout1_39ck890 FIND v(dout1_39) AT=450.025n

.meas tran vdout1_40ck890 FIND v(dout1_40) AT=450.025n

.meas tran vdout1_41ck890 FIND v(dout1_41) AT=450.025n

.meas tran vdout1_42ck890 FIND v(dout1_42) AT=450.025n

.meas tran vdout1_43ck890 FIND v(dout1_43) AT=450.025n

.meas tran vdout1_44ck890 FIND v(dout1_44) AT=450.025n

.meas tran vdout1_45ck890 FIND v(dout1_45) AT=450.025n

.meas tran vdout1_46ck890 FIND v(dout1_46) AT=450.025n

.meas tran vdout1_47ck890 FIND v(dout1_47) AT=450.025n

.meas tran vdout1_48ck890 FIND v(dout1_48) AT=450.025n

.meas tran vdout1_49ck890 FIND v(dout1_49) AT=450.025n

.meas tran vdout1_50ck890 FIND v(dout1_50) AT=450.025n

.meas tran vdout1_51ck890 FIND v(dout1_51) AT=450.025n

.meas tran vdout1_52ck890 FIND v(dout1_52) AT=450.025n

.meas tran vdout1_53ck890 FIND v(dout1_53) AT=450.025n

.meas tran vdout1_54ck890 FIND v(dout1_54) AT=450.025n

.meas tran vdout1_55ck890 FIND v(dout1_55) AT=450.025n

.meas tran vdout1_56ck890 FIND v(dout1_56) AT=450.025n

.meas tran vdout1_57ck890 FIND v(dout1_57) AT=450.025n

.meas tran vdout1_58ck890 FIND v(dout1_58) AT=450.025n

.meas tran vdout1_59ck890 FIND v(dout1_59) AT=450.025n

.meas tran vdout1_60ck890 FIND v(dout1_60) AT=450.025n

.meas tran vdout1_61ck890 FIND v(dout1_61) AT=450.025n

.meas tran vdout1_62ck890 FIND v(dout1_62) AT=450.025n

.meas tran vdout1_63ck890 FIND v(dout1_63) AT=450.025n

.meas tran vdout1_0ck910 FIND v(dout1_0) AT=460.025n

.meas tran vdout1_1ck910 FIND v(dout1_1) AT=460.025n

.meas tran vdout1_2ck910 FIND v(dout1_2) AT=460.025n

.meas tran vdout1_3ck910 FIND v(dout1_3) AT=460.025n

.meas tran vdout1_4ck910 FIND v(dout1_4) AT=460.025n

.meas tran vdout1_5ck910 FIND v(dout1_5) AT=460.025n

.meas tran vdout1_6ck910 FIND v(dout1_6) AT=460.025n

.meas tran vdout1_7ck910 FIND v(dout1_7) AT=460.025n

.meas tran vdout1_8ck910 FIND v(dout1_8) AT=460.025n

.meas tran vdout1_9ck910 FIND v(dout1_9) AT=460.025n

.meas tran vdout1_10ck910 FIND v(dout1_10) AT=460.025n

.meas tran vdout1_11ck910 FIND v(dout1_11) AT=460.025n

.meas tran vdout1_12ck910 FIND v(dout1_12) AT=460.025n

.meas tran vdout1_13ck910 FIND v(dout1_13) AT=460.025n

.meas tran vdout1_14ck910 FIND v(dout1_14) AT=460.025n

.meas tran vdout1_15ck910 FIND v(dout1_15) AT=460.025n

.meas tran vdout1_16ck910 FIND v(dout1_16) AT=460.025n

.meas tran vdout1_17ck910 FIND v(dout1_17) AT=460.025n

.meas tran vdout1_18ck910 FIND v(dout1_18) AT=460.025n

.meas tran vdout1_19ck910 FIND v(dout1_19) AT=460.025n

.meas tran vdout1_20ck910 FIND v(dout1_20) AT=460.025n

.meas tran vdout1_21ck910 FIND v(dout1_21) AT=460.025n

.meas tran vdout1_22ck910 FIND v(dout1_22) AT=460.025n

.meas tran vdout1_23ck910 FIND v(dout1_23) AT=460.025n

.meas tran vdout1_24ck910 FIND v(dout1_24) AT=460.025n

.meas tran vdout1_25ck910 FIND v(dout1_25) AT=460.025n

.meas tran vdout1_26ck910 FIND v(dout1_26) AT=460.025n

.meas tran vdout1_27ck910 FIND v(dout1_27) AT=460.025n

.meas tran vdout1_28ck910 FIND v(dout1_28) AT=460.025n

.meas tran vdout1_29ck910 FIND v(dout1_29) AT=460.025n

.meas tran vdout1_30ck910 FIND v(dout1_30) AT=460.025n

.meas tran vdout1_31ck910 FIND v(dout1_31) AT=460.025n

.meas tran vdout1_32ck910 FIND v(dout1_32) AT=460.025n

.meas tran vdout1_33ck910 FIND v(dout1_33) AT=460.025n

.meas tran vdout1_34ck910 FIND v(dout1_34) AT=460.025n

.meas tran vdout1_35ck910 FIND v(dout1_35) AT=460.025n

.meas tran vdout1_36ck910 FIND v(dout1_36) AT=460.025n

.meas tran vdout1_37ck910 FIND v(dout1_37) AT=460.025n

.meas tran vdout1_38ck910 FIND v(dout1_38) AT=460.025n

.meas tran vdout1_39ck910 FIND v(dout1_39) AT=460.025n

.meas tran vdout1_40ck910 FIND v(dout1_40) AT=460.025n

.meas tran vdout1_41ck910 FIND v(dout1_41) AT=460.025n

.meas tran vdout1_42ck910 FIND v(dout1_42) AT=460.025n

.meas tran vdout1_43ck910 FIND v(dout1_43) AT=460.025n

.meas tran vdout1_44ck910 FIND v(dout1_44) AT=460.025n

.meas tran vdout1_45ck910 FIND v(dout1_45) AT=460.025n

.meas tran vdout1_46ck910 FIND v(dout1_46) AT=460.025n

.meas tran vdout1_47ck910 FIND v(dout1_47) AT=460.025n

.meas tran vdout1_48ck910 FIND v(dout1_48) AT=460.025n

.meas tran vdout1_49ck910 FIND v(dout1_49) AT=460.025n

.meas tran vdout1_50ck910 FIND v(dout1_50) AT=460.025n

.meas tran vdout1_51ck910 FIND v(dout1_51) AT=460.025n

.meas tran vdout1_52ck910 FIND v(dout1_52) AT=460.025n

.meas tran vdout1_53ck910 FIND v(dout1_53) AT=460.025n

.meas tran vdout1_54ck910 FIND v(dout1_54) AT=460.025n

.meas tran vdout1_55ck910 FIND v(dout1_55) AT=460.025n

.meas tran vdout1_56ck910 FIND v(dout1_56) AT=460.025n

.meas tran vdout1_57ck910 FIND v(dout1_57) AT=460.025n

.meas tran vdout1_58ck910 FIND v(dout1_58) AT=460.025n

.meas tran vdout1_59ck910 FIND v(dout1_59) AT=460.025n

.meas tran vdout1_60ck910 FIND v(dout1_60) AT=460.025n

.meas tran vdout1_61ck910 FIND v(dout1_61) AT=460.025n

.meas tran vdout1_62ck910 FIND v(dout1_62) AT=460.025n

.meas tran vdout1_63ck910 FIND v(dout1_63) AT=460.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_32ck930 FIND v(dout1_32) AT=470.025n

.meas tran vdout1_33ck930 FIND v(dout1_33) AT=470.025n

.meas tran vdout1_34ck930 FIND v(dout1_34) AT=470.025n

.meas tran vdout1_35ck930 FIND v(dout1_35) AT=470.025n

.meas tran vdout1_36ck930 FIND v(dout1_36) AT=470.025n

.meas tran vdout1_37ck930 FIND v(dout1_37) AT=470.025n

.meas tran vdout1_38ck930 FIND v(dout1_38) AT=470.025n

.meas tran vdout1_39ck930 FIND v(dout1_39) AT=470.025n

.meas tran vdout1_40ck930 FIND v(dout1_40) AT=470.025n

.meas tran vdout1_41ck930 FIND v(dout1_41) AT=470.025n

.meas tran vdout1_42ck930 FIND v(dout1_42) AT=470.025n

.meas tran vdout1_43ck930 FIND v(dout1_43) AT=470.025n

.meas tran vdout1_44ck930 FIND v(dout1_44) AT=470.025n

.meas tran vdout1_45ck930 FIND v(dout1_45) AT=470.025n

.meas tran vdout1_46ck930 FIND v(dout1_46) AT=470.025n

.meas tran vdout1_47ck930 FIND v(dout1_47) AT=470.025n

.meas tran vdout1_48ck930 FIND v(dout1_48) AT=470.025n

.meas tran vdout1_49ck930 FIND v(dout1_49) AT=470.025n

.meas tran vdout1_50ck930 FIND v(dout1_50) AT=470.025n

.meas tran vdout1_51ck930 FIND v(dout1_51) AT=470.025n

.meas tran vdout1_52ck930 FIND v(dout1_52) AT=470.025n

.meas tran vdout1_53ck930 FIND v(dout1_53) AT=470.025n

.meas tran vdout1_54ck930 FIND v(dout1_54) AT=470.025n

.meas tran vdout1_55ck930 FIND v(dout1_55) AT=470.025n

.meas tran vdout1_56ck930 FIND v(dout1_56) AT=470.025n

.meas tran vdout1_57ck930 FIND v(dout1_57) AT=470.025n

.meas tran vdout1_58ck930 FIND v(dout1_58) AT=470.025n

.meas tran vdout1_59ck930 FIND v(dout1_59) AT=470.025n

.meas tran vdout1_60ck930 FIND v(dout1_60) AT=470.025n

.meas tran vdout1_61ck930 FIND v(dout1_61) AT=470.025n

.meas tran vdout1_62ck930 FIND v(dout1_62) AT=470.025n

.meas tran vdout1_63ck930 FIND v(dout1_63) AT=470.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_22ck950 FIND v(dout1_22) AT=480.025n

.meas tran vdout1_23ck950 FIND v(dout1_23) AT=480.025n

.meas tran vdout1_24ck950 FIND v(dout1_24) AT=480.025n

.meas tran vdout1_25ck950 FIND v(dout1_25) AT=480.025n

.meas tran vdout1_26ck950 FIND v(dout1_26) AT=480.025n

.meas tran vdout1_27ck950 FIND v(dout1_27) AT=480.025n

.meas tran vdout1_28ck950 FIND v(dout1_28) AT=480.025n

.meas tran vdout1_29ck950 FIND v(dout1_29) AT=480.025n

.meas tran vdout1_30ck950 FIND v(dout1_30) AT=480.025n

.meas tran vdout1_31ck950 FIND v(dout1_31) AT=480.025n

.meas tran vdout1_32ck950 FIND v(dout1_32) AT=480.025n

.meas tran vdout1_33ck950 FIND v(dout1_33) AT=480.025n

.meas tran vdout1_34ck950 FIND v(dout1_34) AT=480.025n

.meas tran vdout1_35ck950 FIND v(dout1_35) AT=480.025n

.meas tran vdout1_36ck950 FIND v(dout1_36) AT=480.025n

.meas tran vdout1_37ck950 FIND v(dout1_37) AT=480.025n

.meas tran vdout1_38ck950 FIND v(dout1_38) AT=480.025n

.meas tran vdout1_39ck950 FIND v(dout1_39) AT=480.025n

.meas tran vdout1_40ck950 FIND v(dout1_40) AT=480.025n

.meas tran vdout1_41ck950 FIND v(dout1_41) AT=480.025n

.meas tran vdout1_42ck950 FIND v(dout1_42) AT=480.025n

.meas tran vdout1_43ck950 FIND v(dout1_43) AT=480.025n

.meas tran vdout1_44ck950 FIND v(dout1_44) AT=480.025n

.meas tran vdout1_45ck950 FIND v(dout1_45) AT=480.025n

.meas tran vdout1_46ck950 FIND v(dout1_46) AT=480.025n

.meas tran vdout1_47ck950 FIND v(dout1_47) AT=480.025n

.meas tran vdout1_48ck950 FIND v(dout1_48) AT=480.025n

.meas tran vdout1_49ck950 FIND v(dout1_49) AT=480.025n

.meas tran vdout1_50ck950 FIND v(dout1_50) AT=480.025n

.meas tran vdout1_51ck950 FIND v(dout1_51) AT=480.025n

.meas tran vdout1_52ck950 FIND v(dout1_52) AT=480.025n

.meas tran vdout1_53ck950 FIND v(dout1_53) AT=480.025n

.meas tran vdout1_54ck950 FIND v(dout1_54) AT=480.025n

.meas tran vdout1_55ck950 FIND v(dout1_55) AT=480.025n

.meas tran vdout1_56ck950 FIND v(dout1_56) AT=480.025n

.meas tran vdout1_57ck950 FIND v(dout1_57) AT=480.025n

.meas tran vdout1_58ck950 FIND v(dout1_58) AT=480.025n

.meas tran vdout1_59ck950 FIND v(dout1_59) AT=480.025n

.meas tran vdout1_60ck950 FIND v(dout1_60) AT=480.025n

.meas tran vdout1_61ck950 FIND v(dout1_61) AT=480.025n

.meas tran vdout1_62ck950 FIND v(dout1_62) AT=480.025n

.meas tran vdout1_63ck950 FIND v(dout1_63) AT=480.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_16ck980 FIND v(dout1_16) AT=495.025n

.meas tran vdout1_17ck980 FIND v(dout1_17) AT=495.025n

.meas tran vdout1_18ck980 FIND v(dout1_18) AT=495.025n

.meas tran vdout1_19ck980 FIND v(dout1_19) AT=495.025n

.meas tran vdout1_20ck980 FIND v(dout1_20) AT=495.025n

.meas tran vdout1_21ck980 FIND v(dout1_21) AT=495.025n

.meas tran vdout1_22ck980 FIND v(dout1_22) AT=495.025n

.meas tran vdout1_23ck980 FIND v(dout1_23) AT=495.025n

.meas tran vdout1_24ck980 FIND v(dout1_24) AT=495.025n

.meas tran vdout1_25ck980 FIND v(dout1_25) AT=495.025n

.meas tran vdout1_26ck980 FIND v(dout1_26) AT=495.025n

.meas tran vdout1_27ck980 FIND v(dout1_27) AT=495.025n

.meas tran vdout1_28ck980 FIND v(dout1_28) AT=495.025n

.meas tran vdout1_29ck980 FIND v(dout1_29) AT=495.025n

.meas tran vdout1_30ck980 FIND v(dout1_30) AT=495.025n

.meas tran vdout1_31ck980 FIND v(dout1_31) AT=495.025n

.meas tran vdout1_32ck980 FIND v(dout1_32) AT=495.025n

.meas tran vdout1_33ck980 FIND v(dout1_33) AT=495.025n

.meas tran vdout1_34ck980 FIND v(dout1_34) AT=495.025n

.meas tran vdout1_35ck980 FIND v(dout1_35) AT=495.025n

.meas tran vdout1_36ck980 FIND v(dout1_36) AT=495.025n

.meas tran vdout1_37ck980 FIND v(dout1_37) AT=495.025n

.meas tran vdout1_38ck980 FIND v(dout1_38) AT=495.025n

.meas tran vdout1_39ck980 FIND v(dout1_39) AT=495.025n

.meas tran vdout1_40ck980 FIND v(dout1_40) AT=495.025n

.meas tran vdout1_41ck980 FIND v(dout1_41) AT=495.025n

.meas tran vdout1_42ck980 FIND v(dout1_42) AT=495.025n

.meas tran vdout1_43ck980 FIND v(dout1_43) AT=495.025n

.meas tran vdout1_44ck980 FIND v(dout1_44) AT=495.025n

.meas tran vdout1_45ck980 FIND v(dout1_45) AT=495.025n

.meas tran vdout1_46ck980 FIND v(dout1_46) AT=495.025n

.meas tran vdout1_47ck980 FIND v(dout1_47) AT=495.025n

.meas tran vdout1_48ck980 FIND v(dout1_48) AT=495.025n

.meas tran vdout1_49ck980 FIND v(dout1_49) AT=495.025n

.meas tran vdout1_50ck980 FIND v(dout1_50) AT=495.025n

.meas tran vdout1_51ck980 FIND v(dout1_51) AT=495.025n

.meas tran vdout1_52ck980 FIND v(dout1_52) AT=495.025n

.meas tran vdout1_53ck980 FIND v(dout1_53) AT=495.025n

.meas tran vdout1_54ck980 FIND v(dout1_54) AT=495.025n

.meas tran vdout1_55ck980 FIND v(dout1_55) AT=495.025n

.meas tran vdout1_56ck980 FIND v(dout1_56) AT=495.025n

.meas tran vdout1_57ck980 FIND v(dout1_57) AT=495.025n

.meas tran vdout1_58ck980 FIND v(dout1_58) AT=495.025n

.meas tran vdout1_59ck980 FIND v(dout1_59) AT=495.025n

.meas tran vdout1_60ck980 FIND v(dout1_60) AT=495.025n

.meas tran vdout1_61ck980 FIND v(dout1_61) AT=495.025n

.meas tran vdout1_62ck980 FIND v(dout1_62) AT=495.025n

.meas tran vdout1_63ck980 FIND v(dout1_63) AT=495.025n

.meas tran vdout1_0ck1000 FIND v(dout1_0) AT=505.025n

.meas tran vdout1_1ck1000 FIND v(dout1_1) AT=505.025n

.meas tran vdout1_2ck1000 FIND v(dout1_2) AT=505.025n

.meas tran vdout1_3ck1000 FIND v(dout1_3) AT=505.025n

.meas tran vdout1_4ck1000 FIND v(dout1_4) AT=505.025n

.meas tran vdout1_5ck1000 FIND v(dout1_5) AT=505.025n

.meas tran vdout1_6ck1000 FIND v(dout1_6) AT=505.025n

.meas tran vdout1_7ck1000 FIND v(dout1_7) AT=505.025n

.meas tran vdout1_8ck1000 FIND v(dout1_8) AT=505.025n

.meas tran vdout1_9ck1000 FIND v(dout1_9) AT=505.025n

.meas tran vdout1_10ck1000 FIND v(dout1_10) AT=505.025n

.meas tran vdout1_11ck1000 FIND v(dout1_11) AT=505.025n

.meas tran vdout1_12ck1000 FIND v(dout1_12) AT=505.025n

.meas tran vdout1_13ck1000 FIND v(dout1_13) AT=505.025n

.meas tran vdout1_14ck1000 FIND v(dout1_14) AT=505.025n

.meas tran vdout1_15ck1000 FIND v(dout1_15) AT=505.025n

.meas tran vdout1_16ck1000 FIND v(dout1_16) AT=505.025n

.meas tran vdout1_17ck1000 FIND v(dout1_17) AT=505.025n

.meas tran vdout1_18ck1000 FIND v(dout1_18) AT=505.025n

.meas tran vdout1_19ck1000 FIND v(dout1_19) AT=505.025n

.meas tran vdout1_20ck1000 FIND v(dout1_20) AT=505.025n

.meas tran vdout1_21ck1000 FIND v(dout1_21) AT=505.025n

.meas tran vdout1_22ck1000 FIND v(dout1_22) AT=505.025n

.meas tran vdout1_23ck1000 FIND v(dout1_23) AT=505.025n

.meas tran vdout1_24ck1000 FIND v(dout1_24) AT=505.025n

.meas tran vdout1_25ck1000 FIND v(dout1_25) AT=505.025n

.meas tran vdout1_26ck1000 FIND v(dout1_26) AT=505.025n

.meas tran vdout1_27ck1000 FIND v(dout1_27) AT=505.025n

.meas tran vdout1_28ck1000 FIND v(dout1_28) AT=505.025n

.meas tran vdout1_29ck1000 FIND v(dout1_29) AT=505.025n

.meas tran vdout1_30ck1000 FIND v(dout1_30) AT=505.025n

.meas tran vdout1_31ck1000 FIND v(dout1_31) AT=505.025n

.meas tran vdout1_32ck1000 FIND v(dout1_32) AT=505.025n

.meas tran vdout1_33ck1000 FIND v(dout1_33) AT=505.025n

.meas tran vdout1_34ck1000 FIND v(dout1_34) AT=505.025n

.meas tran vdout1_35ck1000 FIND v(dout1_35) AT=505.025n

.meas tran vdout1_36ck1000 FIND v(dout1_36) AT=505.025n

.meas tran vdout1_37ck1000 FIND v(dout1_37) AT=505.025n

.meas tran vdout1_38ck1000 FIND v(dout1_38) AT=505.025n

.meas tran vdout1_39ck1000 FIND v(dout1_39) AT=505.025n

.meas tran vdout1_40ck1000 FIND v(dout1_40) AT=505.025n

.meas tran vdout1_41ck1000 FIND v(dout1_41) AT=505.025n

.meas tran vdout1_42ck1000 FIND v(dout1_42) AT=505.025n

.meas tran vdout1_43ck1000 FIND v(dout1_43) AT=505.025n

.meas tran vdout1_44ck1000 FIND v(dout1_44) AT=505.025n

.meas tran vdout1_45ck1000 FIND v(dout1_45) AT=505.025n

.meas tran vdout1_46ck1000 FIND v(dout1_46) AT=505.025n

.meas tran vdout1_47ck1000 FIND v(dout1_47) AT=505.025n

.meas tran vdout1_48ck1000 FIND v(dout1_48) AT=505.025n

.meas tran vdout1_49ck1000 FIND v(dout1_49) AT=505.025n

.meas tran vdout1_50ck1000 FIND v(dout1_50) AT=505.025n

.meas tran vdout1_51ck1000 FIND v(dout1_51) AT=505.025n

.meas tran vdout1_52ck1000 FIND v(dout1_52) AT=505.025n

.meas tran vdout1_53ck1000 FIND v(dout1_53) AT=505.025n

.meas tran vdout1_54ck1000 FIND v(dout1_54) AT=505.025n

.meas tran vdout1_55ck1000 FIND v(dout1_55) AT=505.025n

.meas tran vdout1_56ck1000 FIND v(dout1_56) AT=505.025n

.meas tran vdout1_57ck1000 FIND v(dout1_57) AT=505.025n

.meas tran vdout1_58ck1000 FIND v(dout1_58) AT=505.025n

.meas tran vdout1_59ck1000 FIND v(dout1_59) AT=505.025n

.meas tran vdout1_60ck1000 FIND v(dout1_60) AT=505.025n

.meas tran vdout1_61ck1000 FIND v(dout1_61) AT=505.025n

.meas tran vdout1_62ck1000 FIND v(dout1_62) AT=505.025n

.meas tran vdout1_63ck1000 FIND v(dout1_63) AT=505.025n

.meas tran vdout1_0ck1010 FIND v(dout1_0) AT=510.025n

.meas tran vdout1_1ck1010 FIND v(dout1_1) AT=510.025n

.meas tran vdout1_2ck1010 FIND v(dout1_2) AT=510.025n

.meas tran vdout1_3ck1010 FIND v(dout1_3) AT=510.025n

.meas tran vdout1_4ck1010 FIND v(dout1_4) AT=510.025n

.meas tran vdout1_5ck1010 FIND v(dout1_5) AT=510.025n

.meas tran vdout1_6ck1010 FIND v(dout1_6) AT=510.025n

.meas tran vdout1_7ck1010 FIND v(dout1_7) AT=510.025n

.meas tran vdout1_8ck1010 FIND v(dout1_8) AT=510.025n

.meas tran vdout1_9ck1010 FIND v(dout1_9) AT=510.025n

.meas tran vdout1_10ck1010 FIND v(dout1_10) AT=510.025n

.meas tran vdout1_11ck1010 FIND v(dout1_11) AT=510.025n

.meas tran vdout1_12ck1010 FIND v(dout1_12) AT=510.025n

.meas tran vdout1_13ck1010 FIND v(dout1_13) AT=510.025n

.meas tran vdout1_14ck1010 FIND v(dout1_14) AT=510.025n

.meas tran vdout1_15ck1010 FIND v(dout1_15) AT=510.025n

.meas tran vdout1_16ck1010 FIND v(dout1_16) AT=510.025n

.meas tran vdout1_17ck1010 FIND v(dout1_17) AT=510.025n

.meas tran vdout1_18ck1010 FIND v(dout1_18) AT=510.025n

.meas tran vdout1_19ck1010 FIND v(dout1_19) AT=510.025n

.meas tran vdout1_20ck1010 FIND v(dout1_20) AT=510.025n

.meas tran vdout1_21ck1010 FIND v(dout1_21) AT=510.025n

.meas tran vdout1_22ck1010 FIND v(dout1_22) AT=510.025n

.meas tran vdout1_23ck1010 FIND v(dout1_23) AT=510.025n

.meas tran vdout1_24ck1010 FIND v(dout1_24) AT=510.025n

.meas tran vdout1_25ck1010 FIND v(dout1_25) AT=510.025n

.meas tran vdout1_26ck1010 FIND v(dout1_26) AT=510.025n

.meas tran vdout1_27ck1010 FIND v(dout1_27) AT=510.025n

.meas tran vdout1_28ck1010 FIND v(dout1_28) AT=510.025n

.meas tran vdout1_29ck1010 FIND v(dout1_29) AT=510.025n

.meas tran vdout1_30ck1010 FIND v(dout1_30) AT=510.025n

.meas tran vdout1_31ck1010 FIND v(dout1_31) AT=510.025n

.meas tran vdout1_32ck1010 FIND v(dout1_32) AT=510.025n

.meas tran vdout1_33ck1010 FIND v(dout1_33) AT=510.025n

.meas tran vdout1_34ck1010 FIND v(dout1_34) AT=510.025n

.meas tran vdout1_35ck1010 FIND v(dout1_35) AT=510.025n

.meas tran vdout1_36ck1010 FIND v(dout1_36) AT=510.025n

.meas tran vdout1_37ck1010 FIND v(dout1_37) AT=510.025n

.meas tran vdout1_38ck1010 FIND v(dout1_38) AT=510.025n

.meas tran vdout1_39ck1010 FIND v(dout1_39) AT=510.025n

.meas tran vdout1_40ck1010 FIND v(dout1_40) AT=510.025n

.meas tran vdout1_41ck1010 FIND v(dout1_41) AT=510.025n

.meas tran vdout1_42ck1010 FIND v(dout1_42) AT=510.025n

.meas tran vdout1_43ck1010 FIND v(dout1_43) AT=510.025n

.meas tran vdout1_44ck1010 FIND v(dout1_44) AT=510.025n

.meas tran vdout1_45ck1010 FIND v(dout1_45) AT=510.025n

.meas tran vdout1_46ck1010 FIND v(dout1_46) AT=510.025n

.meas tran vdout1_47ck1010 FIND v(dout1_47) AT=510.025n

.meas tran vdout1_48ck1010 FIND v(dout1_48) AT=510.025n

.meas tran vdout1_49ck1010 FIND v(dout1_49) AT=510.025n

.meas tran vdout1_50ck1010 FIND v(dout1_50) AT=510.025n

.meas tran vdout1_51ck1010 FIND v(dout1_51) AT=510.025n

.meas tran vdout1_52ck1010 FIND v(dout1_52) AT=510.025n

.meas tran vdout1_53ck1010 FIND v(dout1_53) AT=510.025n

.meas tran vdout1_54ck1010 FIND v(dout1_54) AT=510.025n

.meas tran vdout1_55ck1010 FIND v(dout1_55) AT=510.025n

.meas tran vdout1_56ck1010 FIND v(dout1_56) AT=510.025n

.meas tran vdout1_57ck1010 FIND v(dout1_57) AT=510.025n

.meas tran vdout1_58ck1010 FIND v(dout1_58) AT=510.025n

.meas tran vdout1_59ck1010 FIND v(dout1_59) AT=510.025n

.meas tran vdout1_60ck1010 FIND v(dout1_60) AT=510.025n

.meas tran vdout1_61ck1010 FIND v(dout1_61) AT=510.025n

.meas tran vdout1_62ck1010 FIND v(dout1_62) AT=510.025n

.meas tran vdout1_63ck1010 FIND v(dout1_63) AT=510.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_22ck1060 FIND v(dout1_22) AT=535.025n

.meas tran vdout1_23ck1060 FIND v(dout1_23) AT=535.025n

.meas tran vdout1_24ck1060 FIND v(dout1_24) AT=535.025n

.meas tran vdout1_25ck1060 FIND v(dout1_25) AT=535.025n

.meas tran vdout1_26ck1060 FIND v(dout1_26) AT=535.025n

.meas tran vdout1_27ck1060 FIND v(dout1_27) AT=535.025n

.meas tran vdout1_28ck1060 FIND v(dout1_28) AT=535.025n

.meas tran vdout1_29ck1060 FIND v(dout1_29) AT=535.025n

.meas tran vdout1_30ck1060 FIND v(dout1_30) AT=535.025n

.meas tran vdout1_31ck1060 FIND v(dout1_31) AT=535.025n

.meas tran vdout1_32ck1060 FIND v(dout1_32) AT=535.025n

.meas tran vdout1_33ck1060 FIND v(dout1_33) AT=535.025n

.meas tran vdout1_34ck1060 FIND v(dout1_34) AT=535.025n

.meas tran vdout1_35ck1060 FIND v(dout1_35) AT=535.025n

.meas tran vdout1_36ck1060 FIND v(dout1_36) AT=535.025n

.meas tran vdout1_37ck1060 FIND v(dout1_37) AT=535.025n

.meas tran vdout1_38ck1060 FIND v(dout1_38) AT=535.025n

.meas tran vdout1_39ck1060 FIND v(dout1_39) AT=535.025n

.meas tran vdout1_40ck1060 FIND v(dout1_40) AT=535.025n

.meas tran vdout1_41ck1060 FIND v(dout1_41) AT=535.025n

.meas tran vdout1_42ck1060 FIND v(dout1_42) AT=535.025n

.meas tran vdout1_43ck1060 FIND v(dout1_43) AT=535.025n

.meas tran vdout1_44ck1060 FIND v(dout1_44) AT=535.025n

.meas tran vdout1_45ck1060 FIND v(dout1_45) AT=535.025n

.meas tran vdout1_46ck1060 FIND v(dout1_46) AT=535.025n

.meas tran vdout1_47ck1060 FIND v(dout1_47) AT=535.025n

.meas tran vdout1_48ck1060 FIND v(dout1_48) AT=535.025n

.meas tran vdout1_49ck1060 FIND v(dout1_49) AT=535.025n

.meas tran vdout1_50ck1060 FIND v(dout1_50) AT=535.025n

.meas tran vdout1_51ck1060 FIND v(dout1_51) AT=535.025n

.meas tran vdout1_52ck1060 FIND v(dout1_52) AT=535.025n

.meas tran vdout1_53ck1060 FIND v(dout1_53) AT=535.025n

.meas tran vdout1_54ck1060 FIND v(dout1_54) AT=535.025n

.meas tran vdout1_55ck1060 FIND v(dout1_55) AT=535.025n

.meas tran vdout1_56ck1060 FIND v(dout1_56) AT=535.025n

.meas tran vdout1_57ck1060 FIND v(dout1_57) AT=535.025n

.meas tran vdout1_58ck1060 FIND v(dout1_58) AT=535.025n

.meas tran vdout1_59ck1060 FIND v(dout1_59) AT=535.025n

.meas tran vdout1_60ck1060 FIND v(dout1_60) AT=535.025n

.meas tran vdout1_61ck1060 FIND v(dout1_61) AT=535.025n

.meas tran vdout1_62ck1060 FIND v(dout1_62) AT=535.025n

.meas tran vdout1_63ck1060 FIND v(dout1_63) AT=535.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_23ck1070 FIND v(dout1_23) AT=540.025n

.meas tran vdout1_24ck1070 FIND v(dout1_24) AT=540.025n

.meas tran vdout1_25ck1070 FIND v(dout1_25) AT=540.025n

.meas tran vdout1_26ck1070 FIND v(dout1_26) AT=540.025n

.meas tran vdout1_27ck1070 FIND v(dout1_27) AT=540.025n

.meas tran vdout1_28ck1070 FIND v(dout1_28) AT=540.025n

.meas tran vdout1_29ck1070 FIND v(dout1_29) AT=540.025n

.meas tran vdout1_30ck1070 FIND v(dout1_30) AT=540.025n

.meas tran vdout1_31ck1070 FIND v(dout1_31) AT=540.025n

.meas tran vdout1_32ck1070 FIND v(dout1_32) AT=540.025n

.meas tran vdout1_33ck1070 FIND v(dout1_33) AT=540.025n

.meas tran vdout1_34ck1070 FIND v(dout1_34) AT=540.025n

.meas tran vdout1_35ck1070 FIND v(dout1_35) AT=540.025n

.meas tran vdout1_36ck1070 FIND v(dout1_36) AT=540.025n

.meas tran vdout1_37ck1070 FIND v(dout1_37) AT=540.025n

.meas tran vdout1_38ck1070 FIND v(dout1_38) AT=540.025n

.meas tran vdout1_39ck1070 FIND v(dout1_39) AT=540.025n

.meas tran vdout1_40ck1070 FIND v(dout1_40) AT=540.025n

.meas tran vdout1_41ck1070 FIND v(dout1_41) AT=540.025n

.meas tran vdout1_42ck1070 FIND v(dout1_42) AT=540.025n

.meas tran vdout1_43ck1070 FIND v(dout1_43) AT=540.025n

.meas tran vdout1_44ck1070 FIND v(dout1_44) AT=540.025n

.meas tran vdout1_45ck1070 FIND v(dout1_45) AT=540.025n

.meas tran vdout1_46ck1070 FIND v(dout1_46) AT=540.025n

.meas tran vdout1_47ck1070 FIND v(dout1_47) AT=540.025n

.meas tran vdout1_48ck1070 FIND v(dout1_48) AT=540.025n

.meas tran vdout1_49ck1070 FIND v(dout1_49) AT=540.025n

.meas tran vdout1_50ck1070 FIND v(dout1_50) AT=540.025n

.meas tran vdout1_51ck1070 FIND v(dout1_51) AT=540.025n

.meas tran vdout1_52ck1070 FIND v(dout1_52) AT=540.025n

.meas tran vdout1_53ck1070 FIND v(dout1_53) AT=540.025n

.meas tran vdout1_54ck1070 FIND v(dout1_54) AT=540.025n

.meas tran vdout1_55ck1070 FIND v(dout1_55) AT=540.025n

.meas tran vdout1_56ck1070 FIND v(dout1_56) AT=540.025n

.meas tran vdout1_57ck1070 FIND v(dout1_57) AT=540.025n

.meas tran vdout1_58ck1070 FIND v(dout1_58) AT=540.025n

.meas tran vdout1_59ck1070 FIND v(dout1_59) AT=540.025n

.meas tran vdout1_60ck1070 FIND v(dout1_60) AT=540.025n

.meas tran vdout1_61ck1070 FIND v(dout1_61) AT=540.025n

.meas tran vdout1_62ck1070 FIND v(dout1_62) AT=540.025n

.meas tran vdout1_63ck1070 FIND v(dout1_63) AT=540.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_19ck1080 FIND v(dout1_19) AT=545.025n

.meas tran vdout1_20ck1080 FIND v(dout1_20) AT=545.025n

.meas tran vdout1_21ck1080 FIND v(dout1_21) AT=545.025n

.meas tran vdout1_22ck1080 FIND v(dout1_22) AT=545.025n

.meas tran vdout1_23ck1080 FIND v(dout1_23) AT=545.025n

.meas tran vdout1_24ck1080 FIND v(dout1_24) AT=545.025n

.meas tran vdout1_25ck1080 FIND v(dout1_25) AT=545.025n

.meas tran vdout1_26ck1080 FIND v(dout1_26) AT=545.025n

.meas tran vdout1_27ck1080 FIND v(dout1_27) AT=545.025n

.meas tran vdout1_28ck1080 FIND v(dout1_28) AT=545.025n

.meas tran vdout1_29ck1080 FIND v(dout1_29) AT=545.025n

.meas tran vdout1_30ck1080 FIND v(dout1_30) AT=545.025n

.meas tran vdout1_31ck1080 FIND v(dout1_31) AT=545.025n

.meas tran vdout1_32ck1080 FIND v(dout1_32) AT=545.025n

.meas tran vdout1_33ck1080 FIND v(dout1_33) AT=545.025n

.meas tran vdout1_34ck1080 FIND v(dout1_34) AT=545.025n

.meas tran vdout1_35ck1080 FIND v(dout1_35) AT=545.025n

.meas tran vdout1_36ck1080 FIND v(dout1_36) AT=545.025n

.meas tran vdout1_37ck1080 FIND v(dout1_37) AT=545.025n

.meas tran vdout1_38ck1080 FIND v(dout1_38) AT=545.025n

.meas tran vdout1_39ck1080 FIND v(dout1_39) AT=545.025n

.meas tran vdout1_40ck1080 FIND v(dout1_40) AT=545.025n

.meas tran vdout1_41ck1080 FIND v(dout1_41) AT=545.025n

.meas tran vdout1_42ck1080 FIND v(dout1_42) AT=545.025n

.meas tran vdout1_43ck1080 FIND v(dout1_43) AT=545.025n

.meas tran vdout1_44ck1080 FIND v(dout1_44) AT=545.025n

.meas tran vdout1_45ck1080 FIND v(dout1_45) AT=545.025n

.meas tran vdout1_46ck1080 FIND v(dout1_46) AT=545.025n

.meas tran vdout1_47ck1080 FIND v(dout1_47) AT=545.025n

.meas tran vdout1_48ck1080 FIND v(dout1_48) AT=545.025n

.meas tran vdout1_49ck1080 FIND v(dout1_49) AT=545.025n

.meas tran vdout1_50ck1080 FIND v(dout1_50) AT=545.025n

.meas tran vdout1_51ck1080 FIND v(dout1_51) AT=545.025n

.meas tran vdout1_52ck1080 FIND v(dout1_52) AT=545.025n

.meas tran vdout1_53ck1080 FIND v(dout1_53) AT=545.025n

.meas tran vdout1_54ck1080 FIND v(dout1_54) AT=545.025n

.meas tran vdout1_55ck1080 FIND v(dout1_55) AT=545.025n

.meas tran vdout1_56ck1080 FIND v(dout1_56) AT=545.025n

.meas tran vdout1_57ck1080 FIND v(dout1_57) AT=545.025n

.meas tran vdout1_58ck1080 FIND v(dout1_58) AT=545.025n

.meas tran vdout1_59ck1080 FIND v(dout1_59) AT=545.025n

.meas tran vdout1_60ck1080 FIND v(dout1_60) AT=545.025n

.meas tran vdout1_61ck1080 FIND v(dout1_61) AT=545.025n

.meas tran vdout1_62ck1080 FIND v(dout1_62) AT=545.025n

.meas tran vdout1_63ck1080 FIND v(dout1_63) AT=545.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_23ck1090 FIND v(dout1_23) AT=550.025n

.meas tran vdout1_24ck1090 FIND v(dout1_24) AT=550.025n

.meas tran vdout1_25ck1090 FIND v(dout1_25) AT=550.025n

.meas tran vdout1_26ck1090 FIND v(dout1_26) AT=550.025n

.meas tran vdout1_27ck1090 FIND v(dout1_27) AT=550.025n

.meas tran vdout1_28ck1090 FIND v(dout1_28) AT=550.025n

.meas tran vdout1_29ck1090 FIND v(dout1_29) AT=550.025n

.meas tran vdout1_30ck1090 FIND v(dout1_30) AT=550.025n

.meas tran vdout1_31ck1090 FIND v(dout1_31) AT=550.025n

.meas tran vdout1_32ck1090 FIND v(dout1_32) AT=550.025n

.meas tran vdout1_33ck1090 FIND v(dout1_33) AT=550.025n

.meas tran vdout1_34ck1090 FIND v(dout1_34) AT=550.025n

.meas tran vdout1_35ck1090 FIND v(dout1_35) AT=550.025n

.meas tran vdout1_36ck1090 FIND v(dout1_36) AT=550.025n

.meas tran vdout1_37ck1090 FIND v(dout1_37) AT=550.025n

.meas tran vdout1_38ck1090 FIND v(dout1_38) AT=550.025n

.meas tran vdout1_39ck1090 FIND v(dout1_39) AT=550.025n

.meas tran vdout1_40ck1090 FIND v(dout1_40) AT=550.025n

.meas tran vdout1_41ck1090 FIND v(dout1_41) AT=550.025n

.meas tran vdout1_42ck1090 FIND v(dout1_42) AT=550.025n

.meas tran vdout1_43ck1090 FIND v(dout1_43) AT=550.025n

.meas tran vdout1_44ck1090 FIND v(dout1_44) AT=550.025n

.meas tran vdout1_45ck1090 FIND v(dout1_45) AT=550.025n

.meas tran vdout1_46ck1090 FIND v(dout1_46) AT=550.025n

.meas tran vdout1_47ck1090 FIND v(dout1_47) AT=550.025n

.meas tran vdout1_48ck1090 FIND v(dout1_48) AT=550.025n

.meas tran vdout1_49ck1090 FIND v(dout1_49) AT=550.025n

.meas tran vdout1_50ck1090 FIND v(dout1_50) AT=550.025n

.meas tran vdout1_51ck1090 FIND v(dout1_51) AT=550.025n

.meas tran vdout1_52ck1090 FIND v(dout1_52) AT=550.025n

.meas tran vdout1_53ck1090 FIND v(dout1_53) AT=550.025n

.meas tran vdout1_54ck1090 FIND v(dout1_54) AT=550.025n

.meas tran vdout1_55ck1090 FIND v(dout1_55) AT=550.025n

.meas tran vdout1_56ck1090 FIND v(dout1_56) AT=550.025n

.meas tran vdout1_57ck1090 FIND v(dout1_57) AT=550.025n

.meas tran vdout1_58ck1090 FIND v(dout1_58) AT=550.025n

.meas tran vdout1_59ck1090 FIND v(dout1_59) AT=550.025n

.meas tran vdout1_60ck1090 FIND v(dout1_60) AT=550.025n

.meas tran vdout1_61ck1090 FIND v(dout1_61) AT=550.025n

.meas tran vdout1_62ck1090 FIND v(dout1_62) AT=550.025n

.meas tran vdout1_63ck1090 FIND v(dout1_63) AT=550.025n

.meas tran vdout1_0ck1130 FIND v(dout1_0) AT=570.025n

.meas tran vdout1_1ck1130 FIND v(dout1_1) AT=570.025n

.meas tran vdout1_2ck1130 FIND v(dout1_2) AT=570.025n

.meas tran vdout1_3ck1130 FIND v(dout1_3) AT=570.025n

.meas tran vdout1_4ck1130 FIND v(dout1_4) AT=570.025n

.meas tran vdout1_5ck1130 FIND v(dout1_5) AT=570.025n

.meas tran vdout1_6ck1130 FIND v(dout1_6) AT=570.025n

.meas tran vdout1_7ck1130 FIND v(dout1_7) AT=570.025n

.meas tran vdout1_8ck1130 FIND v(dout1_8) AT=570.025n

.meas tran vdout1_9ck1130 FIND v(dout1_9) AT=570.025n

.meas tran vdout1_10ck1130 FIND v(dout1_10) AT=570.025n

.meas tran vdout1_11ck1130 FIND v(dout1_11) AT=570.025n

.meas tran vdout1_12ck1130 FIND v(dout1_12) AT=570.025n

.meas tran vdout1_13ck1130 FIND v(dout1_13) AT=570.025n

.meas tran vdout1_14ck1130 FIND v(dout1_14) AT=570.025n

.meas tran vdout1_15ck1130 FIND v(dout1_15) AT=570.025n

.meas tran vdout1_16ck1130 FIND v(dout1_16) AT=570.025n

.meas tran vdout1_17ck1130 FIND v(dout1_17) AT=570.025n

.meas tran vdout1_18ck1130 FIND v(dout1_18) AT=570.025n

.meas tran vdout1_19ck1130 FIND v(dout1_19) AT=570.025n

.meas tran vdout1_20ck1130 FIND v(dout1_20) AT=570.025n

.meas tran vdout1_21ck1130 FIND v(dout1_21) AT=570.025n

.meas tran vdout1_22ck1130 FIND v(dout1_22) AT=570.025n

.meas tran vdout1_23ck1130 FIND v(dout1_23) AT=570.025n

.meas tran vdout1_24ck1130 FIND v(dout1_24) AT=570.025n

.meas tran vdout1_25ck1130 FIND v(dout1_25) AT=570.025n

.meas tran vdout1_26ck1130 FIND v(dout1_26) AT=570.025n

.meas tran vdout1_27ck1130 FIND v(dout1_27) AT=570.025n

.meas tran vdout1_28ck1130 FIND v(dout1_28) AT=570.025n

.meas tran vdout1_29ck1130 FIND v(dout1_29) AT=570.025n

.meas tran vdout1_30ck1130 FIND v(dout1_30) AT=570.025n

.meas tran vdout1_31ck1130 FIND v(dout1_31) AT=570.025n

.meas tran vdout1_32ck1130 FIND v(dout1_32) AT=570.025n

.meas tran vdout1_33ck1130 FIND v(dout1_33) AT=570.025n

.meas tran vdout1_34ck1130 FIND v(dout1_34) AT=570.025n

.meas tran vdout1_35ck1130 FIND v(dout1_35) AT=570.025n

.meas tran vdout1_36ck1130 FIND v(dout1_36) AT=570.025n

.meas tran vdout1_37ck1130 FIND v(dout1_37) AT=570.025n

.meas tran vdout1_38ck1130 FIND v(dout1_38) AT=570.025n

.meas tran vdout1_39ck1130 FIND v(dout1_39) AT=570.025n

.meas tran vdout1_40ck1130 FIND v(dout1_40) AT=570.025n

.meas tran vdout1_41ck1130 FIND v(dout1_41) AT=570.025n

.meas tran vdout1_42ck1130 FIND v(dout1_42) AT=570.025n

.meas tran vdout1_43ck1130 FIND v(dout1_43) AT=570.025n

.meas tran vdout1_44ck1130 FIND v(dout1_44) AT=570.025n

.meas tran vdout1_45ck1130 FIND v(dout1_45) AT=570.025n

.meas tran vdout1_46ck1130 FIND v(dout1_46) AT=570.025n

.meas tran vdout1_47ck1130 FIND v(dout1_47) AT=570.025n

.meas tran vdout1_48ck1130 FIND v(dout1_48) AT=570.025n

.meas tran vdout1_49ck1130 FIND v(dout1_49) AT=570.025n

.meas tran vdout1_50ck1130 FIND v(dout1_50) AT=570.025n

.meas tran vdout1_51ck1130 FIND v(dout1_51) AT=570.025n

.meas tran vdout1_52ck1130 FIND v(dout1_52) AT=570.025n

.meas tran vdout1_53ck1130 FIND v(dout1_53) AT=570.025n

.meas tran vdout1_54ck1130 FIND v(dout1_54) AT=570.025n

.meas tran vdout1_55ck1130 FIND v(dout1_55) AT=570.025n

.meas tran vdout1_56ck1130 FIND v(dout1_56) AT=570.025n

.meas tran vdout1_57ck1130 FIND v(dout1_57) AT=570.025n

.meas tran vdout1_58ck1130 FIND v(dout1_58) AT=570.025n

.meas tran vdout1_59ck1130 FIND v(dout1_59) AT=570.025n

.meas tran vdout1_60ck1130 FIND v(dout1_60) AT=570.025n

.meas tran vdout1_61ck1130 FIND v(dout1_61) AT=570.025n

.meas tran vdout1_62ck1130 FIND v(dout1_62) AT=570.025n

.meas tran vdout1_63ck1130 FIND v(dout1_63) AT=570.025n

.meas tran vdout1_0ck1140 FIND v(dout1_0) AT=575.025n

.meas tran vdout1_1ck1140 FIND v(dout1_1) AT=575.025n

.meas tran vdout1_2ck1140 FIND v(dout1_2) AT=575.025n

.meas tran vdout1_3ck1140 FIND v(dout1_3) AT=575.025n

.meas tran vdout1_4ck1140 FIND v(dout1_4) AT=575.025n

.meas tran vdout1_5ck1140 FIND v(dout1_5) AT=575.025n

.meas tran vdout1_6ck1140 FIND v(dout1_6) AT=575.025n

.meas tran vdout1_7ck1140 FIND v(dout1_7) AT=575.025n

.meas tran vdout1_8ck1140 FIND v(dout1_8) AT=575.025n

.meas tran vdout1_9ck1140 FIND v(dout1_9) AT=575.025n

.meas tran vdout1_10ck1140 FIND v(dout1_10) AT=575.025n

.meas tran vdout1_11ck1140 FIND v(dout1_11) AT=575.025n

.meas tran vdout1_12ck1140 FIND v(dout1_12) AT=575.025n

.meas tran vdout1_13ck1140 FIND v(dout1_13) AT=575.025n

.meas tran vdout1_14ck1140 FIND v(dout1_14) AT=575.025n

.meas tran vdout1_15ck1140 FIND v(dout1_15) AT=575.025n

.meas tran vdout1_16ck1140 FIND v(dout1_16) AT=575.025n

.meas tran vdout1_17ck1140 FIND v(dout1_17) AT=575.025n

.meas tran vdout1_18ck1140 FIND v(dout1_18) AT=575.025n

.meas tran vdout1_19ck1140 FIND v(dout1_19) AT=575.025n

.meas tran vdout1_20ck1140 FIND v(dout1_20) AT=575.025n

.meas tran vdout1_21ck1140 FIND v(dout1_21) AT=575.025n

.meas tran vdout1_22ck1140 FIND v(dout1_22) AT=575.025n

.meas tran vdout1_23ck1140 FIND v(dout1_23) AT=575.025n

.meas tran vdout1_24ck1140 FIND v(dout1_24) AT=575.025n

.meas tran vdout1_25ck1140 FIND v(dout1_25) AT=575.025n

.meas tran vdout1_26ck1140 FIND v(dout1_26) AT=575.025n

.meas tran vdout1_27ck1140 FIND v(dout1_27) AT=575.025n

.meas tran vdout1_28ck1140 FIND v(dout1_28) AT=575.025n

.meas tran vdout1_29ck1140 FIND v(dout1_29) AT=575.025n

.meas tran vdout1_30ck1140 FIND v(dout1_30) AT=575.025n

.meas tran vdout1_31ck1140 FIND v(dout1_31) AT=575.025n

.meas tran vdout1_32ck1140 FIND v(dout1_32) AT=575.025n

.meas tran vdout1_33ck1140 FIND v(dout1_33) AT=575.025n

.meas tran vdout1_34ck1140 FIND v(dout1_34) AT=575.025n

.meas tran vdout1_35ck1140 FIND v(dout1_35) AT=575.025n

.meas tran vdout1_36ck1140 FIND v(dout1_36) AT=575.025n

.meas tran vdout1_37ck1140 FIND v(dout1_37) AT=575.025n

.meas tran vdout1_38ck1140 FIND v(dout1_38) AT=575.025n

.meas tran vdout1_39ck1140 FIND v(dout1_39) AT=575.025n

.meas tran vdout1_40ck1140 FIND v(dout1_40) AT=575.025n

.meas tran vdout1_41ck1140 FIND v(dout1_41) AT=575.025n

.meas tran vdout1_42ck1140 FIND v(dout1_42) AT=575.025n

.meas tran vdout1_43ck1140 FIND v(dout1_43) AT=575.025n

.meas tran vdout1_44ck1140 FIND v(dout1_44) AT=575.025n

.meas tran vdout1_45ck1140 FIND v(dout1_45) AT=575.025n

.meas tran vdout1_46ck1140 FIND v(dout1_46) AT=575.025n

.meas tran vdout1_47ck1140 FIND v(dout1_47) AT=575.025n

.meas tran vdout1_48ck1140 FIND v(dout1_48) AT=575.025n

.meas tran vdout1_49ck1140 FIND v(dout1_49) AT=575.025n

.meas tran vdout1_50ck1140 FIND v(dout1_50) AT=575.025n

.meas tran vdout1_51ck1140 FIND v(dout1_51) AT=575.025n

.meas tran vdout1_52ck1140 FIND v(dout1_52) AT=575.025n

.meas tran vdout1_53ck1140 FIND v(dout1_53) AT=575.025n

.meas tran vdout1_54ck1140 FIND v(dout1_54) AT=575.025n

.meas tran vdout1_55ck1140 FIND v(dout1_55) AT=575.025n

.meas tran vdout1_56ck1140 FIND v(dout1_56) AT=575.025n

.meas tran vdout1_57ck1140 FIND v(dout1_57) AT=575.025n

.meas tran vdout1_58ck1140 FIND v(dout1_58) AT=575.025n

.meas tran vdout1_59ck1140 FIND v(dout1_59) AT=575.025n

.meas tran vdout1_60ck1140 FIND v(dout1_60) AT=575.025n

.meas tran vdout1_61ck1140 FIND v(dout1_61) AT=575.025n

.meas tran vdout1_62ck1140 FIND v(dout1_62) AT=575.025n

.meas tran vdout1_63ck1140 FIND v(dout1_63) AT=575.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_16ck1170 FIND v(dout1_16) AT=590.025n

.meas tran vdout1_17ck1170 FIND v(dout1_17) AT=590.025n

.meas tran vdout1_18ck1170 FIND v(dout1_18) AT=590.025n

.meas tran vdout1_19ck1170 FIND v(dout1_19) AT=590.025n

.meas tran vdout1_20ck1170 FIND v(dout1_20) AT=590.025n

.meas tran vdout1_21ck1170 FIND v(dout1_21) AT=590.025n

.meas tran vdout1_22ck1170 FIND v(dout1_22) AT=590.025n

.meas tran vdout1_23ck1170 FIND v(dout1_23) AT=590.025n

.meas tran vdout1_24ck1170 FIND v(dout1_24) AT=590.025n

.meas tran vdout1_25ck1170 FIND v(dout1_25) AT=590.025n

.meas tran vdout1_26ck1170 FIND v(dout1_26) AT=590.025n

.meas tran vdout1_27ck1170 FIND v(dout1_27) AT=590.025n

.meas tran vdout1_28ck1170 FIND v(dout1_28) AT=590.025n

.meas tran vdout1_29ck1170 FIND v(dout1_29) AT=590.025n

.meas tran vdout1_30ck1170 FIND v(dout1_30) AT=590.025n

.meas tran vdout1_31ck1170 FIND v(dout1_31) AT=590.025n

.meas tran vdout1_32ck1170 FIND v(dout1_32) AT=590.025n

.meas tran vdout1_33ck1170 FIND v(dout1_33) AT=590.025n

.meas tran vdout1_34ck1170 FIND v(dout1_34) AT=590.025n

.meas tran vdout1_35ck1170 FIND v(dout1_35) AT=590.025n

.meas tran vdout1_36ck1170 FIND v(dout1_36) AT=590.025n

.meas tran vdout1_37ck1170 FIND v(dout1_37) AT=590.025n

.meas tran vdout1_38ck1170 FIND v(dout1_38) AT=590.025n

.meas tran vdout1_39ck1170 FIND v(dout1_39) AT=590.025n

.meas tran vdout1_40ck1170 FIND v(dout1_40) AT=590.025n

.meas tran vdout1_41ck1170 FIND v(dout1_41) AT=590.025n

.meas tran vdout1_42ck1170 FIND v(dout1_42) AT=590.025n

.meas tran vdout1_43ck1170 FIND v(dout1_43) AT=590.025n

.meas tran vdout1_44ck1170 FIND v(dout1_44) AT=590.025n

.meas tran vdout1_45ck1170 FIND v(dout1_45) AT=590.025n

.meas tran vdout1_46ck1170 FIND v(dout1_46) AT=590.025n

.meas tran vdout1_47ck1170 FIND v(dout1_47) AT=590.025n

.meas tran vdout1_48ck1170 FIND v(dout1_48) AT=590.025n

.meas tran vdout1_49ck1170 FIND v(dout1_49) AT=590.025n

.meas tran vdout1_50ck1170 FIND v(dout1_50) AT=590.025n

.meas tran vdout1_51ck1170 FIND v(dout1_51) AT=590.025n

.meas tran vdout1_52ck1170 FIND v(dout1_52) AT=590.025n

.meas tran vdout1_53ck1170 FIND v(dout1_53) AT=590.025n

.meas tran vdout1_54ck1170 FIND v(dout1_54) AT=590.025n

.meas tran vdout1_55ck1170 FIND v(dout1_55) AT=590.025n

.meas tran vdout1_56ck1170 FIND v(dout1_56) AT=590.025n

.meas tran vdout1_57ck1170 FIND v(dout1_57) AT=590.025n

.meas tran vdout1_58ck1170 FIND v(dout1_58) AT=590.025n

.meas tran vdout1_59ck1170 FIND v(dout1_59) AT=590.025n

.meas tran vdout1_60ck1170 FIND v(dout1_60) AT=590.025n

.meas tran vdout1_61ck1170 FIND v(dout1_61) AT=590.025n

.meas tran vdout1_62ck1170 FIND v(dout1_62) AT=590.025n

.meas tran vdout1_63ck1170 FIND v(dout1_63) AT=590.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_8ck1180 FIND v(dout1_8) AT=595.025n

.meas tran vdout1_9ck1180 FIND v(dout1_9) AT=595.025n

.meas tran vdout1_10ck1180 FIND v(dout1_10) AT=595.025n

.meas tran vdout1_11ck1180 FIND v(dout1_11) AT=595.025n

.meas tran vdout1_12ck1180 FIND v(dout1_12) AT=595.025n

.meas tran vdout1_13ck1180 FIND v(dout1_13) AT=595.025n

.meas tran vdout1_14ck1180 FIND v(dout1_14) AT=595.025n

.meas tran vdout1_15ck1180 FIND v(dout1_15) AT=595.025n

.meas tran vdout1_16ck1180 FIND v(dout1_16) AT=595.025n

.meas tran vdout1_17ck1180 FIND v(dout1_17) AT=595.025n

.meas tran vdout1_18ck1180 FIND v(dout1_18) AT=595.025n

.meas tran vdout1_19ck1180 FIND v(dout1_19) AT=595.025n

.meas tran vdout1_20ck1180 FIND v(dout1_20) AT=595.025n

.meas tran vdout1_21ck1180 FIND v(dout1_21) AT=595.025n

.meas tran vdout1_22ck1180 FIND v(dout1_22) AT=595.025n

.meas tran vdout1_23ck1180 FIND v(dout1_23) AT=595.025n

.meas tran vdout1_24ck1180 FIND v(dout1_24) AT=595.025n

.meas tran vdout1_25ck1180 FIND v(dout1_25) AT=595.025n

.meas tran vdout1_26ck1180 FIND v(dout1_26) AT=595.025n

.meas tran vdout1_27ck1180 FIND v(dout1_27) AT=595.025n

.meas tran vdout1_28ck1180 FIND v(dout1_28) AT=595.025n

.meas tran vdout1_29ck1180 FIND v(dout1_29) AT=595.025n

.meas tran vdout1_30ck1180 FIND v(dout1_30) AT=595.025n

.meas tran vdout1_31ck1180 FIND v(dout1_31) AT=595.025n

.meas tran vdout1_32ck1180 FIND v(dout1_32) AT=595.025n

.meas tran vdout1_33ck1180 FIND v(dout1_33) AT=595.025n

.meas tran vdout1_34ck1180 FIND v(dout1_34) AT=595.025n

.meas tran vdout1_35ck1180 FIND v(dout1_35) AT=595.025n

.meas tran vdout1_36ck1180 FIND v(dout1_36) AT=595.025n

.meas tran vdout1_37ck1180 FIND v(dout1_37) AT=595.025n

.meas tran vdout1_38ck1180 FIND v(dout1_38) AT=595.025n

.meas tran vdout1_39ck1180 FIND v(dout1_39) AT=595.025n

.meas tran vdout1_40ck1180 FIND v(dout1_40) AT=595.025n

.meas tran vdout1_41ck1180 FIND v(dout1_41) AT=595.025n

.meas tran vdout1_42ck1180 FIND v(dout1_42) AT=595.025n

.meas tran vdout1_43ck1180 FIND v(dout1_43) AT=595.025n

.meas tran vdout1_44ck1180 FIND v(dout1_44) AT=595.025n

.meas tran vdout1_45ck1180 FIND v(dout1_45) AT=595.025n

.meas tran vdout1_46ck1180 FIND v(dout1_46) AT=595.025n

.meas tran vdout1_47ck1180 FIND v(dout1_47) AT=595.025n

.meas tran vdout1_48ck1180 FIND v(dout1_48) AT=595.025n

.meas tran vdout1_49ck1180 FIND v(dout1_49) AT=595.025n

.meas tran vdout1_50ck1180 FIND v(dout1_50) AT=595.025n

.meas tran vdout1_51ck1180 FIND v(dout1_51) AT=595.025n

.meas tran vdout1_52ck1180 FIND v(dout1_52) AT=595.025n

.meas tran vdout1_53ck1180 FIND v(dout1_53) AT=595.025n

.meas tran vdout1_54ck1180 FIND v(dout1_54) AT=595.025n

.meas tran vdout1_55ck1180 FIND v(dout1_55) AT=595.025n

.meas tran vdout1_56ck1180 FIND v(dout1_56) AT=595.025n

.meas tran vdout1_57ck1180 FIND v(dout1_57) AT=595.025n

.meas tran vdout1_58ck1180 FIND v(dout1_58) AT=595.025n

.meas tran vdout1_59ck1180 FIND v(dout1_59) AT=595.025n

.meas tran vdout1_60ck1180 FIND v(dout1_60) AT=595.025n

.meas tran vdout1_61ck1180 FIND v(dout1_61) AT=595.025n

.meas tran vdout1_62ck1180 FIND v(dout1_62) AT=595.025n

.meas tran vdout1_63ck1180 FIND v(dout1_63) AT=595.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_16ck1190 FIND v(dout1_16) AT=600.025n

.meas tran vdout1_17ck1190 FIND v(dout1_17) AT=600.025n

.meas tran vdout1_18ck1190 FIND v(dout1_18) AT=600.025n

.meas tran vdout1_19ck1190 FIND v(dout1_19) AT=600.025n

.meas tran vdout1_20ck1190 FIND v(dout1_20) AT=600.025n

.meas tran vdout1_21ck1190 FIND v(dout1_21) AT=600.025n

.meas tran vdout1_22ck1190 FIND v(dout1_22) AT=600.025n

.meas tran vdout1_23ck1190 FIND v(dout1_23) AT=600.025n

.meas tran vdout1_24ck1190 FIND v(dout1_24) AT=600.025n

.meas tran vdout1_25ck1190 FIND v(dout1_25) AT=600.025n

.meas tran vdout1_26ck1190 FIND v(dout1_26) AT=600.025n

.meas tran vdout1_27ck1190 FIND v(dout1_27) AT=600.025n

.meas tran vdout1_28ck1190 FIND v(dout1_28) AT=600.025n

.meas tran vdout1_29ck1190 FIND v(dout1_29) AT=600.025n

.meas tran vdout1_30ck1190 FIND v(dout1_30) AT=600.025n

.meas tran vdout1_31ck1190 FIND v(dout1_31) AT=600.025n

.meas tran vdout1_32ck1190 FIND v(dout1_32) AT=600.025n

.meas tran vdout1_33ck1190 FIND v(dout1_33) AT=600.025n

.meas tran vdout1_34ck1190 FIND v(dout1_34) AT=600.025n

.meas tran vdout1_35ck1190 FIND v(dout1_35) AT=600.025n

.meas tran vdout1_36ck1190 FIND v(dout1_36) AT=600.025n

.meas tran vdout1_37ck1190 FIND v(dout1_37) AT=600.025n

.meas tran vdout1_38ck1190 FIND v(dout1_38) AT=600.025n

.meas tran vdout1_39ck1190 FIND v(dout1_39) AT=600.025n

.meas tran vdout1_40ck1190 FIND v(dout1_40) AT=600.025n

.meas tran vdout1_41ck1190 FIND v(dout1_41) AT=600.025n

.meas tran vdout1_42ck1190 FIND v(dout1_42) AT=600.025n

.meas tran vdout1_43ck1190 FIND v(dout1_43) AT=600.025n

.meas tran vdout1_44ck1190 FIND v(dout1_44) AT=600.025n

.meas tran vdout1_45ck1190 FIND v(dout1_45) AT=600.025n

.meas tran vdout1_46ck1190 FIND v(dout1_46) AT=600.025n

.meas tran vdout1_47ck1190 FIND v(dout1_47) AT=600.025n

.meas tran vdout1_48ck1190 FIND v(dout1_48) AT=600.025n

.meas tran vdout1_49ck1190 FIND v(dout1_49) AT=600.025n

.meas tran vdout1_50ck1190 FIND v(dout1_50) AT=600.025n

.meas tran vdout1_51ck1190 FIND v(dout1_51) AT=600.025n

.meas tran vdout1_52ck1190 FIND v(dout1_52) AT=600.025n

.meas tran vdout1_53ck1190 FIND v(dout1_53) AT=600.025n

.meas tran vdout1_54ck1190 FIND v(dout1_54) AT=600.025n

.meas tran vdout1_55ck1190 FIND v(dout1_55) AT=600.025n

.meas tran vdout1_56ck1190 FIND v(dout1_56) AT=600.025n

.meas tran vdout1_57ck1190 FIND v(dout1_57) AT=600.025n

.meas tran vdout1_58ck1190 FIND v(dout1_58) AT=600.025n

.meas tran vdout1_59ck1190 FIND v(dout1_59) AT=600.025n

.meas tran vdout1_60ck1190 FIND v(dout1_60) AT=600.025n

.meas tran vdout1_61ck1190 FIND v(dout1_61) AT=600.025n

.meas tran vdout1_62ck1190 FIND v(dout1_62) AT=600.025n

.meas tran vdout1_63ck1190 FIND v(dout1_63) AT=600.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_22ck1220 FIND v(dout1_22) AT=615.025n

.meas tran vdout1_23ck1220 FIND v(dout1_23) AT=615.025n

.meas tran vdout1_24ck1220 FIND v(dout1_24) AT=615.025n

.meas tran vdout1_25ck1220 FIND v(dout1_25) AT=615.025n

.meas tran vdout1_26ck1220 FIND v(dout1_26) AT=615.025n

.meas tran vdout1_27ck1220 FIND v(dout1_27) AT=615.025n

.meas tran vdout1_28ck1220 FIND v(dout1_28) AT=615.025n

.meas tran vdout1_29ck1220 FIND v(dout1_29) AT=615.025n

.meas tran vdout1_30ck1220 FIND v(dout1_30) AT=615.025n

.meas tran vdout1_31ck1220 FIND v(dout1_31) AT=615.025n

.meas tran vdout1_32ck1220 FIND v(dout1_32) AT=615.025n

.meas tran vdout1_33ck1220 FIND v(dout1_33) AT=615.025n

.meas tran vdout1_34ck1220 FIND v(dout1_34) AT=615.025n

.meas tran vdout1_35ck1220 FIND v(dout1_35) AT=615.025n

.meas tran vdout1_36ck1220 FIND v(dout1_36) AT=615.025n

.meas tran vdout1_37ck1220 FIND v(dout1_37) AT=615.025n

.meas tran vdout1_38ck1220 FIND v(dout1_38) AT=615.025n

.meas tran vdout1_39ck1220 FIND v(dout1_39) AT=615.025n

.meas tran vdout1_40ck1220 FIND v(dout1_40) AT=615.025n

.meas tran vdout1_41ck1220 FIND v(dout1_41) AT=615.025n

.meas tran vdout1_42ck1220 FIND v(dout1_42) AT=615.025n

.meas tran vdout1_43ck1220 FIND v(dout1_43) AT=615.025n

.meas tran vdout1_44ck1220 FIND v(dout1_44) AT=615.025n

.meas tran vdout1_45ck1220 FIND v(dout1_45) AT=615.025n

.meas tran vdout1_46ck1220 FIND v(dout1_46) AT=615.025n

.meas tran vdout1_47ck1220 FIND v(dout1_47) AT=615.025n

.meas tran vdout1_48ck1220 FIND v(dout1_48) AT=615.025n

.meas tran vdout1_49ck1220 FIND v(dout1_49) AT=615.025n

.meas tran vdout1_50ck1220 FIND v(dout1_50) AT=615.025n

.meas tran vdout1_51ck1220 FIND v(dout1_51) AT=615.025n

.meas tran vdout1_52ck1220 FIND v(dout1_52) AT=615.025n

.meas tran vdout1_53ck1220 FIND v(dout1_53) AT=615.025n

.meas tran vdout1_54ck1220 FIND v(dout1_54) AT=615.025n

.meas tran vdout1_55ck1220 FIND v(dout1_55) AT=615.025n

.meas tran vdout1_56ck1220 FIND v(dout1_56) AT=615.025n

.meas tran vdout1_57ck1220 FIND v(dout1_57) AT=615.025n

.meas tran vdout1_58ck1220 FIND v(dout1_58) AT=615.025n

.meas tran vdout1_59ck1220 FIND v(dout1_59) AT=615.025n

.meas tran vdout1_60ck1220 FIND v(dout1_60) AT=615.025n

.meas tran vdout1_61ck1220 FIND v(dout1_61) AT=615.025n

.meas tran vdout1_62ck1220 FIND v(dout1_62) AT=615.025n

.meas tran vdout1_63ck1220 FIND v(dout1_63) AT=615.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_8ck1270 FIND v(dout1_8) AT=640.025n

.meas tran vdout1_9ck1270 FIND v(dout1_9) AT=640.025n

.meas tran vdout1_10ck1270 FIND v(dout1_10) AT=640.025n

.meas tran vdout1_11ck1270 FIND v(dout1_11) AT=640.025n

.meas tran vdout1_12ck1270 FIND v(dout1_12) AT=640.025n

.meas tran vdout1_13ck1270 FIND v(dout1_13) AT=640.025n

.meas tran vdout1_14ck1270 FIND v(dout1_14) AT=640.025n

.meas tran vdout1_15ck1270 FIND v(dout1_15) AT=640.025n

.meas tran vdout1_16ck1270 FIND v(dout1_16) AT=640.025n

.meas tran vdout1_17ck1270 FIND v(dout1_17) AT=640.025n

.meas tran vdout1_18ck1270 FIND v(dout1_18) AT=640.025n

.meas tran vdout1_19ck1270 FIND v(dout1_19) AT=640.025n

.meas tran vdout1_20ck1270 FIND v(dout1_20) AT=640.025n

.meas tran vdout1_21ck1270 FIND v(dout1_21) AT=640.025n

.meas tran vdout1_22ck1270 FIND v(dout1_22) AT=640.025n

.meas tran vdout1_23ck1270 FIND v(dout1_23) AT=640.025n

.meas tran vdout1_24ck1270 FIND v(dout1_24) AT=640.025n

.meas tran vdout1_25ck1270 FIND v(dout1_25) AT=640.025n

.meas tran vdout1_26ck1270 FIND v(dout1_26) AT=640.025n

.meas tran vdout1_27ck1270 FIND v(dout1_27) AT=640.025n

.meas tran vdout1_28ck1270 FIND v(dout1_28) AT=640.025n

.meas tran vdout1_29ck1270 FIND v(dout1_29) AT=640.025n

.meas tran vdout1_30ck1270 FIND v(dout1_30) AT=640.025n

.meas tran vdout1_31ck1270 FIND v(dout1_31) AT=640.025n

.meas tran vdout1_32ck1270 FIND v(dout1_32) AT=640.025n

.meas tran vdout1_33ck1270 FIND v(dout1_33) AT=640.025n

.meas tran vdout1_34ck1270 FIND v(dout1_34) AT=640.025n

.meas tran vdout1_35ck1270 FIND v(dout1_35) AT=640.025n

.meas tran vdout1_36ck1270 FIND v(dout1_36) AT=640.025n

.meas tran vdout1_37ck1270 FIND v(dout1_37) AT=640.025n

.meas tran vdout1_38ck1270 FIND v(dout1_38) AT=640.025n

.meas tran vdout1_39ck1270 FIND v(dout1_39) AT=640.025n

.meas tran vdout1_40ck1270 FIND v(dout1_40) AT=640.025n

.meas tran vdout1_41ck1270 FIND v(dout1_41) AT=640.025n

.meas tran vdout1_42ck1270 FIND v(dout1_42) AT=640.025n

.meas tran vdout1_43ck1270 FIND v(dout1_43) AT=640.025n

.meas tran vdout1_44ck1270 FIND v(dout1_44) AT=640.025n

.meas tran vdout1_45ck1270 FIND v(dout1_45) AT=640.025n

.meas tran vdout1_46ck1270 FIND v(dout1_46) AT=640.025n

.meas tran vdout1_47ck1270 FIND v(dout1_47) AT=640.025n

.meas tran vdout1_48ck1270 FIND v(dout1_48) AT=640.025n

.meas tran vdout1_49ck1270 FIND v(dout1_49) AT=640.025n

.meas tran vdout1_50ck1270 FIND v(dout1_50) AT=640.025n

.meas tran vdout1_51ck1270 FIND v(dout1_51) AT=640.025n

.meas tran vdout1_52ck1270 FIND v(dout1_52) AT=640.025n

.meas tran vdout1_53ck1270 FIND v(dout1_53) AT=640.025n

.meas tran vdout1_54ck1270 FIND v(dout1_54) AT=640.025n

.meas tran vdout1_55ck1270 FIND v(dout1_55) AT=640.025n

.meas tran vdout1_56ck1270 FIND v(dout1_56) AT=640.025n

.meas tran vdout1_57ck1270 FIND v(dout1_57) AT=640.025n

.meas tran vdout1_58ck1270 FIND v(dout1_58) AT=640.025n

.meas tran vdout1_59ck1270 FIND v(dout1_59) AT=640.025n

.meas tran vdout1_60ck1270 FIND v(dout1_60) AT=640.025n

.meas tran vdout1_61ck1270 FIND v(dout1_61) AT=640.025n

.meas tran vdout1_62ck1270 FIND v(dout1_62) AT=640.025n

.meas tran vdout1_63ck1270 FIND v(dout1_63) AT=640.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_22ck1280 FIND v(dout1_22) AT=645.025n

.meas tran vdout1_23ck1280 FIND v(dout1_23) AT=645.025n

.meas tran vdout1_24ck1280 FIND v(dout1_24) AT=645.025n

.meas tran vdout1_25ck1280 FIND v(dout1_25) AT=645.025n

.meas tran vdout1_26ck1280 FIND v(dout1_26) AT=645.025n

.meas tran vdout1_27ck1280 FIND v(dout1_27) AT=645.025n

.meas tran vdout1_28ck1280 FIND v(dout1_28) AT=645.025n

.meas tran vdout1_29ck1280 FIND v(dout1_29) AT=645.025n

.meas tran vdout1_30ck1280 FIND v(dout1_30) AT=645.025n

.meas tran vdout1_31ck1280 FIND v(dout1_31) AT=645.025n

.meas tran vdout1_32ck1280 FIND v(dout1_32) AT=645.025n

.meas tran vdout1_33ck1280 FIND v(dout1_33) AT=645.025n

.meas tran vdout1_34ck1280 FIND v(dout1_34) AT=645.025n

.meas tran vdout1_35ck1280 FIND v(dout1_35) AT=645.025n

.meas tran vdout1_36ck1280 FIND v(dout1_36) AT=645.025n

.meas tran vdout1_37ck1280 FIND v(dout1_37) AT=645.025n

.meas tran vdout1_38ck1280 FIND v(dout1_38) AT=645.025n

.meas tran vdout1_39ck1280 FIND v(dout1_39) AT=645.025n

.meas tran vdout1_40ck1280 FIND v(dout1_40) AT=645.025n

.meas tran vdout1_41ck1280 FIND v(dout1_41) AT=645.025n

.meas tran vdout1_42ck1280 FIND v(dout1_42) AT=645.025n

.meas tran vdout1_43ck1280 FIND v(dout1_43) AT=645.025n

.meas tran vdout1_44ck1280 FIND v(dout1_44) AT=645.025n

.meas tran vdout1_45ck1280 FIND v(dout1_45) AT=645.025n

.meas tran vdout1_46ck1280 FIND v(dout1_46) AT=645.025n

.meas tran vdout1_47ck1280 FIND v(dout1_47) AT=645.025n

.meas tran vdout1_48ck1280 FIND v(dout1_48) AT=645.025n

.meas tran vdout1_49ck1280 FIND v(dout1_49) AT=645.025n

.meas tran vdout1_50ck1280 FIND v(dout1_50) AT=645.025n

.meas tran vdout1_51ck1280 FIND v(dout1_51) AT=645.025n

.meas tran vdout1_52ck1280 FIND v(dout1_52) AT=645.025n

.meas tran vdout1_53ck1280 FIND v(dout1_53) AT=645.025n

.meas tran vdout1_54ck1280 FIND v(dout1_54) AT=645.025n

.meas tran vdout1_55ck1280 FIND v(dout1_55) AT=645.025n

.meas tran vdout1_56ck1280 FIND v(dout1_56) AT=645.025n

.meas tran vdout1_57ck1280 FIND v(dout1_57) AT=645.025n

.meas tran vdout1_58ck1280 FIND v(dout1_58) AT=645.025n

.meas tran vdout1_59ck1280 FIND v(dout1_59) AT=645.025n

.meas tran vdout1_60ck1280 FIND v(dout1_60) AT=645.025n

.meas tran vdout1_61ck1280 FIND v(dout1_61) AT=645.025n

.meas tran vdout1_62ck1280 FIND v(dout1_62) AT=645.025n

.meas tran vdout1_63ck1280 FIND v(dout1_63) AT=645.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_22ck1300 FIND v(dout1_22) AT=655.025n

.meas tran vdout1_23ck1300 FIND v(dout1_23) AT=655.025n

.meas tran vdout1_24ck1300 FIND v(dout1_24) AT=655.025n

.meas tran vdout1_25ck1300 FIND v(dout1_25) AT=655.025n

.meas tran vdout1_26ck1300 FIND v(dout1_26) AT=655.025n

.meas tran vdout1_27ck1300 FIND v(dout1_27) AT=655.025n

.meas tran vdout1_28ck1300 FIND v(dout1_28) AT=655.025n

.meas tran vdout1_29ck1300 FIND v(dout1_29) AT=655.025n

.meas tran vdout1_30ck1300 FIND v(dout1_30) AT=655.025n

.meas tran vdout1_31ck1300 FIND v(dout1_31) AT=655.025n

.meas tran vdout1_32ck1300 FIND v(dout1_32) AT=655.025n

.meas tran vdout1_33ck1300 FIND v(dout1_33) AT=655.025n

.meas tran vdout1_34ck1300 FIND v(dout1_34) AT=655.025n

.meas tran vdout1_35ck1300 FIND v(dout1_35) AT=655.025n

.meas tran vdout1_36ck1300 FIND v(dout1_36) AT=655.025n

.meas tran vdout1_37ck1300 FIND v(dout1_37) AT=655.025n

.meas tran vdout1_38ck1300 FIND v(dout1_38) AT=655.025n

.meas tran vdout1_39ck1300 FIND v(dout1_39) AT=655.025n

.meas tran vdout1_40ck1300 FIND v(dout1_40) AT=655.025n

.meas tran vdout1_41ck1300 FIND v(dout1_41) AT=655.025n

.meas tran vdout1_42ck1300 FIND v(dout1_42) AT=655.025n

.meas tran vdout1_43ck1300 FIND v(dout1_43) AT=655.025n

.meas tran vdout1_44ck1300 FIND v(dout1_44) AT=655.025n

.meas tran vdout1_45ck1300 FIND v(dout1_45) AT=655.025n

.meas tran vdout1_46ck1300 FIND v(dout1_46) AT=655.025n

.meas tran vdout1_47ck1300 FIND v(dout1_47) AT=655.025n

.meas tran vdout1_48ck1300 FIND v(dout1_48) AT=655.025n

.meas tran vdout1_49ck1300 FIND v(dout1_49) AT=655.025n

.meas tran vdout1_50ck1300 FIND v(dout1_50) AT=655.025n

.meas tran vdout1_51ck1300 FIND v(dout1_51) AT=655.025n

.meas tran vdout1_52ck1300 FIND v(dout1_52) AT=655.025n

.meas tran vdout1_53ck1300 FIND v(dout1_53) AT=655.025n

.meas tran vdout1_54ck1300 FIND v(dout1_54) AT=655.025n

.meas tran vdout1_55ck1300 FIND v(dout1_55) AT=655.025n

.meas tran vdout1_56ck1300 FIND v(dout1_56) AT=655.025n

.meas tran vdout1_57ck1300 FIND v(dout1_57) AT=655.025n

.meas tran vdout1_58ck1300 FIND v(dout1_58) AT=655.025n

.meas tran vdout1_59ck1300 FIND v(dout1_59) AT=655.025n

.meas tran vdout1_60ck1300 FIND v(dout1_60) AT=655.025n

.meas tran vdout1_61ck1300 FIND v(dout1_61) AT=655.025n

.meas tran vdout1_62ck1300 FIND v(dout1_62) AT=655.025n

.meas tran vdout1_63ck1300 FIND v(dout1_63) AT=655.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_22ck1320 FIND v(dout1_22) AT=665.025n

.meas tran vdout1_23ck1320 FIND v(dout1_23) AT=665.025n

.meas tran vdout1_24ck1320 FIND v(dout1_24) AT=665.025n

.meas tran vdout1_25ck1320 FIND v(dout1_25) AT=665.025n

.meas tran vdout1_26ck1320 FIND v(dout1_26) AT=665.025n

.meas tran vdout1_27ck1320 FIND v(dout1_27) AT=665.025n

.meas tran vdout1_28ck1320 FIND v(dout1_28) AT=665.025n

.meas tran vdout1_29ck1320 FIND v(dout1_29) AT=665.025n

.meas tran vdout1_30ck1320 FIND v(dout1_30) AT=665.025n

.meas tran vdout1_31ck1320 FIND v(dout1_31) AT=665.025n

.meas tran vdout1_32ck1320 FIND v(dout1_32) AT=665.025n

.meas tran vdout1_33ck1320 FIND v(dout1_33) AT=665.025n

.meas tran vdout1_34ck1320 FIND v(dout1_34) AT=665.025n

.meas tran vdout1_35ck1320 FIND v(dout1_35) AT=665.025n

.meas tran vdout1_36ck1320 FIND v(dout1_36) AT=665.025n

.meas tran vdout1_37ck1320 FIND v(dout1_37) AT=665.025n

.meas tran vdout1_38ck1320 FIND v(dout1_38) AT=665.025n

.meas tran vdout1_39ck1320 FIND v(dout1_39) AT=665.025n

.meas tran vdout1_40ck1320 FIND v(dout1_40) AT=665.025n

.meas tran vdout1_41ck1320 FIND v(dout1_41) AT=665.025n

.meas tran vdout1_42ck1320 FIND v(dout1_42) AT=665.025n

.meas tran vdout1_43ck1320 FIND v(dout1_43) AT=665.025n

.meas tran vdout1_44ck1320 FIND v(dout1_44) AT=665.025n

.meas tran vdout1_45ck1320 FIND v(dout1_45) AT=665.025n

.meas tran vdout1_46ck1320 FIND v(dout1_46) AT=665.025n

.meas tran vdout1_47ck1320 FIND v(dout1_47) AT=665.025n

.meas tran vdout1_48ck1320 FIND v(dout1_48) AT=665.025n

.meas tran vdout1_49ck1320 FIND v(dout1_49) AT=665.025n

.meas tran vdout1_50ck1320 FIND v(dout1_50) AT=665.025n

.meas tran vdout1_51ck1320 FIND v(dout1_51) AT=665.025n

.meas tran vdout1_52ck1320 FIND v(dout1_52) AT=665.025n

.meas tran vdout1_53ck1320 FIND v(dout1_53) AT=665.025n

.meas tran vdout1_54ck1320 FIND v(dout1_54) AT=665.025n

.meas tran vdout1_55ck1320 FIND v(dout1_55) AT=665.025n

.meas tran vdout1_56ck1320 FIND v(dout1_56) AT=665.025n

.meas tran vdout1_57ck1320 FIND v(dout1_57) AT=665.025n

.meas tran vdout1_58ck1320 FIND v(dout1_58) AT=665.025n

.meas tran vdout1_59ck1320 FIND v(dout1_59) AT=665.025n

.meas tran vdout1_60ck1320 FIND v(dout1_60) AT=665.025n

.meas tran vdout1_61ck1320 FIND v(dout1_61) AT=665.025n

.meas tran vdout1_62ck1320 FIND v(dout1_62) AT=665.025n

.meas tran vdout1_63ck1320 FIND v(dout1_63) AT=665.025n

.meas tran vdout1_0ck1330 FIND v(dout1_0) AT=670.025n

.meas tran vdout1_1ck1330 FIND v(dout1_1) AT=670.025n

.meas tran vdout1_2ck1330 FIND v(dout1_2) AT=670.025n

.meas tran vdout1_3ck1330 FIND v(dout1_3) AT=670.025n

.meas tran vdout1_4ck1330 FIND v(dout1_4) AT=670.025n

.meas tran vdout1_5ck1330 FIND v(dout1_5) AT=670.025n

.meas tran vdout1_6ck1330 FIND v(dout1_6) AT=670.025n

.meas tran vdout1_7ck1330 FIND v(dout1_7) AT=670.025n

.meas tran vdout1_8ck1330 FIND v(dout1_8) AT=670.025n

.meas tran vdout1_9ck1330 FIND v(dout1_9) AT=670.025n

.meas tran vdout1_10ck1330 FIND v(dout1_10) AT=670.025n

.meas tran vdout1_11ck1330 FIND v(dout1_11) AT=670.025n

.meas tran vdout1_12ck1330 FIND v(dout1_12) AT=670.025n

.meas tran vdout1_13ck1330 FIND v(dout1_13) AT=670.025n

.meas tran vdout1_14ck1330 FIND v(dout1_14) AT=670.025n

.meas tran vdout1_15ck1330 FIND v(dout1_15) AT=670.025n

.meas tran vdout1_16ck1330 FIND v(dout1_16) AT=670.025n

.meas tran vdout1_17ck1330 FIND v(dout1_17) AT=670.025n

.meas tran vdout1_18ck1330 FIND v(dout1_18) AT=670.025n

.meas tran vdout1_19ck1330 FIND v(dout1_19) AT=670.025n

.meas tran vdout1_20ck1330 FIND v(dout1_20) AT=670.025n

.meas tran vdout1_21ck1330 FIND v(dout1_21) AT=670.025n

.meas tran vdout1_22ck1330 FIND v(dout1_22) AT=670.025n

.meas tran vdout1_23ck1330 FIND v(dout1_23) AT=670.025n

.meas tran vdout1_24ck1330 FIND v(dout1_24) AT=670.025n

.meas tran vdout1_25ck1330 FIND v(dout1_25) AT=670.025n

.meas tran vdout1_26ck1330 FIND v(dout1_26) AT=670.025n

.meas tran vdout1_27ck1330 FIND v(dout1_27) AT=670.025n

.meas tran vdout1_28ck1330 FIND v(dout1_28) AT=670.025n

.meas tran vdout1_29ck1330 FIND v(dout1_29) AT=670.025n

.meas tran vdout1_30ck1330 FIND v(dout1_30) AT=670.025n

.meas tran vdout1_31ck1330 FIND v(dout1_31) AT=670.025n

.meas tran vdout1_32ck1330 FIND v(dout1_32) AT=670.025n

.meas tran vdout1_33ck1330 FIND v(dout1_33) AT=670.025n

.meas tran vdout1_34ck1330 FIND v(dout1_34) AT=670.025n

.meas tran vdout1_35ck1330 FIND v(dout1_35) AT=670.025n

.meas tran vdout1_36ck1330 FIND v(dout1_36) AT=670.025n

.meas tran vdout1_37ck1330 FIND v(dout1_37) AT=670.025n

.meas tran vdout1_38ck1330 FIND v(dout1_38) AT=670.025n

.meas tran vdout1_39ck1330 FIND v(dout1_39) AT=670.025n

.meas tran vdout1_40ck1330 FIND v(dout1_40) AT=670.025n

.meas tran vdout1_41ck1330 FIND v(dout1_41) AT=670.025n

.meas tran vdout1_42ck1330 FIND v(dout1_42) AT=670.025n

.meas tran vdout1_43ck1330 FIND v(dout1_43) AT=670.025n

.meas tran vdout1_44ck1330 FIND v(dout1_44) AT=670.025n

.meas tran vdout1_45ck1330 FIND v(dout1_45) AT=670.025n

.meas tran vdout1_46ck1330 FIND v(dout1_46) AT=670.025n

.meas tran vdout1_47ck1330 FIND v(dout1_47) AT=670.025n

.meas tran vdout1_48ck1330 FIND v(dout1_48) AT=670.025n

.meas tran vdout1_49ck1330 FIND v(dout1_49) AT=670.025n

.meas tran vdout1_50ck1330 FIND v(dout1_50) AT=670.025n

.meas tran vdout1_51ck1330 FIND v(dout1_51) AT=670.025n

.meas tran vdout1_52ck1330 FIND v(dout1_52) AT=670.025n

.meas tran vdout1_53ck1330 FIND v(dout1_53) AT=670.025n

.meas tran vdout1_54ck1330 FIND v(dout1_54) AT=670.025n

.meas tran vdout1_55ck1330 FIND v(dout1_55) AT=670.025n

.meas tran vdout1_56ck1330 FIND v(dout1_56) AT=670.025n

.meas tran vdout1_57ck1330 FIND v(dout1_57) AT=670.025n

.meas tran vdout1_58ck1330 FIND v(dout1_58) AT=670.025n

.meas tran vdout1_59ck1330 FIND v(dout1_59) AT=670.025n

.meas tran vdout1_60ck1330 FIND v(dout1_60) AT=670.025n

.meas tran vdout1_61ck1330 FIND v(dout1_61) AT=670.025n

.meas tran vdout1_62ck1330 FIND v(dout1_62) AT=670.025n

.meas tran vdout1_63ck1330 FIND v(dout1_63) AT=670.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_16ck1340 FIND v(dout1_16) AT=675.025n

.meas tran vdout1_17ck1340 FIND v(dout1_17) AT=675.025n

.meas tran vdout1_18ck1340 FIND v(dout1_18) AT=675.025n

.meas tran vdout1_19ck1340 FIND v(dout1_19) AT=675.025n

.meas tran vdout1_20ck1340 FIND v(dout1_20) AT=675.025n

.meas tran vdout1_21ck1340 FIND v(dout1_21) AT=675.025n

.meas tran vdout1_22ck1340 FIND v(dout1_22) AT=675.025n

.meas tran vdout1_23ck1340 FIND v(dout1_23) AT=675.025n

.meas tran vdout1_24ck1340 FIND v(dout1_24) AT=675.025n

.meas tran vdout1_25ck1340 FIND v(dout1_25) AT=675.025n

.meas tran vdout1_26ck1340 FIND v(dout1_26) AT=675.025n

.meas tran vdout1_27ck1340 FIND v(dout1_27) AT=675.025n

.meas tran vdout1_28ck1340 FIND v(dout1_28) AT=675.025n

.meas tran vdout1_29ck1340 FIND v(dout1_29) AT=675.025n

.meas tran vdout1_30ck1340 FIND v(dout1_30) AT=675.025n

.meas tran vdout1_31ck1340 FIND v(dout1_31) AT=675.025n

.meas tran vdout1_32ck1340 FIND v(dout1_32) AT=675.025n

.meas tran vdout1_33ck1340 FIND v(dout1_33) AT=675.025n

.meas tran vdout1_34ck1340 FIND v(dout1_34) AT=675.025n

.meas tran vdout1_35ck1340 FIND v(dout1_35) AT=675.025n

.meas tran vdout1_36ck1340 FIND v(dout1_36) AT=675.025n

.meas tran vdout1_37ck1340 FIND v(dout1_37) AT=675.025n

.meas tran vdout1_38ck1340 FIND v(dout1_38) AT=675.025n

.meas tran vdout1_39ck1340 FIND v(dout1_39) AT=675.025n

.meas tran vdout1_40ck1340 FIND v(dout1_40) AT=675.025n

.meas tran vdout1_41ck1340 FIND v(dout1_41) AT=675.025n

.meas tran vdout1_42ck1340 FIND v(dout1_42) AT=675.025n

.meas tran vdout1_43ck1340 FIND v(dout1_43) AT=675.025n

.meas tran vdout1_44ck1340 FIND v(dout1_44) AT=675.025n

.meas tran vdout1_45ck1340 FIND v(dout1_45) AT=675.025n

.meas tran vdout1_46ck1340 FIND v(dout1_46) AT=675.025n

.meas tran vdout1_47ck1340 FIND v(dout1_47) AT=675.025n

.meas tran vdout1_48ck1340 FIND v(dout1_48) AT=675.025n

.meas tran vdout1_49ck1340 FIND v(dout1_49) AT=675.025n

.meas tran vdout1_50ck1340 FIND v(dout1_50) AT=675.025n

.meas tran vdout1_51ck1340 FIND v(dout1_51) AT=675.025n

.meas tran vdout1_52ck1340 FIND v(dout1_52) AT=675.025n

.meas tran vdout1_53ck1340 FIND v(dout1_53) AT=675.025n

.meas tran vdout1_54ck1340 FIND v(dout1_54) AT=675.025n

.meas tran vdout1_55ck1340 FIND v(dout1_55) AT=675.025n

.meas tran vdout1_56ck1340 FIND v(dout1_56) AT=675.025n

.meas tran vdout1_57ck1340 FIND v(dout1_57) AT=675.025n

.meas tran vdout1_58ck1340 FIND v(dout1_58) AT=675.025n

.meas tran vdout1_59ck1340 FIND v(dout1_59) AT=675.025n

.meas tran vdout1_60ck1340 FIND v(dout1_60) AT=675.025n

.meas tran vdout1_61ck1340 FIND v(dout1_61) AT=675.025n

.meas tran vdout1_62ck1340 FIND v(dout1_62) AT=675.025n

.meas tran vdout1_63ck1340 FIND v(dout1_63) AT=675.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_32ck1350 FIND v(dout1_32) AT=680.025n

.meas tran vdout1_33ck1350 FIND v(dout1_33) AT=680.025n

.meas tran vdout1_34ck1350 FIND v(dout1_34) AT=680.025n

.meas tran vdout1_35ck1350 FIND v(dout1_35) AT=680.025n

.meas tran vdout1_36ck1350 FIND v(dout1_36) AT=680.025n

.meas tran vdout1_37ck1350 FIND v(dout1_37) AT=680.025n

.meas tran vdout1_38ck1350 FIND v(dout1_38) AT=680.025n

.meas tran vdout1_39ck1350 FIND v(dout1_39) AT=680.025n

.meas tran vdout1_40ck1350 FIND v(dout1_40) AT=680.025n

.meas tran vdout1_41ck1350 FIND v(dout1_41) AT=680.025n

.meas tran vdout1_42ck1350 FIND v(dout1_42) AT=680.025n

.meas tran vdout1_43ck1350 FIND v(dout1_43) AT=680.025n

.meas tran vdout1_44ck1350 FIND v(dout1_44) AT=680.025n

.meas tran vdout1_45ck1350 FIND v(dout1_45) AT=680.025n

.meas tran vdout1_46ck1350 FIND v(dout1_46) AT=680.025n

.meas tran vdout1_47ck1350 FIND v(dout1_47) AT=680.025n

.meas tran vdout1_48ck1350 FIND v(dout1_48) AT=680.025n

.meas tran vdout1_49ck1350 FIND v(dout1_49) AT=680.025n

.meas tran vdout1_50ck1350 FIND v(dout1_50) AT=680.025n

.meas tran vdout1_51ck1350 FIND v(dout1_51) AT=680.025n

.meas tran vdout1_52ck1350 FIND v(dout1_52) AT=680.025n

.meas tran vdout1_53ck1350 FIND v(dout1_53) AT=680.025n

.meas tran vdout1_54ck1350 FIND v(dout1_54) AT=680.025n

.meas tran vdout1_55ck1350 FIND v(dout1_55) AT=680.025n

.meas tran vdout1_56ck1350 FIND v(dout1_56) AT=680.025n

.meas tran vdout1_57ck1350 FIND v(dout1_57) AT=680.025n

.meas tran vdout1_58ck1350 FIND v(dout1_58) AT=680.025n

.meas tran vdout1_59ck1350 FIND v(dout1_59) AT=680.025n

.meas tran vdout1_60ck1350 FIND v(dout1_60) AT=680.025n

.meas tran vdout1_61ck1350 FIND v(dout1_61) AT=680.025n

.meas tran vdout1_62ck1350 FIND v(dout1_62) AT=680.025n

.meas tran vdout1_63ck1350 FIND v(dout1_63) AT=680.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_23ck1370 FIND v(dout1_23) AT=690.025n

.meas tran vdout1_24ck1370 FIND v(dout1_24) AT=690.025n

.meas tran vdout1_25ck1370 FIND v(dout1_25) AT=690.025n

.meas tran vdout1_26ck1370 FIND v(dout1_26) AT=690.025n

.meas tran vdout1_27ck1370 FIND v(dout1_27) AT=690.025n

.meas tran vdout1_28ck1370 FIND v(dout1_28) AT=690.025n

.meas tran vdout1_29ck1370 FIND v(dout1_29) AT=690.025n

.meas tran vdout1_30ck1370 FIND v(dout1_30) AT=690.025n

.meas tran vdout1_31ck1370 FIND v(dout1_31) AT=690.025n

.meas tran vdout1_32ck1370 FIND v(dout1_32) AT=690.025n

.meas tran vdout1_33ck1370 FIND v(dout1_33) AT=690.025n

.meas tran vdout1_34ck1370 FIND v(dout1_34) AT=690.025n

.meas tran vdout1_35ck1370 FIND v(dout1_35) AT=690.025n

.meas tran vdout1_36ck1370 FIND v(dout1_36) AT=690.025n

.meas tran vdout1_37ck1370 FIND v(dout1_37) AT=690.025n

.meas tran vdout1_38ck1370 FIND v(dout1_38) AT=690.025n

.meas tran vdout1_39ck1370 FIND v(dout1_39) AT=690.025n

.meas tran vdout1_40ck1370 FIND v(dout1_40) AT=690.025n

.meas tran vdout1_41ck1370 FIND v(dout1_41) AT=690.025n

.meas tran vdout1_42ck1370 FIND v(dout1_42) AT=690.025n

.meas tran vdout1_43ck1370 FIND v(dout1_43) AT=690.025n

.meas tran vdout1_44ck1370 FIND v(dout1_44) AT=690.025n

.meas tran vdout1_45ck1370 FIND v(dout1_45) AT=690.025n

.meas tran vdout1_46ck1370 FIND v(dout1_46) AT=690.025n

.meas tran vdout1_47ck1370 FIND v(dout1_47) AT=690.025n

.meas tran vdout1_48ck1370 FIND v(dout1_48) AT=690.025n

.meas tran vdout1_49ck1370 FIND v(dout1_49) AT=690.025n

.meas tran vdout1_50ck1370 FIND v(dout1_50) AT=690.025n

.meas tran vdout1_51ck1370 FIND v(dout1_51) AT=690.025n

.meas tran vdout1_52ck1370 FIND v(dout1_52) AT=690.025n

.meas tran vdout1_53ck1370 FIND v(dout1_53) AT=690.025n

.meas tran vdout1_54ck1370 FIND v(dout1_54) AT=690.025n

.meas tran vdout1_55ck1370 FIND v(dout1_55) AT=690.025n

.meas tran vdout1_56ck1370 FIND v(dout1_56) AT=690.025n

.meas tran vdout1_57ck1370 FIND v(dout1_57) AT=690.025n

.meas tran vdout1_58ck1370 FIND v(dout1_58) AT=690.025n

.meas tran vdout1_59ck1370 FIND v(dout1_59) AT=690.025n

.meas tran vdout1_60ck1370 FIND v(dout1_60) AT=690.025n

.meas tran vdout1_61ck1370 FIND v(dout1_61) AT=690.025n

.meas tran vdout1_62ck1370 FIND v(dout1_62) AT=690.025n

.meas tran vdout1_63ck1370 FIND v(dout1_63) AT=690.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_32ck1380 FIND v(dout1_32) AT=695.025n

.meas tran vdout1_33ck1380 FIND v(dout1_33) AT=695.025n

.meas tran vdout1_34ck1380 FIND v(dout1_34) AT=695.025n

.meas tran vdout1_35ck1380 FIND v(dout1_35) AT=695.025n

.meas tran vdout1_36ck1380 FIND v(dout1_36) AT=695.025n

.meas tran vdout1_37ck1380 FIND v(dout1_37) AT=695.025n

.meas tran vdout1_38ck1380 FIND v(dout1_38) AT=695.025n

.meas tran vdout1_39ck1380 FIND v(dout1_39) AT=695.025n

.meas tran vdout1_40ck1380 FIND v(dout1_40) AT=695.025n

.meas tran vdout1_41ck1380 FIND v(dout1_41) AT=695.025n

.meas tran vdout1_42ck1380 FIND v(dout1_42) AT=695.025n

.meas tran vdout1_43ck1380 FIND v(dout1_43) AT=695.025n

.meas tran vdout1_44ck1380 FIND v(dout1_44) AT=695.025n

.meas tran vdout1_45ck1380 FIND v(dout1_45) AT=695.025n

.meas tran vdout1_46ck1380 FIND v(dout1_46) AT=695.025n

.meas tran vdout1_47ck1380 FIND v(dout1_47) AT=695.025n

.meas tran vdout1_48ck1380 FIND v(dout1_48) AT=695.025n

.meas tran vdout1_49ck1380 FIND v(dout1_49) AT=695.025n

.meas tran vdout1_50ck1380 FIND v(dout1_50) AT=695.025n

.meas tran vdout1_51ck1380 FIND v(dout1_51) AT=695.025n

.meas tran vdout1_52ck1380 FIND v(dout1_52) AT=695.025n

.meas tran vdout1_53ck1380 FIND v(dout1_53) AT=695.025n

.meas tran vdout1_54ck1380 FIND v(dout1_54) AT=695.025n

.meas tran vdout1_55ck1380 FIND v(dout1_55) AT=695.025n

.meas tran vdout1_56ck1380 FIND v(dout1_56) AT=695.025n

.meas tran vdout1_57ck1380 FIND v(dout1_57) AT=695.025n

.meas tran vdout1_58ck1380 FIND v(dout1_58) AT=695.025n

.meas tran vdout1_59ck1380 FIND v(dout1_59) AT=695.025n

.meas tran vdout1_60ck1380 FIND v(dout1_60) AT=695.025n

.meas tran vdout1_61ck1380 FIND v(dout1_61) AT=695.025n

.meas tran vdout1_62ck1380 FIND v(dout1_62) AT=695.025n

.meas tran vdout1_63ck1380 FIND v(dout1_63) AT=695.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_32ck1400 FIND v(dout1_32) AT=705.025n

.meas tran vdout1_33ck1400 FIND v(dout1_33) AT=705.025n

.meas tran vdout1_34ck1400 FIND v(dout1_34) AT=705.025n

.meas tran vdout1_35ck1400 FIND v(dout1_35) AT=705.025n

.meas tran vdout1_36ck1400 FIND v(dout1_36) AT=705.025n

.meas tran vdout1_37ck1400 FIND v(dout1_37) AT=705.025n

.meas tran vdout1_38ck1400 FIND v(dout1_38) AT=705.025n

.meas tran vdout1_39ck1400 FIND v(dout1_39) AT=705.025n

.meas tran vdout1_40ck1400 FIND v(dout1_40) AT=705.025n

.meas tran vdout1_41ck1400 FIND v(dout1_41) AT=705.025n

.meas tran vdout1_42ck1400 FIND v(dout1_42) AT=705.025n

.meas tran vdout1_43ck1400 FIND v(dout1_43) AT=705.025n

.meas tran vdout1_44ck1400 FIND v(dout1_44) AT=705.025n

.meas tran vdout1_45ck1400 FIND v(dout1_45) AT=705.025n

.meas tran vdout1_46ck1400 FIND v(dout1_46) AT=705.025n

.meas tran vdout1_47ck1400 FIND v(dout1_47) AT=705.025n

.meas tran vdout1_48ck1400 FIND v(dout1_48) AT=705.025n

.meas tran vdout1_49ck1400 FIND v(dout1_49) AT=705.025n

.meas tran vdout1_50ck1400 FIND v(dout1_50) AT=705.025n

.meas tran vdout1_51ck1400 FIND v(dout1_51) AT=705.025n

.meas tran vdout1_52ck1400 FIND v(dout1_52) AT=705.025n

.meas tran vdout1_53ck1400 FIND v(dout1_53) AT=705.025n

.meas tran vdout1_54ck1400 FIND v(dout1_54) AT=705.025n

.meas tran vdout1_55ck1400 FIND v(dout1_55) AT=705.025n

.meas tran vdout1_56ck1400 FIND v(dout1_56) AT=705.025n

.meas tran vdout1_57ck1400 FIND v(dout1_57) AT=705.025n

.meas tran vdout1_58ck1400 FIND v(dout1_58) AT=705.025n

.meas tran vdout1_59ck1400 FIND v(dout1_59) AT=705.025n

.meas tran vdout1_60ck1400 FIND v(dout1_60) AT=705.025n

.meas tran vdout1_61ck1400 FIND v(dout1_61) AT=705.025n

.meas tran vdout1_62ck1400 FIND v(dout1_62) AT=705.025n

.meas tran vdout1_63ck1400 FIND v(dout1_63) AT=705.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_22ck1410 FIND v(dout1_22) AT=710.025n

.meas tran vdout1_23ck1410 FIND v(dout1_23) AT=710.025n

.meas tran vdout1_24ck1410 FIND v(dout1_24) AT=710.025n

.meas tran vdout1_25ck1410 FIND v(dout1_25) AT=710.025n

.meas tran vdout1_26ck1410 FIND v(dout1_26) AT=710.025n

.meas tran vdout1_27ck1410 FIND v(dout1_27) AT=710.025n

.meas tran vdout1_28ck1410 FIND v(dout1_28) AT=710.025n

.meas tran vdout1_29ck1410 FIND v(dout1_29) AT=710.025n

.meas tran vdout1_30ck1410 FIND v(dout1_30) AT=710.025n

.meas tran vdout1_31ck1410 FIND v(dout1_31) AT=710.025n

.meas tran vdout1_32ck1410 FIND v(dout1_32) AT=710.025n

.meas tran vdout1_33ck1410 FIND v(dout1_33) AT=710.025n

.meas tran vdout1_34ck1410 FIND v(dout1_34) AT=710.025n

.meas tran vdout1_35ck1410 FIND v(dout1_35) AT=710.025n

.meas tran vdout1_36ck1410 FIND v(dout1_36) AT=710.025n

.meas tran vdout1_37ck1410 FIND v(dout1_37) AT=710.025n

.meas tran vdout1_38ck1410 FIND v(dout1_38) AT=710.025n

.meas tran vdout1_39ck1410 FIND v(dout1_39) AT=710.025n

.meas tran vdout1_40ck1410 FIND v(dout1_40) AT=710.025n

.meas tran vdout1_41ck1410 FIND v(dout1_41) AT=710.025n

.meas tran vdout1_42ck1410 FIND v(dout1_42) AT=710.025n

.meas tran vdout1_43ck1410 FIND v(dout1_43) AT=710.025n

.meas tran vdout1_44ck1410 FIND v(dout1_44) AT=710.025n

.meas tran vdout1_45ck1410 FIND v(dout1_45) AT=710.025n

.meas tran vdout1_46ck1410 FIND v(dout1_46) AT=710.025n

.meas tran vdout1_47ck1410 FIND v(dout1_47) AT=710.025n

.meas tran vdout1_48ck1410 FIND v(dout1_48) AT=710.025n

.meas tran vdout1_49ck1410 FIND v(dout1_49) AT=710.025n

.meas tran vdout1_50ck1410 FIND v(dout1_50) AT=710.025n

.meas tran vdout1_51ck1410 FIND v(dout1_51) AT=710.025n

.meas tran vdout1_52ck1410 FIND v(dout1_52) AT=710.025n

.meas tran vdout1_53ck1410 FIND v(dout1_53) AT=710.025n

.meas tran vdout1_54ck1410 FIND v(dout1_54) AT=710.025n

.meas tran vdout1_55ck1410 FIND v(dout1_55) AT=710.025n

.meas tran vdout1_56ck1410 FIND v(dout1_56) AT=710.025n

.meas tran vdout1_57ck1410 FIND v(dout1_57) AT=710.025n

.meas tran vdout1_58ck1410 FIND v(dout1_58) AT=710.025n

.meas tran vdout1_59ck1410 FIND v(dout1_59) AT=710.025n

.meas tran vdout1_60ck1410 FIND v(dout1_60) AT=710.025n

.meas tran vdout1_61ck1410 FIND v(dout1_61) AT=710.025n

.meas tran vdout1_62ck1410 FIND v(dout1_62) AT=710.025n

.meas tran vdout1_63ck1410 FIND v(dout1_63) AT=710.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_22ck1460 FIND v(dout1_22) AT=735.025n

.meas tran vdout1_23ck1460 FIND v(dout1_23) AT=735.025n

.meas tran vdout1_24ck1460 FIND v(dout1_24) AT=735.025n

.meas tran vdout1_25ck1460 FIND v(dout1_25) AT=735.025n

.meas tran vdout1_26ck1460 FIND v(dout1_26) AT=735.025n

.meas tran vdout1_27ck1460 FIND v(dout1_27) AT=735.025n

.meas tran vdout1_28ck1460 FIND v(dout1_28) AT=735.025n

.meas tran vdout1_29ck1460 FIND v(dout1_29) AT=735.025n

.meas tran vdout1_30ck1460 FIND v(dout1_30) AT=735.025n

.meas tran vdout1_31ck1460 FIND v(dout1_31) AT=735.025n

.meas tran vdout1_32ck1460 FIND v(dout1_32) AT=735.025n

.meas tran vdout1_33ck1460 FIND v(dout1_33) AT=735.025n

.meas tran vdout1_34ck1460 FIND v(dout1_34) AT=735.025n

.meas tran vdout1_35ck1460 FIND v(dout1_35) AT=735.025n

.meas tran vdout1_36ck1460 FIND v(dout1_36) AT=735.025n

.meas tran vdout1_37ck1460 FIND v(dout1_37) AT=735.025n

.meas tran vdout1_38ck1460 FIND v(dout1_38) AT=735.025n

.meas tran vdout1_39ck1460 FIND v(dout1_39) AT=735.025n

.meas tran vdout1_40ck1460 FIND v(dout1_40) AT=735.025n

.meas tran vdout1_41ck1460 FIND v(dout1_41) AT=735.025n

.meas tran vdout1_42ck1460 FIND v(dout1_42) AT=735.025n

.meas tran vdout1_43ck1460 FIND v(dout1_43) AT=735.025n

.meas tran vdout1_44ck1460 FIND v(dout1_44) AT=735.025n

.meas tran vdout1_45ck1460 FIND v(dout1_45) AT=735.025n

.meas tran vdout1_46ck1460 FIND v(dout1_46) AT=735.025n

.meas tran vdout1_47ck1460 FIND v(dout1_47) AT=735.025n

.meas tran vdout1_48ck1460 FIND v(dout1_48) AT=735.025n

.meas tran vdout1_49ck1460 FIND v(dout1_49) AT=735.025n

.meas tran vdout1_50ck1460 FIND v(dout1_50) AT=735.025n

.meas tran vdout1_51ck1460 FIND v(dout1_51) AT=735.025n

.meas tran vdout1_52ck1460 FIND v(dout1_52) AT=735.025n

.meas tran vdout1_53ck1460 FIND v(dout1_53) AT=735.025n

.meas tran vdout1_54ck1460 FIND v(dout1_54) AT=735.025n

.meas tran vdout1_55ck1460 FIND v(dout1_55) AT=735.025n

.meas tran vdout1_56ck1460 FIND v(dout1_56) AT=735.025n

.meas tran vdout1_57ck1460 FIND v(dout1_57) AT=735.025n

.meas tran vdout1_58ck1460 FIND v(dout1_58) AT=735.025n

.meas tran vdout1_59ck1460 FIND v(dout1_59) AT=735.025n

.meas tran vdout1_60ck1460 FIND v(dout1_60) AT=735.025n

.meas tran vdout1_61ck1460 FIND v(dout1_61) AT=735.025n

.meas tran vdout1_62ck1460 FIND v(dout1_62) AT=735.025n

.meas tran vdout1_63ck1460 FIND v(dout1_63) AT=735.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_8ck1470 FIND v(dout1_8) AT=740.025n

.meas tran vdout1_9ck1470 FIND v(dout1_9) AT=740.025n

.meas tran vdout1_10ck1470 FIND v(dout1_10) AT=740.025n

.meas tran vdout1_11ck1470 FIND v(dout1_11) AT=740.025n

.meas tran vdout1_12ck1470 FIND v(dout1_12) AT=740.025n

.meas tran vdout1_13ck1470 FIND v(dout1_13) AT=740.025n

.meas tran vdout1_14ck1470 FIND v(dout1_14) AT=740.025n

.meas tran vdout1_15ck1470 FIND v(dout1_15) AT=740.025n

.meas tran vdout1_16ck1470 FIND v(dout1_16) AT=740.025n

.meas tran vdout1_17ck1470 FIND v(dout1_17) AT=740.025n

.meas tran vdout1_18ck1470 FIND v(dout1_18) AT=740.025n

.meas tran vdout1_19ck1470 FIND v(dout1_19) AT=740.025n

.meas tran vdout1_20ck1470 FIND v(dout1_20) AT=740.025n

.meas tran vdout1_21ck1470 FIND v(dout1_21) AT=740.025n

.meas tran vdout1_22ck1470 FIND v(dout1_22) AT=740.025n

.meas tran vdout1_23ck1470 FIND v(dout1_23) AT=740.025n

.meas tran vdout1_24ck1470 FIND v(dout1_24) AT=740.025n

.meas tran vdout1_25ck1470 FIND v(dout1_25) AT=740.025n

.meas tran vdout1_26ck1470 FIND v(dout1_26) AT=740.025n

.meas tran vdout1_27ck1470 FIND v(dout1_27) AT=740.025n

.meas tran vdout1_28ck1470 FIND v(dout1_28) AT=740.025n

.meas tran vdout1_29ck1470 FIND v(dout1_29) AT=740.025n

.meas tran vdout1_30ck1470 FIND v(dout1_30) AT=740.025n

.meas tran vdout1_31ck1470 FIND v(dout1_31) AT=740.025n

.meas tran vdout1_32ck1470 FIND v(dout1_32) AT=740.025n

.meas tran vdout1_33ck1470 FIND v(dout1_33) AT=740.025n

.meas tran vdout1_34ck1470 FIND v(dout1_34) AT=740.025n

.meas tran vdout1_35ck1470 FIND v(dout1_35) AT=740.025n

.meas tran vdout1_36ck1470 FIND v(dout1_36) AT=740.025n

.meas tran vdout1_37ck1470 FIND v(dout1_37) AT=740.025n

.meas tran vdout1_38ck1470 FIND v(dout1_38) AT=740.025n

.meas tran vdout1_39ck1470 FIND v(dout1_39) AT=740.025n

.meas tran vdout1_40ck1470 FIND v(dout1_40) AT=740.025n

.meas tran vdout1_41ck1470 FIND v(dout1_41) AT=740.025n

.meas tran vdout1_42ck1470 FIND v(dout1_42) AT=740.025n

.meas tran vdout1_43ck1470 FIND v(dout1_43) AT=740.025n

.meas tran vdout1_44ck1470 FIND v(dout1_44) AT=740.025n

.meas tran vdout1_45ck1470 FIND v(dout1_45) AT=740.025n

.meas tran vdout1_46ck1470 FIND v(dout1_46) AT=740.025n

.meas tran vdout1_47ck1470 FIND v(dout1_47) AT=740.025n

.meas tran vdout1_48ck1470 FIND v(dout1_48) AT=740.025n

.meas tran vdout1_49ck1470 FIND v(dout1_49) AT=740.025n

.meas tran vdout1_50ck1470 FIND v(dout1_50) AT=740.025n

.meas tran vdout1_51ck1470 FIND v(dout1_51) AT=740.025n

.meas tran vdout1_52ck1470 FIND v(dout1_52) AT=740.025n

.meas tran vdout1_53ck1470 FIND v(dout1_53) AT=740.025n

.meas tran vdout1_54ck1470 FIND v(dout1_54) AT=740.025n

.meas tran vdout1_55ck1470 FIND v(dout1_55) AT=740.025n

.meas tran vdout1_56ck1470 FIND v(dout1_56) AT=740.025n

.meas tran vdout1_57ck1470 FIND v(dout1_57) AT=740.025n

.meas tran vdout1_58ck1470 FIND v(dout1_58) AT=740.025n

.meas tran vdout1_59ck1470 FIND v(dout1_59) AT=740.025n

.meas tran vdout1_60ck1470 FIND v(dout1_60) AT=740.025n

.meas tran vdout1_61ck1470 FIND v(dout1_61) AT=740.025n

.meas tran vdout1_62ck1470 FIND v(dout1_62) AT=740.025n

.meas tran vdout1_63ck1470 FIND v(dout1_63) AT=740.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_22ck1490 FIND v(dout1_22) AT=750.025n

.meas tran vdout1_23ck1490 FIND v(dout1_23) AT=750.025n

.meas tran vdout1_24ck1490 FIND v(dout1_24) AT=750.025n

.meas tran vdout1_25ck1490 FIND v(dout1_25) AT=750.025n

.meas tran vdout1_26ck1490 FIND v(dout1_26) AT=750.025n

.meas tran vdout1_27ck1490 FIND v(dout1_27) AT=750.025n

.meas tran vdout1_28ck1490 FIND v(dout1_28) AT=750.025n

.meas tran vdout1_29ck1490 FIND v(dout1_29) AT=750.025n

.meas tran vdout1_30ck1490 FIND v(dout1_30) AT=750.025n

.meas tran vdout1_31ck1490 FIND v(dout1_31) AT=750.025n

.meas tran vdout1_32ck1490 FIND v(dout1_32) AT=750.025n

.meas tran vdout1_33ck1490 FIND v(dout1_33) AT=750.025n

.meas tran vdout1_34ck1490 FIND v(dout1_34) AT=750.025n

.meas tran vdout1_35ck1490 FIND v(dout1_35) AT=750.025n

.meas tran vdout1_36ck1490 FIND v(dout1_36) AT=750.025n

.meas tran vdout1_37ck1490 FIND v(dout1_37) AT=750.025n

.meas tran vdout1_38ck1490 FIND v(dout1_38) AT=750.025n

.meas tran vdout1_39ck1490 FIND v(dout1_39) AT=750.025n

.meas tran vdout1_40ck1490 FIND v(dout1_40) AT=750.025n

.meas tran vdout1_41ck1490 FIND v(dout1_41) AT=750.025n

.meas tran vdout1_42ck1490 FIND v(dout1_42) AT=750.025n

.meas tran vdout1_43ck1490 FIND v(dout1_43) AT=750.025n

.meas tran vdout1_44ck1490 FIND v(dout1_44) AT=750.025n

.meas tran vdout1_45ck1490 FIND v(dout1_45) AT=750.025n

.meas tran vdout1_46ck1490 FIND v(dout1_46) AT=750.025n

.meas tran vdout1_47ck1490 FIND v(dout1_47) AT=750.025n

.meas tran vdout1_48ck1490 FIND v(dout1_48) AT=750.025n

.meas tran vdout1_49ck1490 FIND v(dout1_49) AT=750.025n

.meas tran vdout1_50ck1490 FIND v(dout1_50) AT=750.025n

.meas tran vdout1_51ck1490 FIND v(dout1_51) AT=750.025n

.meas tran vdout1_52ck1490 FIND v(dout1_52) AT=750.025n

.meas tran vdout1_53ck1490 FIND v(dout1_53) AT=750.025n

.meas tran vdout1_54ck1490 FIND v(dout1_54) AT=750.025n

.meas tran vdout1_55ck1490 FIND v(dout1_55) AT=750.025n

.meas tran vdout1_56ck1490 FIND v(dout1_56) AT=750.025n

.meas tran vdout1_57ck1490 FIND v(dout1_57) AT=750.025n

.meas tran vdout1_58ck1490 FIND v(dout1_58) AT=750.025n

.meas tran vdout1_59ck1490 FIND v(dout1_59) AT=750.025n

.meas tran vdout1_60ck1490 FIND v(dout1_60) AT=750.025n

.meas tran vdout1_61ck1490 FIND v(dout1_61) AT=750.025n

.meas tran vdout1_62ck1490 FIND v(dout1_62) AT=750.025n

.meas tran vdout1_63ck1490 FIND v(dout1_63) AT=750.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_22ck1500 FIND v(dout1_22) AT=755.025n

.meas tran vdout1_23ck1500 FIND v(dout1_23) AT=755.025n

.meas tran vdout1_24ck1500 FIND v(dout1_24) AT=755.025n

.meas tran vdout1_25ck1500 FIND v(dout1_25) AT=755.025n

.meas tran vdout1_26ck1500 FIND v(dout1_26) AT=755.025n

.meas tran vdout1_27ck1500 FIND v(dout1_27) AT=755.025n

.meas tran vdout1_28ck1500 FIND v(dout1_28) AT=755.025n

.meas tran vdout1_29ck1500 FIND v(dout1_29) AT=755.025n

.meas tran vdout1_30ck1500 FIND v(dout1_30) AT=755.025n

.meas tran vdout1_31ck1500 FIND v(dout1_31) AT=755.025n

.meas tran vdout1_32ck1500 FIND v(dout1_32) AT=755.025n

.meas tran vdout1_33ck1500 FIND v(dout1_33) AT=755.025n

.meas tran vdout1_34ck1500 FIND v(dout1_34) AT=755.025n

.meas tran vdout1_35ck1500 FIND v(dout1_35) AT=755.025n

.meas tran vdout1_36ck1500 FIND v(dout1_36) AT=755.025n

.meas tran vdout1_37ck1500 FIND v(dout1_37) AT=755.025n

.meas tran vdout1_38ck1500 FIND v(dout1_38) AT=755.025n

.meas tran vdout1_39ck1500 FIND v(dout1_39) AT=755.025n

.meas tran vdout1_40ck1500 FIND v(dout1_40) AT=755.025n

.meas tran vdout1_41ck1500 FIND v(dout1_41) AT=755.025n

.meas tran vdout1_42ck1500 FIND v(dout1_42) AT=755.025n

.meas tran vdout1_43ck1500 FIND v(dout1_43) AT=755.025n

.meas tran vdout1_44ck1500 FIND v(dout1_44) AT=755.025n

.meas tran vdout1_45ck1500 FIND v(dout1_45) AT=755.025n

.meas tran vdout1_46ck1500 FIND v(dout1_46) AT=755.025n

.meas tran vdout1_47ck1500 FIND v(dout1_47) AT=755.025n

.meas tran vdout1_48ck1500 FIND v(dout1_48) AT=755.025n

.meas tran vdout1_49ck1500 FIND v(dout1_49) AT=755.025n

.meas tran vdout1_50ck1500 FIND v(dout1_50) AT=755.025n

.meas tran vdout1_51ck1500 FIND v(dout1_51) AT=755.025n

.meas tran vdout1_52ck1500 FIND v(dout1_52) AT=755.025n

.meas tran vdout1_53ck1500 FIND v(dout1_53) AT=755.025n

.meas tran vdout1_54ck1500 FIND v(dout1_54) AT=755.025n

.meas tran vdout1_55ck1500 FIND v(dout1_55) AT=755.025n

.meas tran vdout1_56ck1500 FIND v(dout1_56) AT=755.025n

.meas tran vdout1_57ck1500 FIND v(dout1_57) AT=755.025n

.meas tran vdout1_58ck1500 FIND v(dout1_58) AT=755.025n

.meas tran vdout1_59ck1500 FIND v(dout1_59) AT=755.025n

.meas tran vdout1_60ck1500 FIND v(dout1_60) AT=755.025n

.meas tran vdout1_61ck1500 FIND v(dout1_61) AT=755.025n

.meas tran vdout1_62ck1500 FIND v(dout1_62) AT=755.025n

.meas tran vdout1_63ck1500 FIND v(dout1_63) AT=755.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_23ck1540 FIND v(dout1_23) AT=775.025n

.meas tran vdout1_24ck1540 FIND v(dout1_24) AT=775.025n

.meas tran vdout1_25ck1540 FIND v(dout1_25) AT=775.025n

.meas tran vdout1_26ck1540 FIND v(dout1_26) AT=775.025n

.meas tran vdout1_27ck1540 FIND v(dout1_27) AT=775.025n

.meas tran vdout1_28ck1540 FIND v(dout1_28) AT=775.025n

.meas tran vdout1_29ck1540 FIND v(dout1_29) AT=775.025n

.meas tran vdout1_30ck1540 FIND v(dout1_30) AT=775.025n

.meas tran vdout1_31ck1540 FIND v(dout1_31) AT=775.025n

.meas tran vdout1_32ck1540 FIND v(dout1_32) AT=775.025n

.meas tran vdout1_33ck1540 FIND v(dout1_33) AT=775.025n

.meas tran vdout1_34ck1540 FIND v(dout1_34) AT=775.025n

.meas tran vdout1_35ck1540 FIND v(dout1_35) AT=775.025n

.meas tran vdout1_36ck1540 FIND v(dout1_36) AT=775.025n

.meas tran vdout1_37ck1540 FIND v(dout1_37) AT=775.025n

.meas tran vdout1_38ck1540 FIND v(dout1_38) AT=775.025n

.meas tran vdout1_39ck1540 FIND v(dout1_39) AT=775.025n

.meas tran vdout1_40ck1540 FIND v(dout1_40) AT=775.025n

.meas tran vdout1_41ck1540 FIND v(dout1_41) AT=775.025n

.meas tran vdout1_42ck1540 FIND v(dout1_42) AT=775.025n

.meas tran vdout1_43ck1540 FIND v(dout1_43) AT=775.025n

.meas tran vdout1_44ck1540 FIND v(dout1_44) AT=775.025n

.meas tran vdout1_45ck1540 FIND v(dout1_45) AT=775.025n

.meas tran vdout1_46ck1540 FIND v(dout1_46) AT=775.025n

.meas tran vdout1_47ck1540 FIND v(dout1_47) AT=775.025n

.meas tran vdout1_48ck1540 FIND v(dout1_48) AT=775.025n

.meas tran vdout1_49ck1540 FIND v(dout1_49) AT=775.025n

.meas tran vdout1_50ck1540 FIND v(dout1_50) AT=775.025n

.meas tran vdout1_51ck1540 FIND v(dout1_51) AT=775.025n

.meas tran vdout1_52ck1540 FIND v(dout1_52) AT=775.025n

.meas tran vdout1_53ck1540 FIND v(dout1_53) AT=775.025n

.meas tran vdout1_54ck1540 FIND v(dout1_54) AT=775.025n

.meas tran vdout1_55ck1540 FIND v(dout1_55) AT=775.025n

.meas tran vdout1_56ck1540 FIND v(dout1_56) AT=775.025n

.meas tran vdout1_57ck1540 FIND v(dout1_57) AT=775.025n

.meas tran vdout1_58ck1540 FIND v(dout1_58) AT=775.025n

.meas tran vdout1_59ck1540 FIND v(dout1_59) AT=775.025n

.meas tran vdout1_60ck1540 FIND v(dout1_60) AT=775.025n

.meas tran vdout1_61ck1540 FIND v(dout1_61) AT=775.025n

.meas tran vdout1_62ck1540 FIND v(dout1_62) AT=775.025n

.meas tran vdout1_63ck1540 FIND v(dout1_63) AT=775.025n

.meas tran vdout1_0ck1550 FIND v(dout1_0) AT=780.025n

.meas tran vdout1_1ck1550 FIND v(dout1_1) AT=780.025n

.meas tran vdout1_2ck1550 FIND v(dout1_2) AT=780.025n

.meas tran vdout1_3ck1550 FIND v(dout1_3) AT=780.025n

.meas tran vdout1_4ck1550 FIND v(dout1_4) AT=780.025n

.meas tran vdout1_5ck1550 FIND v(dout1_5) AT=780.025n

.meas tran vdout1_6ck1550 FIND v(dout1_6) AT=780.025n

.meas tran vdout1_7ck1550 FIND v(dout1_7) AT=780.025n

.meas tran vdout1_8ck1550 FIND v(dout1_8) AT=780.025n

.meas tran vdout1_9ck1550 FIND v(dout1_9) AT=780.025n

.meas tran vdout1_10ck1550 FIND v(dout1_10) AT=780.025n

.meas tran vdout1_11ck1550 FIND v(dout1_11) AT=780.025n

.meas tran vdout1_12ck1550 FIND v(dout1_12) AT=780.025n

.meas tran vdout1_13ck1550 FIND v(dout1_13) AT=780.025n

.meas tran vdout1_14ck1550 FIND v(dout1_14) AT=780.025n

.meas tran vdout1_15ck1550 FIND v(dout1_15) AT=780.025n

.meas tran vdout1_16ck1550 FIND v(dout1_16) AT=780.025n

.meas tran vdout1_17ck1550 FIND v(dout1_17) AT=780.025n

.meas tran vdout1_18ck1550 FIND v(dout1_18) AT=780.025n

.meas tran vdout1_19ck1550 FIND v(dout1_19) AT=780.025n

.meas tran vdout1_20ck1550 FIND v(dout1_20) AT=780.025n

.meas tran vdout1_21ck1550 FIND v(dout1_21) AT=780.025n

.meas tran vdout1_22ck1550 FIND v(dout1_22) AT=780.025n

.meas tran vdout1_23ck1550 FIND v(dout1_23) AT=780.025n

.meas tran vdout1_24ck1550 FIND v(dout1_24) AT=780.025n

.meas tran vdout1_25ck1550 FIND v(dout1_25) AT=780.025n

.meas tran vdout1_26ck1550 FIND v(dout1_26) AT=780.025n

.meas tran vdout1_27ck1550 FIND v(dout1_27) AT=780.025n

.meas tran vdout1_28ck1550 FIND v(dout1_28) AT=780.025n

.meas tran vdout1_29ck1550 FIND v(dout1_29) AT=780.025n

.meas tran vdout1_30ck1550 FIND v(dout1_30) AT=780.025n

.meas tran vdout1_31ck1550 FIND v(dout1_31) AT=780.025n

.meas tran vdout1_32ck1550 FIND v(dout1_32) AT=780.025n

.meas tran vdout1_33ck1550 FIND v(dout1_33) AT=780.025n

.meas tran vdout1_34ck1550 FIND v(dout1_34) AT=780.025n

.meas tran vdout1_35ck1550 FIND v(dout1_35) AT=780.025n

.meas tran vdout1_36ck1550 FIND v(dout1_36) AT=780.025n

.meas tran vdout1_37ck1550 FIND v(dout1_37) AT=780.025n

.meas tran vdout1_38ck1550 FIND v(dout1_38) AT=780.025n

.meas tran vdout1_39ck1550 FIND v(dout1_39) AT=780.025n

.meas tran vdout1_40ck1550 FIND v(dout1_40) AT=780.025n

.meas tran vdout1_41ck1550 FIND v(dout1_41) AT=780.025n

.meas tran vdout1_42ck1550 FIND v(dout1_42) AT=780.025n

.meas tran vdout1_43ck1550 FIND v(dout1_43) AT=780.025n

.meas tran vdout1_44ck1550 FIND v(dout1_44) AT=780.025n

.meas tran vdout1_45ck1550 FIND v(dout1_45) AT=780.025n

.meas tran vdout1_46ck1550 FIND v(dout1_46) AT=780.025n

.meas tran vdout1_47ck1550 FIND v(dout1_47) AT=780.025n

.meas tran vdout1_48ck1550 FIND v(dout1_48) AT=780.025n

.meas tran vdout1_49ck1550 FIND v(dout1_49) AT=780.025n

.meas tran vdout1_50ck1550 FIND v(dout1_50) AT=780.025n

.meas tran vdout1_51ck1550 FIND v(dout1_51) AT=780.025n

.meas tran vdout1_52ck1550 FIND v(dout1_52) AT=780.025n

.meas tran vdout1_53ck1550 FIND v(dout1_53) AT=780.025n

.meas tran vdout1_54ck1550 FIND v(dout1_54) AT=780.025n

.meas tran vdout1_55ck1550 FIND v(dout1_55) AT=780.025n

.meas tran vdout1_56ck1550 FIND v(dout1_56) AT=780.025n

.meas tran vdout1_57ck1550 FIND v(dout1_57) AT=780.025n

.meas tran vdout1_58ck1550 FIND v(dout1_58) AT=780.025n

.meas tran vdout1_59ck1550 FIND v(dout1_59) AT=780.025n

.meas tran vdout1_60ck1550 FIND v(dout1_60) AT=780.025n

.meas tran vdout1_61ck1550 FIND v(dout1_61) AT=780.025n

.meas tran vdout1_62ck1550 FIND v(dout1_62) AT=780.025n

.meas tran vdout1_63ck1550 FIND v(dout1_63) AT=780.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_16ck1560 FIND v(dout1_16) AT=785.025n

.meas tran vdout1_17ck1560 FIND v(dout1_17) AT=785.025n

.meas tran vdout1_18ck1560 FIND v(dout1_18) AT=785.025n

.meas tran vdout1_19ck1560 FIND v(dout1_19) AT=785.025n

.meas tran vdout1_20ck1560 FIND v(dout1_20) AT=785.025n

.meas tran vdout1_21ck1560 FIND v(dout1_21) AT=785.025n

.meas tran vdout1_22ck1560 FIND v(dout1_22) AT=785.025n

.meas tran vdout1_23ck1560 FIND v(dout1_23) AT=785.025n

.meas tran vdout1_24ck1560 FIND v(dout1_24) AT=785.025n

.meas tran vdout1_25ck1560 FIND v(dout1_25) AT=785.025n

.meas tran vdout1_26ck1560 FIND v(dout1_26) AT=785.025n

.meas tran vdout1_27ck1560 FIND v(dout1_27) AT=785.025n

.meas tran vdout1_28ck1560 FIND v(dout1_28) AT=785.025n

.meas tran vdout1_29ck1560 FIND v(dout1_29) AT=785.025n

.meas tran vdout1_30ck1560 FIND v(dout1_30) AT=785.025n

.meas tran vdout1_31ck1560 FIND v(dout1_31) AT=785.025n

.meas tran vdout1_32ck1560 FIND v(dout1_32) AT=785.025n

.meas tran vdout1_33ck1560 FIND v(dout1_33) AT=785.025n

.meas tran vdout1_34ck1560 FIND v(dout1_34) AT=785.025n

.meas tran vdout1_35ck1560 FIND v(dout1_35) AT=785.025n

.meas tran vdout1_36ck1560 FIND v(dout1_36) AT=785.025n

.meas tran vdout1_37ck1560 FIND v(dout1_37) AT=785.025n

.meas tran vdout1_38ck1560 FIND v(dout1_38) AT=785.025n

.meas tran vdout1_39ck1560 FIND v(dout1_39) AT=785.025n

.meas tran vdout1_40ck1560 FIND v(dout1_40) AT=785.025n

.meas tran vdout1_41ck1560 FIND v(dout1_41) AT=785.025n

.meas tran vdout1_42ck1560 FIND v(dout1_42) AT=785.025n

.meas tran vdout1_43ck1560 FIND v(dout1_43) AT=785.025n

.meas tran vdout1_44ck1560 FIND v(dout1_44) AT=785.025n

.meas tran vdout1_45ck1560 FIND v(dout1_45) AT=785.025n

.meas tran vdout1_46ck1560 FIND v(dout1_46) AT=785.025n

.meas tran vdout1_47ck1560 FIND v(dout1_47) AT=785.025n

.meas tran vdout1_48ck1560 FIND v(dout1_48) AT=785.025n

.meas tran vdout1_49ck1560 FIND v(dout1_49) AT=785.025n

.meas tran vdout1_50ck1560 FIND v(dout1_50) AT=785.025n

.meas tran vdout1_51ck1560 FIND v(dout1_51) AT=785.025n

.meas tran vdout1_52ck1560 FIND v(dout1_52) AT=785.025n

.meas tran vdout1_53ck1560 FIND v(dout1_53) AT=785.025n

.meas tran vdout1_54ck1560 FIND v(dout1_54) AT=785.025n

.meas tran vdout1_55ck1560 FIND v(dout1_55) AT=785.025n

.meas tran vdout1_56ck1560 FIND v(dout1_56) AT=785.025n

.meas tran vdout1_57ck1560 FIND v(dout1_57) AT=785.025n

.meas tran vdout1_58ck1560 FIND v(dout1_58) AT=785.025n

.meas tran vdout1_59ck1560 FIND v(dout1_59) AT=785.025n

.meas tran vdout1_60ck1560 FIND v(dout1_60) AT=785.025n

.meas tran vdout1_61ck1560 FIND v(dout1_61) AT=785.025n

.meas tran vdout1_62ck1560 FIND v(dout1_62) AT=785.025n

.meas tran vdout1_63ck1560 FIND v(dout1_63) AT=785.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_17ck1570 FIND v(dout1_17) AT=790.025n

.meas tran vdout1_18ck1570 FIND v(dout1_18) AT=790.025n

.meas tran vdout1_19ck1570 FIND v(dout1_19) AT=790.025n

.meas tran vdout1_20ck1570 FIND v(dout1_20) AT=790.025n

.meas tran vdout1_21ck1570 FIND v(dout1_21) AT=790.025n

.meas tran vdout1_22ck1570 FIND v(dout1_22) AT=790.025n

.meas tran vdout1_23ck1570 FIND v(dout1_23) AT=790.025n

.meas tran vdout1_24ck1570 FIND v(dout1_24) AT=790.025n

.meas tran vdout1_25ck1570 FIND v(dout1_25) AT=790.025n

.meas tran vdout1_26ck1570 FIND v(dout1_26) AT=790.025n

.meas tran vdout1_27ck1570 FIND v(dout1_27) AT=790.025n

.meas tran vdout1_28ck1570 FIND v(dout1_28) AT=790.025n

.meas tran vdout1_29ck1570 FIND v(dout1_29) AT=790.025n

.meas tran vdout1_30ck1570 FIND v(dout1_30) AT=790.025n

.meas tran vdout1_31ck1570 FIND v(dout1_31) AT=790.025n

.meas tran vdout1_32ck1570 FIND v(dout1_32) AT=790.025n

.meas tran vdout1_33ck1570 FIND v(dout1_33) AT=790.025n

.meas tran vdout1_34ck1570 FIND v(dout1_34) AT=790.025n

.meas tran vdout1_35ck1570 FIND v(dout1_35) AT=790.025n

.meas tran vdout1_36ck1570 FIND v(dout1_36) AT=790.025n

.meas tran vdout1_37ck1570 FIND v(dout1_37) AT=790.025n

.meas tran vdout1_38ck1570 FIND v(dout1_38) AT=790.025n

.meas tran vdout1_39ck1570 FIND v(dout1_39) AT=790.025n

.meas tran vdout1_40ck1570 FIND v(dout1_40) AT=790.025n

.meas tran vdout1_41ck1570 FIND v(dout1_41) AT=790.025n

.meas tran vdout1_42ck1570 FIND v(dout1_42) AT=790.025n

.meas tran vdout1_43ck1570 FIND v(dout1_43) AT=790.025n

.meas tran vdout1_44ck1570 FIND v(dout1_44) AT=790.025n

.meas tran vdout1_45ck1570 FIND v(dout1_45) AT=790.025n

.meas tran vdout1_46ck1570 FIND v(dout1_46) AT=790.025n

.meas tran vdout1_47ck1570 FIND v(dout1_47) AT=790.025n

.meas tran vdout1_48ck1570 FIND v(dout1_48) AT=790.025n

.meas tran vdout1_49ck1570 FIND v(dout1_49) AT=790.025n

.meas tran vdout1_50ck1570 FIND v(dout1_50) AT=790.025n

.meas tran vdout1_51ck1570 FIND v(dout1_51) AT=790.025n

.meas tran vdout1_52ck1570 FIND v(dout1_52) AT=790.025n

.meas tran vdout1_53ck1570 FIND v(dout1_53) AT=790.025n

.meas tran vdout1_54ck1570 FIND v(dout1_54) AT=790.025n

.meas tran vdout1_55ck1570 FIND v(dout1_55) AT=790.025n

.meas tran vdout1_56ck1570 FIND v(dout1_56) AT=790.025n

.meas tran vdout1_57ck1570 FIND v(dout1_57) AT=790.025n

.meas tran vdout1_58ck1570 FIND v(dout1_58) AT=790.025n

.meas tran vdout1_59ck1570 FIND v(dout1_59) AT=790.025n

.meas tran vdout1_60ck1570 FIND v(dout1_60) AT=790.025n

.meas tran vdout1_61ck1570 FIND v(dout1_61) AT=790.025n

.meas tran vdout1_62ck1570 FIND v(dout1_62) AT=790.025n

.meas tran vdout1_63ck1570 FIND v(dout1_63) AT=790.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_22ck1610 FIND v(dout1_22) AT=810.025n

.meas tran vdout1_23ck1610 FIND v(dout1_23) AT=810.025n

.meas tran vdout1_24ck1610 FIND v(dout1_24) AT=810.025n

.meas tran vdout1_25ck1610 FIND v(dout1_25) AT=810.025n

.meas tran vdout1_26ck1610 FIND v(dout1_26) AT=810.025n

.meas tran vdout1_27ck1610 FIND v(dout1_27) AT=810.025n

.meas tran vdout1_28ck1610 FIND v(dout1_28) AT=810.025n

.meas tran vdout1_29ck1610 FIND v(dout1_29) AT=810.025n

.meas tran vdout1_30ck1610 FIND v(dout1_30) AT=810.025n

.meas tran vdout1_31ck1610 FIND v(dout1_31) AT=810.025n

.meas tran vdout1_32ck1610 FIND v(dout1_32) AT=810.025n

.meas tran vdout1_33ck1610 FIND v(dout1_33) AT=810.025n

.meas tran vdout1_34ck1610 FIND v(dout1_34) AT=810.025n

.meas tran vdout1_35ck1610 FIND v(dout1_35) AT=810.025n

.meas tran vdout1_36ck1610 FIND v(dout1_36) AT=810.025n

.meas tran vdout1_37ck1610 FIND v(dout1_37) AT=810.025n

.meas tran vdout1_38ck1610 FIND v(dout1_38) AT=810.025n

.meas tran vdout1_39ck1610 FIND v(dout1_39) AT=810.025n

.meas tran vdout1_40ck1610 FIND v(dout1_40) AT=810.025n

.meas tran vdout1_41ck1610 FIND v(dout1_41) AT=810.025n

.meas tran vdout1_42ck1610 FIND v(dout1_42) AT=810.025n

.meas tran vdout1_43ck1610 FIND v(dout1_43) AT=810.025n

.meas tran vdout1_44ck1610 FIND v(dout1_44) AT=810.025n

.meas tran vdout1_45ck1610 FIND v(dout1_45) AT=810.025n

.meas tran vdout1_46ck1610 FIND v(dout1_46) AT=810.025n

.meas tran vdout1_47ck1610 FIND v(dout1_47) AT=810.025n

.meas tran vdout1_48ck1610 FIND v(dout1_48) AT=810.025n

.meas tran vdout1_49ck1610 FIND v(dout1_49) AT=810.025n

.meas tran vdout1_50ck1610 FIND v(dout1_50) AT=810.025n

.meas tran vdout1_51ck1610 FIND v(dout1_51) AT=810.025n

.meas tran vdout1_52ck1610 FIND v(dout1_52) AT=810.025n

.meas tran vdout1_53ck1610 FIND v(dout1_53) AT=810.025n

.meas tran vdout1_54ck1610 FIND v(dout1_54) AT=810.025n

.meas tran vdout1_55ck1610 FIND v(dout1_55) AT=810.025n

.meas tran vdout1_56ck1610 FIND v(dout1_56) AT=810.025n

.meas tran vdout1_57ck1610 FIND v(dout1_57) AT=810.025n

.meas tran vdout1_58ck1610 FIND v(dout1_58) AT=810.025n

.meas tran vdout1_59ck1610 FIND v(dout1_59) AT=810.025n

.meas tran vdout1_60ck1610 FIND v(dout1_60) AT=810.025n

.meas tran vdout1_61ck1610 FIND v(dout1_61) AT=810.025n

.meas tran vdout1_62ck1610 FIND v(dout1_62) AT=810.025n

.meas tran vdout1_63ck1610 FIND v(dout1_63) AT=810.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_32ck1660 FIND v(dout1_32) AT=835.025n

.meas tran vdout1_33ck1660 FIND v(dout1_33) AT=835.025n

.meas tran vdout1_34ck1660 FIND v(dout1_34) AT=835.025n

.meas tran vdout1_35ck1660 FIND v(dout1_35) AT=835.025n

.meas tran vdout1_36ck1660 FIND v(dout1_36) AT=835.025n

.meas tran vdout1_37ck1660 FIND v(dout1_37) AT=835.025n

.meas tran vdout1_38ck1660 FIND v(dout1_38) AT=835.025n

.meas tran vdout1_39ck1660 FIND v(dout1_39) AT=835.025n

.meas tran vdout1_40ck1660 FIND v(dout1_40) AT=835.025n

.meas tran vdout1_41ck1660 FIND v(dout1_41) AT=835.025n

.meas tran vdout1_42ck1660 FIND v(dout1_42) AT=835.025n

.meas tran vdout1_43ck1660 FIND v(dout1_43) AT=835.025n

.meas tran vdout1_44ck1660 FIND v(dout1_44) AT=835.025n

.meas tran vdout1_45ck1660 FIND v(dout1_45) AT=835.025n

.meas tran vdout1_46ck1660 FIND v(dout1_46) AT=835.025n

.meas tran vdout1_47ck1660 FIND v(dout1_47) AT=835.025n

.meas tran vdout1_48ck1660 FIND v(dout1_48) AT=835.025n

.meas tran vdout1_49ck1660 FIND v(dout1_49) AT=835.025n

.meas tran vdout1_50ck1660 FIND v(dout1_50) AT=835.025n

.meas tran vdout1_51ck1660 FIND v(dout1_51) AT=835.025n

.meas tran vdout1_52ck1660 FIND v(dout1_52) AT=835.025n

.meas tran vdout1_53ck1660 FIND v(dout1_53) AT=835.025n

.meas tran vdout1_54ck1660 FIND v(dout1_54) AT=835.025n

.meas tran vdout1_55ck1660 FIND v(dout1_55) AT=835.025n

.meas tran vdout1_56ck1660 FIND v(dout1_56) AT=835.025n

.meas tran vdout1_57ck1660 FIND v(dout1_57) AT=835.025n

.meas tran vdout1_58ck1660 FIND v(dout1_58) AT=835.025n

.meas tran vdout1_59ck1660 FIND v(dout1_59) AT=835.025n

.meas tran vdout1_60ck1660 FIND v(dout1_60) AT=835.025n

.meas tran vdout1_61ck1660 FIND v(dout1_61) AT=835.025n

.meas tran vdout1_62ck1660 FIND v(dout1_62) AT=835.025n

.meas tran vdout1_63ck1660 FIND v(dout1_63) AT=835.025n

.meas tran vdout1_0ck1670 FIND v(dout1_0) AT=840.025n

.meas tran vdout1_1ck1670 FIND v(dout1_1) AT=840.025n

.meas tran vdout1_2ck1670 FIND v(dout1_2) AT=840.025n

.meas tran vdout1_3ck1670 FIND v(dout1_3) AT=840.025n

.meas tran vdout1_4ck1670 FIND v(dout1_4) AT=840.025n

.meas tran vdout1_5ck1670 FIND v(dout1_5) AT=840.025n

.meas tran vdout1_6ck1670 FIND v(dout1_6) AT=840.025n

.meas tran vdout1_7ck1670 FIND v(dout1_7) AT=840.025n

.meas tran vdout1_8ck1670 FIND v(dout1_8) AT=840.025n

.meas tran vdout1_9ck1670 FIND v(dout1_9) AT=840.025n

.meas tran vdout1_10ck1670 FIND v(dout1_10) AT=840.025n

.meas tran vdout1_11ck1670 FIND v(dout1_11) AT=840.025n

.meas tran vdout1_12ck1670 FIND v(dout1_12) AT=840.025n

.meas tran vdout1_13ck1670 FIND v(dout1_13) AT=840.025n

.meas tran vdout1_14ck1670 FIND v(dout1_14) AT=840.025n

.meas tran vdout1_15ck1670 FIND v(dout1_15) AT=840.025n

.meas tran vdout1_16ck1670 FIND v(dout1_16) AT=840.025n

.meas tran vdout1_17ck1670 FIND v(dout1_17) AT=840.025n

.meas tran vdout1_18ck1670 FIND v(dout1_18) AT=840.025n

.meas tran vdout1_19ck1670 FIND v(dout1_19) AT=840.025n

.meas tran vdout1_20ck1670 FIND v(dout1_20) AT=840.025n

.meas tran vdout1_21ck1670 FIND v(dout1_21) AT=840.025n

.meas tran vdout1_22ck1670 FIND v(dout1_22) AT=840.025n

.meas tran vdout1_23ck1670 FIND v(dout1_23) AT=840.025n

.meas tran vdout1_24ck1670 FIND v(dout1_24) AT=840.025n

.meas tran vdout1_25ck1670 FIND v(dout1_25) AT=840.025n

.meas tran vdout1_26ck1670 FIND v(dout1_26) AT=840.025n

.meas tran vdout1_27ck1670 FIND v(dout1_27) AT=840.025n

.meas tran vdout1_28ck1670 FIND v(dout1_28) AT=840.025n

.meas tran vdout1_29ck1670 FIND v(dout1_29) AT=840.025n

.meas tran vdout1_30ck1670 FIND v(dout1_30) AT=840.025n

.meas tran vdout1_31ck1670 FIND v(dout1_31) AT=840.025n

.meas tran vdout1_32ck1670 FIND v(dout1_32) AT=840.025n

.meas tran vdout1_33ck1670 FIND v(dout1_33) AT=840.025n

.meas tran vdout1_34ck1670 FIND v(dout1_34) AT=840.025n

.meas tran vdout1_35ck1670 FIND v(dout1_35) AT=840.025n

.meas tran vdout1_36ck1670 FIND v(dout1_36) AT=840.025n

.meas tran vdout1_37ck1670 FIND v(dout1_37) AT=840.025n

.meas tran vdout1_38ck1670 FIND v(dout1_38) AT=840.025n

.meas tran vdout1_39ck1670 FIND v(dout1_39) AT=840.025n

.meas tran vdout1_40ck1670 FIND v(dout1_40) AT=840.025n

.meas tran vdout1_41ck1670 FIND v(dout1_41) AT=840.025n

.meas tran vdout1_42ck1670 FIND v(dout1_42) AT=840.025n

.meas tran vdout1_43ck1670 FIND v(dout1_43) AT=840.025n

.meas tran vdout1_44ck1670 FIND v(dout1_44) AT=840.025n

.meas tran vdout1_45ck1670 FIND v(dout1_45) AT=840.025n

.meas tran vdout1_46ck1670 FIND v(dout1_46) AT=840.025n

.meas tran vdout1_47ck1670 FIND v(dout1_47) AT=840.025n

.meas tran vdout1_48ck1670 FIND v(dout1_48) AT=840.025n

.meas tran vdout1_49ck1670 FIND v(dout1_49) AT=840.025n

.meas tran vdout1_50ck1670 FIND v(dout1_50) AT=840.025n

.meas tran vdout1_51ck1670 FIND v(dout1_51) AT=840.025n

.meas tran vdout1_52ck1670 FIND v(dout1_52) AT=840.025n

.meas tran vdout1_53ck1670 FIND v(dout1_53) AT=840.025n

.meas tran vdout1_54ck1670 FIND v(dout1_54) AT=840.025n

.meas tran vdout1_55ck1670 FIND v(dout1_55) AT=840.025n

.meas tran vdout1_56ck1670 FIND v(dout1_56) AT=840.025n

.meas tran vdout1_57ck1670 FIND v(dout1_57) AT=840.025n

.meas tran vdout1_58ck1670 FIND v(dout1_58) AT=840.025n

.meas tran vdout1_59ck1670 FIND v(dout1_59) AT=840.025n

.meas tran vdout1_60ck1670 FIND v(dout1_60) AT=840.025n

.meas tran vdout1_61ck1670 FIND v(dout1_61) AT=840.025n

.meas tran vdout1_62ck1670 FIND v(dout1_62) AT=840.025n

.meas tran vdout1_63ck1670 FIND v(dout1_63) AT=840.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_22ck1690 FIND v(dout1_22) AT=850.025n

.meas tran vdout1_23ck1690 FIND v(dout1_23) AT=850.025n

.meas tran vdout1_24ck1690 FIND v(dout1_24) AT=850.025n

.meas tran vdout1_25ck1690 FIND v(dout1_25) AT=850.025n

.meas tran vdout1_26ck1690 FIND v(dout1_26) AT=850.025n

.meas tran vdout1_27ck1690 FIND v(dout1_27) AT=850.025n

.meas tran vdout1_28ck1690 FIND v(dout1_28) AT=850.025n

.meas tran vdout1_29ck1690 FIND v(dout1_29) AT=850.025n

.meas tran vdout1_30ck1690 FIND v(dout1_30) AT=850.025n

.meas tran vdout1_31ck1690 FIND v(dout1_31) AT=850.025n

.meas tran vdout1_32ck1690 FIND v(dout1_32) AT=850.025n

.meas tran vdout1_33ck1690 FIND v(dout1_33) AT=850.025n

.meas tran vdout1_34ck1690 FIND v(dout1_34) AT=850.025n

.meas tran vdout1_35ck1690 FIND v(dout1_35) AT=850.025n

.meas tran vdout1_36ck1690 FIND v(dout1_36) AT=850.025n

.meas tran vdout1_37ck1690 FIND v(dout1_37) AT=850.025n

.meas tran vdout1_38ck1690 FIND v(dout1_38) AT=850.025n

.meas tran vdout1_39ck1690 FIND v(dout1_39) AT=850.025n

.meas tran vdout1_40ck1690 FIND v(dout1_40) AT=850.025n

.meas tran vdout1_41ck1690 FIND v(dout1_41) AT=850.025n

.meas tran vdout1_42ck1690 FIND v(dout1_42) AT=850.025n

.meas tran vdout1_43ck1690 FIND v(dout1_43) AT=850.025n

.meas tran vdout1_44ck1690 FIND v(dout1_44) AT=850.025n

.meas tran vdout1_45ck1690 FIND v(dout1_45) AT=850.025n

.meas tran vdout1_46ck1690 FIND v(dout1_46) AT=850.025n

.meas tran vdout1_47ck1690 FIND v(dout1_47) AT=850.025n

.meas tran vdout1_48ck1690 FIND v(dout1_48) AT=850.025n

.meas tran vdout1_49ck1690 FIND v(dout1_49) AT=850.025n

.meas tran vdout1_50ck1690 FIND v(dout1_50) AT=850.025n

.meas tran vdout1_51ck1690 FIND v(dout1_51) AT=850.025n

.meas tran vdout1_52ck1690 FIND v(dout1_52) AT=850.025n

.meas tran vdout1_53ck1690 FIND v(dout1_53) AT=850.025n

.meas tran vdout1_54ck1690 FIND v(dout1_54) AT=850.025n

.meas tran vdout1_55ck1690 FIND v(dout1_55) AT=850.025n

.meas tran vdout1_56ck1690 FIND v(dout1_56) AT=850.025n

.meas tran vdout1_57ck1690 FIND v(dout1_57) AT=850.025n

.meas tran vdout1_58ck1690 FIND v(dout1_58) AT=850.025n

.meas tran vdout1_59ck1690 FIND v(dout1_59) AT=850.025n

.meas tran vdout1_60ck1690 FIND v(dout1_60) AT=850.025n

.meas tran vdout1_61ck1690 FIND v(dout1_61) AT=850.025n

.meas tran vdout1_62ck1690 FIND v(dout1_62) AT=850.025n

.meas tran vdout1_63ck1690 FIND v(dout1_63) AT=850.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_19ck1700 FIND v(dout1_19) AT=855.025n

.meas tran vdout1_20ck1700 FIND v(dout1_20) AT=855.025n

.meas tran vdout1_21ck1700 FIND v(dout1_21) AT=855.025n

.meas tran vdout1_22ck1700 FIND v(dout1_22) AT=855.025n

.meas tran vdout1_23ck1700 FIND v(dout1_23) AT=855.025n

.meas tran vdout1_24ck1700 FIND v(dout1_24) AT=855.025n

.meas tran vdout1_25ck1700 FIND v(dout1_25) AT=855.025n

.meas tran vdout1_26ck1700 FIND v(dout1_26) AT=855.025n

.meas tran vdout1_27ck1700 FIND v(dout1_27) AT=855.025n

.meas tran vdout1_28ck1700 FIND v(dout1_28) AT=855.025n

.meas tran vdout1_29ck1700 FIND v(dout1_29) AT=855.025n

.meas tran vdout1_30ck1700 FIND v(dout1_30) AT=855.025n

.meas tran vdout1_31ck1700 FIND v(dout1_31) AT=855.025n

.meas tran vdout1_32ck1700 FIND v(dout1_32) AT=855.025n

.meas tran vdout1_33ck1700 FIND v(dout1_33) AT=855.025n

.meas tran vdout1_34ck1700 FIND v(dout1_34) AT=855.025n

.meas tran vdout1_35ck1700 FIND v(dout1_35) AT=855.025n

.meas tran vdout1_36ck1700 FIND v(dout1_36) AT=855.025n

.meas tran vdout1_37ck1700 FIND v(dout1_37) AT=855.025n

.meas tran vdout1_38ck1700 FIND v(dout1_38) AT=855.025n

.meas tran vdout1_39ck1700 FIND v(dout1_39) AT=855.025n

.meas tran vdout1_40ck1700 FIND v(dout1_40) AT=855.025n

.meas tran vdout1_41ck1700 FIND v(dout1_41) AT=855.025n

.meas tran vdout1_42ck1700 FIND v(dout1_42) AT=855.025n

.meas tran vdout1_43ck1700 FIND v(dout1_43) AT=855.025n

.meas tran vdout1_44ck1700 FIND v(dout1_44) AT=855.025n

.meas tran vdout1_45ck1700 FIND v(dout1_45) AT=855.025n

.meas tran vdout1_46ck1700 FIND v(dout1_46) AT=855.025n

.meas tran vdout1_47ck1700 FIND v(dout1_47) AT=855.025n

.meas tran vdout1_48ck1700 FIND v(dout1_48) AT=855.025n

.meas tran vdout1_49ck1700 FIND v(dout1_49) AT=855.025n

.meas tran vdout1_50ck1700 FIND v(dout1_50) AT=855.025n

.meas tran vdout1_51ck1700 FIND v(dout1_51) AT=855.025n

.meas tran vdout1_52ck1700 FIND v(dout1_52) AT=855.025n

.meas tran vdout1_53ck1700 FIND v(dout1_53) AT=855.025n

.meas tran vdout1_54ck1700 FIND v(dout1_54) AT=855.025n

.meas tran vdout1_55ck1700 FIND v(dout1_55) AT=855.025n

.meas tran vdout1_56ck1700 FIND v(dout1_56) AT=855.025n

.meas tran vdout1_57ck1700 FIND v(dout1_57) AT=855.025n

.meas tran vdout1_58ck1700 FIND v(dout1_58) AT=855.025n

.meas tran vdout1_59ck1700 FIND v(dout1_59) AT=855.025n

.meas tran vdout1_60ck1700 FIND v(dout1_60) AT=855.025n

.meas tran vdout1_61ck1700 FIND v(dout1_61) AT=855.025n

.meas tran vdout1_62ck1700 FIND v(dout1_62) AT=855.025n

.meas tran vdout1_63ck1700 FIND v(dout1_63) AT=855.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_19ck1710 FIND v(dout1_19) AT=860.025n

.meas tran vdout1_20ck1710 FIND v(dout1_20) AT=860.025n

.meas tran vdout1_21ck1710 FIND v(dout1_21) AT=860.025n

.meas tran vdout1_22ck1710 FIND v(dout1_22) AT=860.025n

.meas tran vdout1_23ck1710 FIND v(dout1_23) AT=860.025n

.meas tran vdout1_24ck1710 FIND v(dout1_24) AT=860.025n

.meas tran vdout1_25ck1710 FIND v(dout1_25) AT=860.025n

.meas tran vdout1_26ck1710 FIND v(dout1_26) AT=860.025n

.meas tran vdout1_27ck1710 FIND v(dout1_27) AT=860.025n

.meas tran vdout1_28ck1710 FIND v(dout1_28) AT=860.025n

.meas tran vdout1_29ck1710 FIND v(dout1_29) AT=860.025n

.meas tran vdout1_30ck1710 FIND v(dout1_30) AT=860.025n

.meas tran vdout1_31ck1710 FIND v(dout1_31) AT=860.025n

.meas tran vdout1_32ck1710 FIND v(dout1_32) AT=860.025n

.meas tran vdout1_33ck1710 FIND v(dout1_33) AT=860.025n

.meas tran vdout1_34ck1710 FIND v(dout1_34) AT=860.025n

.meas tran vdout1_35ck1710 FIND v(dout1_35) AT=860.025n

.meas tran vdout1_36ck1710 FIND v(dout1_36) AT=860.025n

.meas tran vdout1_37ck1710 FIND v(dout1_37) AT=860.025n

.meas tran vdout1_38ck1710 FIND v(dout1_38) AT=860.025n

.meas tran vdout1_39ck1710 FIND v(dout1_39) AT=860.025n

.meas tran vdout1_40ck1710 FIND v(dout1_40) AT=860.025n

.meas tran vdout1_41ck1710 FIND v(dout1_41) AT=860.025n

.meas tran vdout1_42ck1710 FIND v(dout1_42) AT=860.025n

.meas tran vdout1_43ck1710 FIND v(dout1_43) AT=860.025n

.meas tran vdout1_44ck1710 FIND v(dout1_44) AT=860.025n

.meas tran vdout1_45ck1710 FIND v(dout1_45) AT=860.025n

.meas tran vdout1_46ck1710 FIND v(dout1_46) AT=860.025n

.meas tran vdout1_47ck1710 FIND v(dout1_47) AT=860.025n

.meas tran vdout1_48ck1710 FIND v(dout1_48) AT=860.025n

.meas tran vdout1_49ck1710 FIND v(dout1_49) AT=860.025n

.meas tran vdout1_50ck1710 FIND v(dout1_50) AT=860.025n

.meas tran vdout1_51ck1710 FIND v(dout1_51) AT=860.025n

.meas tran vdout1_52ck1710 FIND v(dout1_52) AT=860.025n

.meas tran vdout1_53ck1710 FIND v(dout1_53) AT=860.025n

.meas tran vdout1_54ck1710 FIND v(dout1_54) AT=860.025n

.meas tran vdout1_55ck1710 FIND v(dout1_55) AT=860.025n

.meas tran vdout1_56ck1710 FIND v(dout1_56) AT=860.025n

.meas tran vdout1_57ck1710 FIND v(dout1_57) AT=860.025n

.meas tran vdout1_58ck1710 FIND v(dout1_58) AT=860.025n

.meas tran vdout1_59ck1710 FIND v(dout1_59) AT=860.025n

.meas tran vdout1_60ck1710 FIND v(dout1_60) AT=860.025n

.meas tran vdout1_61ck1710 FIND v(dout1_61) AT=860.025n

.meas tran vdout1_62ck1710 FIND v(dout1_62) AT=860.025n

.meas tran vdout1_63ck1710 FIND v(dout1_63) AT=860.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_16ck1730 FIND v(dout1_16) AT=870.025n

.meas tran vdout1_17ck1730 FIND v(dout1_17) AT=870.025n

.meas tran vdout1_18ck1730 FIND v(dout1_18) AT=870.025n

.meas tran vdout1_19ck1730 FIND v(dout1_19) AT=870.025n

.meas tran vdout1_20ck1730 FIND v(dout1_20) AT=870.025n

.meas tran vdout1_21ck1730 FIND v(dout1_21) AT=870.025n

.meas tran vdout1_22ck1730 FIND v(dout1_22) AT=870.025n

.meas tran vdout1_23ck1730 FIND v(dout1_23) AT=870.025n

.meas tran vdout1_24ck1730 FIND v(dout1_24) AT=870.025n

.meas tran vdout1_25ck1730 FIND v(dout1_25) AT=870.025n

.meas tran vdout1_26ck1730 FIND v(dout1_26) AT=870.025n

.meas tran vdout1_27ck1730 FIND v(dout1_27) AT=870.025n

.meas tran vdout1_28ck1730 FIND v(dout1_28) AT=870.025n

.meas tran vdout1_29ck1730 FIND v(dout1_29) AT=870.025n

.meas tran vdout1_30ck1730 FIND v(dout1_30) AT=870.025n

.meas tran vdout1_31ck1730 FIND v(dout1_31) AT=870.025n

.meas tran vdout1_32ck1730 FIND v(dout1_32) AT=870.025n

.meas tran vdout1_33ck1730 FIND v(dout1_33) AT=870.025n

.meas tran vdout1_34ck1730 FIND v(dout1_34) AT=870.025n

.meas tran vdout1_35ck1730 FIND v(dout1_35) AT=870.025n

.meas tran vdout1_36ck1730 FIND v(dout1_36) AT=870.025n

.meas tran vdout1_37ck1730 FIND v(dout1_37) AT=870.025n

.meas tran vdout1_38ck1730 FIND v(dout1_38) AT=870.025n

.meas tran vdout1_39ck1730 FIND v(dout1_39) AT=870.025n

.meas tran vdout1_40ck1730 FIND v(dout1_40) AT=870.025n

.meas tran vdout1_41ck1730 FIND v(dout1_41) AT=870.025n

.meas tran vdout1_42ck1730 FIND v(dout1_42) AT=870.025n

.meas tran vdout1_43ck1730 FIND v(dout1_43) AT=870.025n

.meas tran vdout1_44ck1730 FIND v(dout1_44) AT=870.025n

.meas tran vdout1_45ck1730 FIND v(dout1_45) AT=870.025n

.meas tran vdout1_46ck1730 FIND v(dout1_46) AT=870.025n

.meas tran vdout1_47ck1730 FIND v(dout1_47) AT=870.025n

.meas tran vdout1_48ck1730 FIND v(dout1_48) AT=870.025n

.meas tran vdout1_49ck1730 FIND v(dout1_49) AT=870.025n

.meas tran vdout1_50ck1730 FIND v(dout1_50) AT=870.025n

.meas tran vdout1_51ck1730 FIND v(dout1_51) AT=870.025n

.meas tran vdout1_52ck1730 FIND v(dout1_52) AT=870.025n

.meas tran vdout1_53ck1730 FIND v(dout1_53) AT=870.025n

.meas tran vdout1_54ck1730 FIND v(dout1_54) AT=870.025n

.meas tran vdout1_55ck1730 FIND v(dout1_55) AT=870.025n

.meas tran vdout1_56ck1730 FIND v(dout1_56) AT=870.025n

.meas tran vdout1_57ck1730 FIND v(dout1_57) AT=870.025n

.meas tran vdout1_58ck1730 FIND v(dout1_58) AT=870.025n

.meas tran vdout1_59ck1730 FIND v(dout1_59) AT=870.025n

.meas tran vdout1_60ck1730 FIND v(dout1_60) AT=870.025n

.meas tran vdout1_61ck1730 FIND v(dout1_61) AT=870.025n

.meas tran vdout1_62ck1730 FIND v(dout1_62) AT=870.025n

.meas tran vdout1_63ck1730 FIND v(dout1_63) AT=870.025n

.meas tran vdout1_0ck1740 FIND v(dout1_0) AT=875.025n

.meas tran vdout1_1ck1740 FIND v(dout1_1) AT=875.025n

.meas tran vdout1_2ck1740 FIND v(dout1_2) AT=875.025n

.meas tran vdout1_3ck1740 FIND v(dout1_3) AT=875.025n

.meas tran vdout1_4ck1740 FIND v(dout1_4) AT=875.025n

.meas tran vdout1_5ck1740 FIND v(dout1_5) AT=875.025n

.meas tran vdout1_6ck1740 FIND v(dout1_6) AT=875.025n

.meas tran vdout1_7ck1740 FIND v(dout1_7) AT=875.025n

.meas tran vdout1_8ck1740 FIND v(dout1_8) AT=875.025n

.meas tran vdout1_9ck1740 FIND v(dout1_9) AT=875.025n

.meas tran vdout1_10ck1740 FIND v(dout1_10) AT=875.025n

.meas tran vdout1_11ck1740 FIND v(dout1_11) AT=875.025n

.meas tran vdout1_12ck1740 FIND v(dout1_12) AT=875.025n

.meas tran vdout1_13ck1740 FIND v(dout1_13) AT=875.025n

.meas tran vdout1_14ck1740 FIND v(dout1_14) AT=875.025n

.meas tran vdout1_15ck1740 FIND v(dout1_15) AT=875.025n

.meas tran vdout1_16ck1740 FIND v(dout1_16) AT=875.025n

.meas tran vdout1_17ck1740 FIND v(dout1_17) AT=875.025n

.meas tran vdout1_18ck1740 FIND v(dout1_18) AT=875.025n

.meas tran vdout1_19ck1740 FIND v(dout1_19) AT=875.025n

.meas tran vdout1_20ck1740 FIND v(dout1_20) AT=875.025n

.meas tran vdout1_21ck1740 FIND v(dout1_21) AT=875.025n

.meas tran vdout1_22ck1740 FIND v(dout1_22) AT=875.025n

.meas tran vdout1_23ck1740 FIND v(dout1_23) AT=875.025n

.meas tran vdout1_24ck1740 FIND v(dout1_24) AT=875.025n

.meas tran vdout1_25ck1740 FIND v(dout1_25) AT=875.025n

.meas tran vdout1_26ck1740 FIND v(dout1_26) AT=875.025n

.meas tran vdout1_27ck1740 FIND v(dout1_27) AT=875.025n

.meas tran vdout1_28ck1740 FIND v(dout1_28) AT=875.025n

.meas tran vdout1_29ck1740 FIND v(dout1_29) AT=875.025n

.meas tran vdout1_30ck1740 FIND v(dout1_30) AT=875.025n

.meas tran vdout1_31ck1740 FIND v(dout1_31) AT=875.025n

.meas tran vdout1_32ck1740 FIND v(dout1_32) AT=875.025n

.meas tran vdout1_33ck1740 FIND v(dout1_33) AT=875.025n

.meas tran vdout1_34ck1740 FIND v(dout1_34) AT=875.025n

.meas tran vdout1_35ck1740 FIND v(dout1_35) AT=875.025n

.meas tran vdout1_36ck1740 FIND v(dout1_36) AT=875.025n

.meas tran vdout1_37ck1740 FIND v(dout1_37) AT=875.025n

.meas tran vdout1_38ck1740 FIND v(dout1_38) AT=875.025n

.meas tran vdout1_39ck1740 FIND v(dout1_39) AT=875.025n

.meas tran vdout1_40ck1740 FIND v(dout1_40) AT=875.025n

.meas tran vdout1_41ck1740 FIND v(dout1_41) AT=875.025n

.meas tran vdout1_42ck1740 FIND v(dout1_42) AT=875.025n

.meas tran vdout1_43ck1740 FIND v(dout1_43) AT=875.025n

.meas tran vdout1_44ck1740 FIND v(dout1_44) AT=875.025n

.meas tran vdout1_45ck1740 FIND v(dout1_45) AT=875.025n

.meas tran vdout1_46ck1740 FIND v(dout1_46) AT=875.025n

.meas tran vdout1_47ck1740 FIND v(dout1_47) AT=875.025n

.meas tran vdout1_48ck1740 FIND v(dout1_48) AT=875.025n

.meas tran vdout1_49ck1740 FIND v(dout1_49) AT=875.025n

.meas tran vdout1_50ck1740 FIND v(dout1_50) AT=875.025n

.meas tran vdout1_51ck1740 FIND v(dout1_51) AT=875.025n

.meas tran vdout1_52ck1740 FIND v(dout1_52) AT=875.025n

.meas tran vdout1_53ck1740 FIND v(dout1_53) AT=875.025n

.meas tran vdout1_54ck1740 FIND v(dout1_54) AT=875.025n

.meas tran vdout1_55ck1740 FIND v(dout1_55) AT=875.025n

.meas tran vdout1_56ck1740 FIND v(dout1_56) AT=875.025n

.meas tran vdout1_57ck1740 FIND v(dout1_57) AT=875.025n

.meas tran vdout1_58ck1740 FIND v(dout1_58) AT=875.025n

.meas tran vdout1_59ck1740 FIND v(dout1_59) AT=875.025n

.meas tran vdout1_60ck1740 FIND v(dout1_60) AT=875.025n

.meas tran vdout1_61ck1740 FIND v(dout1_61) AT=875.025n

.meas tran vdout1_62ck1740 FIND v(dout1_62) AT=875.025n

.meas tran vdout1_63ck1740 FIND v(dout1_63) AT=875.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_16ck1760 FIND v(dout1_16) AT=885.025n

.meas tran vdout1_17ck1760 FIND v(dout1_17) AT=885.025n

.meas tran vdout1_18ck1760 FIND v(dout1_18) AT=885.025n

.meas tran vdout1_19ck1760 FIND v(dout1_19) AT=885.025n

.meas tran vdout1_20ck1760 FIND v(dout1_20) AT=885.025n

.meas tran vdout1_21ck1760 FIND v(dout1_21) AT=885.025n

.meas tran vdout1_22ck1760 FIND v(dout1_22) AT=885.025n

.meas tran vdout1_23ck1760 FIND v(dout1_23) AT=885.025n

.meas tran vdout1_24ck1760 FIND v(dout1_24) AT=885.025n

.meas tran vdout1_25ck1760 FIND v(dout1_25) AT=885.025n

.meas tran vdout1_26ck1760 FIND v(dout1_26) AT=885.025n

.meas tran vdout1_27ck1760 FIND v(dout1_27) AT=885.025n

.meas tran vdout1_28ck1760 FIND v(dout1_28) AT=885.025n

.meas tran vdout1_29ck1760 FIND v(dout1_29) AT=885.025n

.meas tran vdout1_30ck1760 FIND v(dout1_30) AT=885.025n

.meas tran vdout1_31ck1760 FIND v(dout1_31) AT=885.025n

.meas tran vdout1_32ck1760 FIND v(dout1_32) AT=885.025n

.meas tran vdout1_33ck1760 FIND v(dout1_33) AT=885.025n

.meas tran vdout1_34ck1760 FIND v(dout1_34) AT=885.025n

.meas tran vdout1_35ck1760 FIND v(dout1_35) AT=885.025n

.meas tran vdout1_36ck1760 FIND v(dout1_36) AT=885.025n

.meas tran vdout1_37ck1760 FIND v(dout1_37) AT=885.025n

.meas tran vdout1_38ck1760 FIND v(dout1_38) AT=885.025n

.meas tran vdout1_39ck1760 FIND v(dout1_39) AT=885.025n

.meas tran vdout1_40ck1760 FIND v(dout1_40) AT=885.025n

.meas tran vdout1_41ck1760 FIND v(dout1_41) AT=885.025n

.meas tran vdout1_42ck1760 FIND v(dout1_42) AT=885.025n

.meas tran vdout1_43ck1760 FIND v(dout1_43) AT=885.025n

.meas tran vdout1_44ck1760 FIND v(dout1_44) AT=885.025n

.meas tran vdout1_45ck1760 FIND v(dout1_45) AT=885.025n

.meas tran vdout1_46ck1760 FIND v(dout1_46) AT=885.025n

.meas tran vdout1_47ck1760 FIND v(dout1_47) AT=885.025n

.meas tran vdout1_48ck1760 FIND v(dout1_48) AT=885.025n

.meas tran vdout1_49ck1760 FIND v(dout1_49) AT=885.025n

.meas tran vdout1_50ck1760 FIND v(dout1_50) AT=885.025n

.meas tran vdout1_51ck1760 FIND v(dout1_51) AT=885.025n

.meas tran vdout1_52ck1760 FIND v(dout1_52) AT=885.025n

.meas tran vdout1_53ck1760 FIND v(dout1_53) AT=885.025n

.meas tran vdout1_54ck1760 FIND v(dout1_54) AT=885.025n

.meas tran vdout1_55ck1760 FIND v(dout1_55) AT=885.025n

.meas tran vdout1_56ck1760 FIND v(dout1_56) AT=885.025n

.meas tran vdout1_57ck1760 FIND v(dout1_57) AT=885.025n

.meas tran vdout1_58ck1760 FIND v(dout1_58) AT=885.025n

.meas tran vdout1_59ck1760 FIND v(dout1_59) AT=885.025n

.meas tran vdout1_60ck1760 FIND v(dout1_60) AT=885.025n

.meas tran vdout1_61ck1760 FIND v(dout1_61) AT=885.025n

.meas tran vdout1_62ck1760 FIND v(dout1_62) AT=885.025n

.meas tran vdout1_63ck1760 FIND v(dout1_63) AT=885.025n

.meas tran vdout1_0ck1770 FIND v(dout1_0) AT=890.025n

.meas tran vdout1_1ck1770 FIND v(dout1_1) AT=890.025n

.meas tran vdout1_2ck1770 FIND v(dout1_2) AT=890.025n

.meas tran vdout1_3ck1770 FIND v(dout1_3) AT=890.025n

.meas tran vdout1_4ck1770 FIND v(dout1_4) AT=890.025n

.meas tran vdout1_5ck1770 FIND v(dout1_5) AT=890.025n

.meas tran vdout1_6ck1770 FIND v(dout1_6) AT=890.025n

.meas tran vdout1_7ck1770 FIND v(dout1_7) AT=890.025n

.meas tran vdout1_8ck1770 FIND v(dout1_8) AT=890.025n

.meas tran vdout1_9ck1770 FIND v(dout1_9) AT=890.025n

.meas tran vdout1_10ck1770 FIND v(dout1_10) AT=890.025n

.meas tran vdout1_11ck1770 FIND v(dout1_11) AT=890.025n

.meas tran vdout1_12ck1770 FIND v(dout1_12) AT=890.025n

.meas tran vdout1_13ck1770 FIND v(dout1_13) AT=890.025n

.meas tran vdout1_14ck1770 FIND v(dout1_14) AT=890.025n

.meas tran vdout1_15ck1770 FIND v(dout1_15) AT=890.025n

.meas tran vdout1_16ck1770 FIND v(dout1_16) AT=890.025n

.meas tran vdout1_17ck1770 FIND v(dout1_17) AT=890.025n

.meas tran vdout1_18ck1770 FIND v(dout1_18) AT=890.025n

.meas tran vdout1_19ck1770 FIND v(dout1_19) AT=890.025n

.meas tran vdout1_20ck1770 FIND v(dout1_20) AT=890.025n

.meas tran vdout1_21ck1770 FIND v(dout1_21) AT=890.025n

.meas tran vdout1_22ck1770 FIND v(dout1_22) AT=890.025n

.meas tran vdout1_23ck1770 FIND v(dout1_23) AT=890.025n

.meas tran vdout1_24ck1770 FIND v(dout1_24) AT=890.025n

.meas tran vdout1_25ck1770 FIND v(dout1_25) AT=890.025n

.meas tran vdout1_26ck1770 FIND v(dout1_26) AT=890.025n

.meas tran vdout1_27ck1770 FIND v(dout1_27) AT=890.025n

.meas tran vdout1_28ck1770 FIND v(dout1_28) AT=890.025n

.meas tran vdout1_29ck1770 FIND v(dout1_29) AT=890.025n

.meas tran vdout1_30ck1770 FIND v(dout1_30) AT=890.025n

.meas tran vdout1_31ck1770 FIND v(dout1_31) AT=890.025n

.meas tran vdout1_32ck1770 FIND v(dout1_32) AT=890.025n

.meas tran vdout1_33ck1770 FIND v(dout1_33) AT=890.025n

.meas tran vdout1_34ck1770 FIND v(dout1_34) AT=890.025n

.meas tran vdout1_35ck1770 FIND v(dout1_35) AT=890.025n

.meas tran vdout1_36ck1770 FIND v(dout1_36) AT=890.025n

.meas tran vdout1_37ck1770 FIND v(dout1_37) AT=890.025n

.meas tran vdout1_38ck1770 FIND v(dout1_38) AT=890.025n

.meas tran vdout1_39ck1770 FIND v(dout1_39) AT=890.025n

.meas tran vdout1_40ck1770 FIND v(dout1_40) AT=890.025n

.meas tran vdout1_41ck1770 FIND v(dout1_41) AT=890.025n

.meas tran vdout1_42ck1770 FIND v(dout1_42) AT=890.025n

.meas tran vdout1_43ck1770 FIND v(dout1_43) AT=890.025n

.meas tran vdout1_44ck1770 FIND v(dout1_44) AT=890.025n

.meas tran vdout1_45ck1770 FIND v(dout1_45) AT=890.025n

.meas tran vdout1_46ck1770 FIND v(dout1_46) AT=890.025n

.meas tran vdout1_47ck1770 FIND v(dout1_47) AT=890.025n

.meas tran vdout1_48ck1770 FIND v(dout1_48) AT=890.025n

.meas tran vdout1_49ck1770 FIND v(dout1_49) AT=890.025n

.meas tran vdout1_50ck1770 FIND v(dout1_50) AT=890.025n

.meas tran vdout1_51ck1770 FIND v(dout1_51) AT=890.025n

.meas tran vdout1_52ck1770 FIND v(dout1_52) AT=890.025n

.meas tran vdout1_53ck1770 FIND v(dout1_53) AT=890.025n

.meas tran vdout1_54ck1770 FIND v(dout1_54) AT=890.025n

.meas tran vdout1_55ck1770 FIND v(dout1_55) AT=890.025n

.meas tran vdout1_56ck1770 FIND v(dout1_56) AT=890.025n

.meas tran vdout1_57ck1770 FIND v(dout1_57) AT=890.025n

.meas tran vdout1_58ck1770 FIND v(dout1_58) AT=890.025n

.meas tran vdout1_59ck1770 FIND v(dout1_59) AT=890.025n

.meas tran vdout1_60ck1770 FIND v(dout1_60) AT=890.025n

.meas tran vdout1_61ck1770 FIND v(dout1_61) AT=890.025n

.meas tran vdout1_62ck1770 FIND v(dout1_62) AT=890.025n

.meas tran vdout1_63ck1770 FIND v(dout1_63) AT=890.025n

.meas tran vdout1_0ck1800 FIND v(dout1_0) AT=905.025n

.meas tran vdout1_1ck1800 FIND v(dout1_1) AT=905.025n

.meas tran vdout1_2ck1800 FIND v(dout1_2) AT=905.025n

.meas tran vdout1_3ck1800 FIND v(dout1_3) AT=905.025n

.meas tran vdout1_4ck1800 FIND v(dout1_4) AT=905.025n

.meas tran vdout1_5ck1800 FIND v(dout1_5) AT=905.025n

.meas tran vdout1_6ck1800 FIND v(dout1_6) AT=905.025n

.meas tran vdout1_7ck1800 FIND v(dout1_7) AT=905.025n

.meas tran vdout1_8ck1800 FIND v(dout1_8) AT=905.025n

.meas tran vdout1_9ck1800 FIND v(dout1_9) AT=905.025n

.meas tran vdout1_10ck1800 FIND v(dout1_10) AT=905.025n

.meas tran vdout1_11ck1800 FIND v(dout1_11) AT=905.025n

.meas tran vdout1_12ck1800 FIND v(dout1_12) AT=905.025n

.meas tran vdout1_13ck1800 FIND v(dout1_13) AT=905.025n

.meas tran vdout1_14ck1800 FIND v(dout1_14) AT=905.025n

.meas tran vdout1_15ck1800 FIND v(dout1_15) AT=905.025n

.meas tran vdout1_16ck1800 FIND v(dout1_16) AT=905.025n

.meas tran vdout1_17ck1800 FIND v(dout1_17) AT=905.025n

.meas tran vdout1_18ck1800 FIND v(dout1_18) AT=905.025n

.meas tran vdout1_19ck1800 FIND v(dout1_19) AT=905.025n

.meas tran vdout1_20ck1800 FIND v(dout1_20) AT=905.025n

.meas tran vdout1_21ck1800 FIND v(dout1_21) AT=905.025n

.meas tran vdout1_22ck1800 FIND v(dout1_22) AT=905.025n

.meas tran vdout1_23ck1800 FIND v(dout1_23) AT=905.025n

.meas tran vdout1_24ck1800 FIND v(dout1_24) AT=905.025n

.meas tran vdout1_25ck1800 FIND v(dout1_25) AT=905.025n

.meas tran vdout1_26ck1800 FIND v(dout1_26) AT=905.025n

.meas tran vdout1_27ck1800 FIND v(dout1_27) AT=905.025n

.meas tran vdout1_28ck1800 FIND v(dout1_28) AT=905.025n

.meas tran vdout1_29ck1800 FIND v(dout1_29) AT=905.025n

.meas tran vdout1_30ck1800 FIND v(dout1_30) AT=905.025n

.meas tran vdout1_31ck1800 FIND v(dout1_31) AT=905.025n

.meas tran vdout1_32ck1800 FIND v(dout1_32) AT=905.025n

.meas tran vdout1_33ck1800 FIND v(dout1_33) AT=905.025n

.meas tran vdout1_34ck1800 FIND v(dout1_34) AT=905.025n

.meas tran vdout1_35ck1800 FIND v(dout1_35) AT=905.025n

.meas tran vdout1_36ck1800 FIND v(dout1_36) AT=905.025n

.meas tran vdout1_37ck1800 FIND v(dout1_37) AT=905.025n

.meas tran vdout1_38ck1800 FIND v(dout1_38) AT=905.025n

.meas tran vdout1_39ck1800 FIND v(dout1_39) AT=905.025n

.meas tran vdout1_40ck1800 FIND v(dout1_40) AT=905.025n

.meas tran vdout1_41ck1800 FIND v(dout1_41) AT=905.025n

.meas tran vdout1_42ck1800 FIND v(dout1_42) AT=905.025n

.meas tran vdout1_43ck1800 FIND v(dout1_43) AT=905.025n

.meas tran vdout1_44ck1800 FIND v(dout1_44) AT=905.025n

.meas tran vdout1_45ck1800 FIND v(dout1_45) AT=905.025n

.meas tran vdout1_46ck1800 FIND v(dout1_46) AT=905.025n

.meas tran vdout1_47ck1800 FIND v(dout1_47) AT=905.025n

.meas tran vdout1_48ck1800 FIND v(dout1_48) AT=905.025n

.meas tran vdout1_49ck1800 FIND v(dout1_49) AT=905.025n

.meas tran vdout1_50ck1800 FIND v(dout1_50) AT=905.025n

.meas tran vdout1_51ck1800 FIND v(dout1_51) AT=905.025n

.meas tran vdout1_52ck1800 FIND v(dout1_52) AT=905.025n

.meas tran vdout1_53ck1800 FIND v(dout1_53) AT=905.025n

.meas tran vdout1_54ck1800 FIND v(dout1_54) AT=905.025n

.meas tran vdout1_55ck1800 FIND v(dout1_55) AT=905.025n

.meas tran vdout1_56ck1800 FIND v(dout1_56) AT=905.025n

.meas tran vdout1_57ck1800 FIND v(dout1_57) AT=905.025n

.meas tran vdout1_58ck1800 FIND v(dout1_58) AT=905.025n

.meas tran vdout1_59ck1800 FIND v(dout1_59) AT=905.025n

.meas tran vdout1_60ck1800 FIND v(dout1_60) AT=905.025n

.meas tran vdout1_61ck1800 FIND v(dout1_61) AT=905.025n

.meas tran vdout1_62ck1800 FIND v(dout1_62) AT=905.025n

.meas tran vdout1_63ck1800 FIND v(dout1_63) AT=905.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_16ck1820 FIND v(dout1_16) AT=915.025n

.meas tran vdout1_17ck1820 FIND v(dout1_17) AT=915.025n

.meas tran vdout1_18ck1820 FIND v(dout1_18) AT=915.025n

.meas tran vdout1_19ck1820 FIND v(dout1_19) AT=915.025n

.meas tran vdout1_20ck1820 FIND v(dout1_20) AT=915.025n

.meas tran vdout1_21ck1820 FIND v(dout1_21) AT=915.025n

.meas tran vdout1_22ck1820 FIND v(dout1_22) AT=915.025n

.meas tran vdout1_23ck1820 FIND v(dout1_23) AT=915.025n

.meas tran vdout1_24ck1820 FIND v(dout1_24) AT=915.025n

.meas tran vdout1_25ck1820 FIND v(dout1_25) AT=915.025n

.meas tran vdout1_26ck1820 FIND v(dout1_26) AT=915.025n

.meas tran vdout1_27ck1820 FIND v(dout1_27) AT=915.025n

.meas tran vdout1_28ck1820 FIND v(dout1_28) AT=915.025n

.meas tran vdout1_29ck1820 FIND v(dout1_29) AT=915.025n

.meas tran vdout1_30ck1820 FIND v(dout1_30) AT=915.025n

.meas tran vdout1_31ck1820 FIND v(dout1_31) AT=915.025n

.meas tran vdout1_32ck1820 FIND v(dout1_32) AT=915.025n

.meas tran vdout1_33ck1820 FIND v(dout1_33) AT=915.025n

.meas tran vdout1_34ck1820 FIND v(dout1_34) AT=915.025n

.meas tran vdout1_35ck1820 FIND v(dout1_35) AT=915.025n

.meas tran vdout1_36ck1820 FIND v(dout1_36) AT=915.025n

.meas tran vdout1_37ck1820 FIND v(dout1_37) AT=915.025n

.meas tran vdout1_38ck1820 FIND v(dout1_38) AT=915.025n

.meas tran vdout1_39ck1820 FIND v(dout1_39) AT=915.025n

.meas tran vdout1_40ck1820 FIND v(dout1_40) AT=915.025n

.meas tran vdout1_41ck1820 FIND v(dout1_41) AT=915.025n

.meas tran vdout1_42ck1820 FIND v(dout1_42) AT=915.025n

.meas tran vdout1_43ck1820 FIND v(dout1_43) AT=915.025n

.meas tran vdout1_44ck1820 FIND v(dout1_44) AT=915.025n

.meas tran vdout1_45ck1820 FIND v(dout1_45) AT=915.025n

.meas tran vdout1_46ck1820 FIND v(dout1_46) AT=915.025n

.meas tran vdout1_47ck1820 FIND v(dout1_47) AT=915.025n

.meas tran vdout1_48ck1820 FIND v(dout1_48) AT=915.025n

.meas tran vdout1_49ck1820 FIND v(dout1_49) AT=915.025n

.meas tran vdout1_50ck1820 FIND v(dout1_50) AT=915.025n

.meas tran vdout1_51ck1820 FIND v(dout1_51) AT=915.025n

.meas tran vdout1_52ck1820 FIND v(dout1_52) AT=915.025n

.meas tran vdout1_53ck1820 FIND v(dout1_53) AT=915.025n

.meas tran vdout1_54ck1820 FIND v(dout1_54) AT=915.025n

.meas tran vdout1_55ck1820 FIND v(dout1_55) AT=915.025n

.meas tran vdout1_56ck1820 FIND v(dout1_56) AT=915.025n

.meas tran vdout1_57ck1820 FIND v(dout1_57) AT=915.025n

.meas tran vdout1_58ck1820 FIND v(dout1_58) AT=915.025n

.meas tran vdout1_59ck1820 FIND v(dout1_59) AT=915.025n

.meas tran vdout1_60ck1820 FIND v(dout1_60) AT=915.025n

.meas tran vdout1_61ck1820 FIND v(dout1_61) AT=915.025n

.meas tran vdout1_62ck1820 FIND v(dout1_62) AT=915.025n

.meas tran vdout1_63ck1820 FIND v(dout1_63) AT=915.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_23ck1830 FIND v(dout1_23) AT=920.025n

.meas tran vdout1_24ck1830 FIND v(dout1_24) AT=920.025n

.meas tran vdout1_25ck1830 FIND v(dout1_25) AT=920.025n

.meas tran vdout1_26ck1830 FIND v(dout1_26) AT=920.025n

.meas tran vdout1_27ck1830 FIND v(dout1_27) AT=920.025n

.meas tran vdout1_28ck1830 FIND v(dout1_28) AT=920.025n

.meas tran vdout1_29ck1830 FIND v(dout1_29) AT=920.025n

.meas tran vdout1_30ck1830 FIND v(dout1_30) AT=920.025n

.meas tran vdout1_31ck1830 FIND v(dout1_31) AT=920.025n

.meas tran vdout1_32ck1830 FIND v(dout1_32) AT=920.025n

.meas tran vdout1_33ck1830 FIND v(dout1_33) AT=920.025n

.meas tran vdout1_34ck1830 FIND v(dout1_34) AT=920.025n

.meas tran vdout1_35ck1830 FIND v(dout1_35) AT=920.025n

.meas tran vdout1_36ck1830 FIND v(dout1_36) AT=920.025n

.meas tran vdout1_37ck1830 FIND v(dout1_37) AT=920.025n

.meas tran vdout1_38ck1830 FIND v(dout1_38) AT=920.025n

.meas tran vdout1_39ck1830 FIND v(dout1_39) AT=920.025n

.meas tran vdout1_40ck1830 FIND v(dout1_40) AT=920.025n

.meas tran vdout1_41ck1830 FIND v(dout1_41) AT=920.025n

.meas tran vdout1_42ck1830 FIND v(dout1_42) AT=920.025n

.meas tran vdout1_43ck1830 FIND v(dout1_43) AT=920.025n

.meas tran vdout1_44ck1830 FIND v(dout1_44) AT=920.025n

.meas tran vdout1_45ck1830 FIND v(dout1_45) AT=920.025n

.meas tran vdout1_46ck1830 FIND v(dout1_46) AT=920.025n

.meas tran vdout1_47ck1830 FIND v(dout1_47) AT=920.025n

.meas tran vdout1_48ck1830 FIND v(dout1_48) AT=920.025n

.meas tran vdout1_49ck1830 FIND v(dout1_49) AT=920.025n

.meas tran vdout1_50ck1830 FIND v(dout1_50) AT=920.025n

.meas tran vdout1_51ck1830 FIND v(dout1_51) AT=920.025n

.meas tran vdout1_52ck1830 FIND v(dout1_52) AT=920.025n

.meas tran vdout1_53ck1830 FIND v(dout1_53) AT=920.025n

.meas tran vdout1_54ck1830 FIND v(dout1_54) AT=920.025n

.meas tran vdout1_55ck1830 FIND v(dout1_55) AT=920.025n

.meas tran vdout1_56ck1830 FIND v(dout1_56) AT=920.025n

.meas tran vdout1_57ck1830 FIND v(dout1_57) AT=920.025n

.meas tran vdout1_58ck1830 FIND v(dout1_58) AT=920.025n

.meas tran vdout1_59ck1830 FIND v(dout1_59) AT=920.025n

.meas tran vdout1_60ck1830 FIND v(dout1_60) AT=920.025n

.meas tran vdout1_61ck1830 FIND v(dout1_61) AT=920.025n

.meas tran vdout1_62ck1830 FIND v(dout1_62) AT=920.025n

.meas tran vdout1_63ck1830 FIND v(dout1_63) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_32ck1840 FIND v(dout1_32) AT=925.025n

.meas tran vdout1_33ck1840 FIND v(dout1_33) AT=925.025n

.meas tran vdout1_34ck1840 FIND v(dout1_34) AT=925.025n

.meas tran vdout1_35ck1840 FIND v(dout1_35) AT=925.025n

.meas tran vdout1_36ck1840 FIND v(dout1_36) AT=925.025n

.meas tran vdout1_37ck1840 FIND v(dout1_37) AT=925.025n

.meas tran vdout1_38ck1840 FIND v(dout1_38) AT=925.025n

.meas tran vdout1_39ck1840 FIND v(dout1_39) AT=925.025n

.meas tran vdout1_40ck1840 FIND v(dout1_40) AT=925.025n

.meas tran vdout1_41ck1840 FIND v(dout1_41) AT=925.025n

.meas tran vdout1_42ck1840 FIND v(dout1_42) AT=925.025n

.meas tran vdout1_43ck1840 FIND v(dout1_43) AT=925.025n

.meas tran vdout1_44ck1840 FIND v(dout1_44) AT=925.025n

.meas tran vdout1_45ck1840 FIND v(dout1_45) AT=925.025n

.meas tran vdout1_46ck1840 FIND v(dout1_46) AT=925.025n

.meas tran vdout1_47ck1840 FIND v(dout1_47) AT=925.025n

.meas tran vdout1_48ck1840 FIND v(dout1_48) AT=925.025n

.meas tran vdout1_49ck1840 FIND v(dout1_49) AT=925.025n

.meas tran vdout1_50ck1840 FIND v(dout1_50) AT=925.025n

.meas tran vdout1_51ck1840 FIND v(dout1_51) AT=925.025n

.meas tran vdout1_52ck1840 FIND v(dout1_52) AT=925.025n

.meas tran vdout1_53ck1840 FIND v(dout1_53) AT=925.025n

.meas tran vdout1_54ck1840 FIND v(dout1_54) AT=925.025n

.meas tran vdout1_55ck1840 FIND v(dout1_55) AT=925.025n

.meas tran vdout1_56ck1840 FIND v(dout1_56) AT=925.025n

.meas tran vdout1_57ck1840 FIND v(dout1_57) AT=925.025n

.meas tran vdout1_58ck1840 FIND v(dout1_58) AT=925.025n

.meas tran vdout1_59ck1840 FIND v(dout1_59) AT=925.025n

.meas tran vdout1_60ck1840 FIND v(dout1_60) AT=925.025n

.meas tran vdout1_61ck1840 FIND v(dout1_61) AT=925.025n

.meas tran vdout1_62ck1840 FIND v(dout1_62) AT=925.025n

.meas tran vdout1_63ck1840 FIND v(dout1_63) AT=925.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_8ck1860 FIND v(dout1_8) AT=935.025n

.meas tran vdout1_9ck1860 FIND v(dout1_9) AT=935.025n

.meas tran vdout1_10ck1860 FIND v(dout1_10) AT=935.025n

.meas tran vdout1_11ck1860 FIND v(dout1_11) AT=935.025n

.meas tran vdout1_12ck1860 FIND v(dout1_12) AT=935.025n

.meas tran vdout1_13ck1860 FIND v(dout1_13) AT=935.025n

.meas tran vdout1_14ck1860 FIND v(dout1_14) AT=935.025n

.meas tran vdout1_15ck1860 FIND v(dout1_15) AT=935.025n

.meas tran vdout1_16ck1860 FIND v(dout1_16) AT=935.025n

.meas tran vdout1_17ck1860 FIND v(dout1_17) AT=935.025n

.meas tran vdout1_18ck1860 FIND v(dout1_18) AT=935.025n

.meas tran vdout1_19ck1860 FIND v(dout1_19) AT=935.025n

.meas tran vdout1_20ck1860 FIND v(dout1_20) AT=935.025n

.meas tran vdout1_21ck1860 FIND v(dout1_21) AT=935.025n

.meas tran vdout1_22ck1860 FIND v(dout1_22) AT=935.025n

.meas tran vdout1_23ck1860 FIND v(dout1_23) AT=935.025n

.meas tran vdout1_24ck1860 FIND v(dout1_24) AT=935.025n

.meas tran vdout1_25ck1860 FIND v(dout1_25) AT=935.025n

.meas tran vdout1_26ck1860 FIND v(dout1_26) AT=935.025n

.meas tran vdout1_27ck1860 FIND v(dout1_27) AT=935.025n

.meas tran vdout1_28ck1860 FIND v(dout1_28) AT=935.025n

.meas tran vdout1_29ck1860 FIND v(dout1_29) AT=935.025n

.meas tran vdout1_30ck1860 FIND v(dout1_30) AT=935.025n

.meas tran vdout1_31ck1860 FIND v(dout1_31) AT=935.025n

.meas tran vdout1_32ck1860 FIND v(dout1_32) AT=935.025n

.meas tran vdout1_33ck1860 FIND v(dout1_33) AT=935.025n

.meas tran vdout1_34ck1860 FIND v(dout1_34) AT=935.025n

.meas tran vdout1_35ck1860 FIND v(dout1_35) AT=935.025n

.meas tran vdout1_36ck1860 FIND v(dout1_36) AT=935.025n

.meas tran vdout1_37ck1860 FIND v(dout1_37) AT=935.025n

.meas tran vdout1_38ck1860 FIND v(dout1_38) AT=935.025n

.meas tran vdout1_39ck1860 FIND v(dout1_39) AT=935.025n

.meas tran vdout1_40ck1860 FIND v(dout1_40) AT=935.025n

.meas tran vdout1_41ck1860 FIND v(dout1_41) AT=935.025n

.meas tran vdout1_42ck1860 FIND v(dout1_42) AT=935.025n

.meas tran vdout1_43ck1860 FIND v(dout1_43) AT=935.025n

.meas tran vdout1_44ck1860 FIND v(dout1_44) AT=935.025n

.meas tran vdout1_45ck1860 FIND v(dout1_45) AT=935.025n

.meas tran vdout1_46ck1860 FIND v(dout1_46) AT=935.025n

.meas tran vdout1_47ck1860 FIND v(dout1_47) AT=935.025n

.meas tran vdout1_48ck1860 FIND v(dout1_48) AT=935.025n

.meas tran vdout1_49ck1860 FIND v(dout1_49) AT=935.025n

.meas tran vdout1_50ck1860 FIND v(dout1_50) AT=935.025n

.meas tran vdout1_51ck1860 FIND v(dout1_51) AT=935.025n

.meas tran vdout1_52ck1860 FIND v(dout1_52) AT=935.025n

.meas tran vdout1_53ck1860 FIND v(dout1_53) AT=935.025n

.meas tran vdout1_54ck1860 FIND v(dout1_54) AT=935.025n

.meas tran vdout1_55ck1860 FIND v(dout1_55) AT=935.025n

.meas tran vdout1_56ck1860 FIND v(dout1_56) AT=935.025n

.meas tran vdout1_57ck1860 FIND v(dout1_57) AT=935.025n

.meas tran vdout1_58ck1860 FIND v(dout1_58) AT=935.025n

.meas tran vdout1_59ck1860 FIND v(dout1_59) AT=935.025n

.meas tran vdout1_60ck1860 FIND v(dout1_60) AT=935.025n

.meas tran vdout1_61ck1860 FIND v(dout1_61) AT=935.025n

.meas tran vdout1_62ck1860 FIND v(dout1_62) AT=935.025n

.meas tran vdout1_63ck1860 FIND v(dout1_63) AT=935.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_23ck1890 FIND v(dout1_23) AT=950.025n

.meas tran vdout1_24ck1890 FIND v(dout1_24) AT=950.025n

.meas tran vdout1_25ck1890 FIND v(dout1_25) AT=950.025n

.meas tran vdout1_26ck1890 FIND v(dout1_26) AT=950.025n

.meas tran vdout1_27ck1890 FIND v(dout1_27) AT=950.025n

.meas tran vdout1_28ck1890 FIND v(dout1_28) AT=950.025n

.meas tran vdout1_29ck1890 FIND v(dout1_29) AT=950.025n

.meas tran vdout1_30ck1890 FIND v(dout1_30) AT=950.025n

.meas tran vdout1_31ck1890 FIND v(dout1_31) AT=950.025n

.meas tran vdout1_32ck1890 FIND v(dout1_32) AT=950.025n

.meas tran vdout1_33ck1890 FIND v(dout1_33) AT=950.025n

.meas tran vdout1_34ck1890 FIND v(dout1_34) AT=950.025n

.meas tran vdout1_35ck1890 FIND v(dout1_35) AT=950.025n

.meas tran vdout1_36ck1890 FIND v(dout1_36) AT=950.025n

.meas tran vdout1_37ck1890 FIND v(dout1_37) AT=950.025n

.meas tran vdout1_38ck1890 FIND v(dout1_38) AT=950.025n

.meas tran vdout1_39ck1890 FIND v(dout1_39) AT=950.025n

.meas tran vdout1_40ck1890 FIND v(dout1_40) AT=950.025n

.meas tran vdout1_41ck1890 FIND v(dout1_41) AT=950.025n

.meas tran vdout1_42ck1890 FIND v(dout1_42) AT=950.025n

.meas tran vdout1_43ck1890 FIND v(dout1_43) AT=950.025n

.meas tran vdout1_44ck1890 FIND v(dout1_44) AT=950.025n

.meas tran vdout1_45ck1890 FIND v(dout1_45) AT=950.025n

.meas tran vdout1_46ck1890 FIND v(dout1_46) AT=950.025n

.meas tran vdout1_47ck1890 FIND v(dout1_47) AT=950.025n

.meas tran vdout1_48ck1890 FIND v(dout1_48) AT=950.025n

.meas tran vdout1_49ck1890 FIND v(dout1_49) AT=950.025n

.meas tran vdout1_50ck1890 FIND v(dout1_50) AT=950.025n

.meas tran vdout1_51ck1890 FIND v(dout1_51) AT=950.025n

.meas tran vdout1_52ck1890 FIND v(dout1_52) AT=950.025n

.meas tran vdout1_53ck1890 FIND v(dout1_53) AT=950.025n

.meas tran vdout1_54ck1890 FIND v(dout1_54) AT=950.025n

.meas tran vdout1_55ck1890 FIND v(dout1_55) AT=950.025n

.meas tran vdout1_56ck1890 FIND v(dout1_56) AT=950.025n

.meas tran vdout1_57ck1890 FIND v(dout1_57) AT=950.025n

.meas tran vdout1_58ck1890 FIND v(dout1_58) AT=950.025n

.meas tran vdout1_59ck1890 FIND v(dout1_59) AT=950.025n

.meas tran vdout1_60ck1890 FIND v(dout1_60) AT=950.025n

.meas tran vdout1_61ck1890 FIND v(dout1_61) AT=950.025n

.meas tran vdout1_62ck1890 FIND v(dout1_62) AT=950.025n

.meas tran vdout1_63ck1890 FIND v(dout1_63) AT=950.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_22ck1950 FIND v(dout1_22) AT=980.025n

.meas tran vdout1_23ck1950 FIND v(dout1_23) AT=980.025n

.meas tran vdout1_24ck1950 FIND v(dout1_24) AT=980.025n

.meas tran vdout1_25ck1950 FIND v(dout1_25) AT=980.025n

.meas tran vdout1_26ck1950 FIND v(dout1_26) AT=980.025n

.meas tran vdout1_27ck1950 FIND v(dout1_27) AT=980.025n

.meas tran vdout1_28ck1950 FIND v(dout1_28) AT=980.025n

.meas tran vdout1_29ck1950 FIND v(dout1_29) AT=980.025n

.meas tran vdout1_30ck1950 FIND v(dout1_30) AT=980.025n

.meas tran vdout1_31ck1950 FIND v(dout1_31) AT=980.025n

.meas tran vdout1_32ck1950 FIND v(dout1_32) AT=980.025n

.meas tran vdout1_33ck1950 FIND v(dout1_33) AT=980.025n

.meas tran vdout1_34ck1950 FIND v(dout1_34) AT=980.025n

.meas tran vdout1_35ck1950 FIND v(dout1_35) AT=980.025n

.meas tran vdout1_36ck1950 FIND v(dout1_36) AT=980.025n

.meas tran vdout1_37ck1950 FIND v(dout1_37) AT=980.025n

.meas tran vdout1_38ck1950 FIND v(dout1_38) AT=980.025n

.meas tran vdout1_39ck1950 FIND v(dout1_39) AT=980.025n

.meas tran vdout1_40ck1950 FIND v(dout1_40) AT=980.025n

.meas tran vdout1_41ck1950 FIND v(dout1_41) AT=980.025n

.meas tran vdout1_42ck1950 FIND v(dout1_42) AT=980.025n

.meas tran vdout1_43ck1950 FIND v(dout1_43) AT=980.025n

.meas tran vdout1_44ck1950 FIND v(dout1_44) AT=980.025n

.meas tran vdout1_45ck1950 FIND v(dout1_45) AT=980.025n

.meas tran vdout1_46ck1950 FIND v(dout1_46) AT=980.025n

.meas tran vdout1_47ck1950 FIND v(dout1_47) AT=980.025n

.meas tran vdout1_48ck1950 FIND v(dout1_48) AT=980.025n

.meas tran vdout1_49ck1950 FIND v(dout1_49) AT=980.025n

.meas tran vdout1_50ck1950 FIND v(dout1_50) AT=980.025n

.meas tran vdout1_51ck1950 FIND v(dout1_51) AT=980.025n

.meas tran vdout1_52ck1950 FIND v(dout1_52) AT=980.025n

.meas tran vdout1_53ck1950 FIND v(dout1_53) AT=980.025n

.meas tran vdout1_54ck1950 FIND v(dout1_54) AT=980.025n

.meas tran vdout1_55ck1950 FIND v(dout1_55) AT=980.025n

.meas tran vdout1_56ck1950 FIND v(dout1_56) AT=980.025n

.meas tran vdout1_57ck1950 FIND v(dout1_57) AT=980.025n

.meas tran vdout1_58ck1950 FIND v(dout1_58) AT=980.025n

.meas tran vdout1_59ck1950 FIND v(dout1_59) AT=980.025n

.meas tran vdout1_60ck1950 FIND v(dout1_60) AT=980.025n

.meas tran vdout1_61ck1950 FIND v(dout1_61) AT=980.025n

.meas tran vdout1_62ck1950 FIND v(dout1_62) AT=980.025n

.meas tran vdout1_63ck1950 FIND v(dout1_63) AT=980.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_16ck1980 FIND v(dout1_16) AT=995.025n

.meas tran vdout1_17ck1980 FIND v(dout1_17) AT=995.025n

.meas tran vdout1_18ck1980 FIND v(dout1_18) AT=995.025n

.meas tran vdout1_19ck1980 FIND v(dout1_19) AT=995.025n

.meas tran vdout1_20ck1980 FIND v(dout1_20) AT=995.025n

.meas tran vdout1_21ck1980 FIND v(dout1_21) AT=995.025n

.meas tran vdout1_22ck1980 FIND v(dout1_22) AT=995.025n

.meas tran vdout1_23ck1980 FIND v(dout1_23) AT=995.025n

.meas tran vdout1_24ck1980 FIND v(dout1_24) AT=995.025n

.meas tran vdout1_25ck1980 FIND v(dout1_25) AT=995.025n

.meas tran vdout1_26ck1980 FIND v(dout1_26) AT=995.025n

.meas tran vdout1_27ck1980 FIND v(dout1_27) AT=995.025n

.meas tran vdout1_28ck1980 FIND v(dout1_28) AT=995.025n

.meas tran vdout1_29ck1980 FIND v(dout1_29) AT=995.025n

.meas tran vdout1_30ck1980 FIND v(dout1_30) AT=995.025n

.meas tran vdout1_31ck1980 FIND v(dout1_31) AT=995.025n

.meas tran vdout1_32ck1980 FIND v(dout1_32) AT=995.025n

.meas tran vdout1_33ck1980 FIND v(dout1_33) AT=995.025n

.meas tran vdout1_34ck1980 FIND v(dout1_34) AT=995.025n

.meas tran vdout1_35ck1980 FIND v(dout1_35) AT=995.025n

.meas tran vdout1_36ck1980 FIND v(dout1_36) AT=995.025n

.meas tran vdout1_37ck1980 FIND v(dout1_37) AT=995.025n

.meas tran vdout1_38ck1980 FIND v(dout1_38) AT=995.025n

.meas tran vdout1_39ck1980 FIND v(dout1_39) AT=995.025n

.meas tran vdout1_40ck1980 FIND v(dout1_40) AT=995.025n

.meas tran vdout1_41ck1980 FIND v(dout1_41) AT=995.025n

.meas tran vdout1_42ck1980 FIND v(dout1_42) AT=995.025n

.meas tran vdout1_43ck1980 FIND v(dout1_43) AT=995.025n

.meas tran vdout1_44ck1980 FIND v(dout1_44) AT=995.025n

.meas tran vdout1_45ck1980 FIND v(dout1_45) AT=995.025n

.meas tran vdout1_46ck1980 FIND v(dout1_46) AT=995.025n

.meas tran vdout1_47ck1980 FIND v(dout1_47) AT=995.025n

.meas tran vdout1_48ck1980 FIND v(dout1_48) AT=995.025n

.meas tran vdout1_49ck1980 FIND v(dout1_49) AT=995.025n

.meas tran vdout1_50ck1980 FIND v(dout1_50) AT=995.025n

.meas tran vdout1_51ck1980 FIND v(dout1_51) AT=995.025n

.meas tran vdout1_52ck1980 FIND v(dout1_52) AT=995.025n

.meas tran vdout1_53ck1980 FIND v(dout1_53) AT=995.025n

.meas tran vdout1_54ck1980 FIND v(dout1_54) AT=995.025n

.meas tran vdout1_55ck1980 FIND v(dout1_55) AT=995.025n

.meas tran vdout1_56ck1980 FIND v(dout1_56) AT=995.025n

.meas tran vdout1_57ck1980 FIND v(dout1_57) AT=995.025n

.meas tran vdout1_58ck1980 FIND v(dout1_58) AT=995.025n

.meas tran vdout1_59ck1980 FIND v(dout1_59) AT=995.025n

.meas tran vdout1_60ck1980 FIND v(dout1_60) AT=995.025n

.meas tran vdout1_61ck1980 FIND v(dout1_61) AT=995.025n

.meas tran vdout1_62ck1980 FIND v(dout1_62) AT=995.025n

.meas tran vdout1_63ck1980 FIND v(dout1_63) AT=995.025n

.meas tran vdout1_0ck2000 FIND v(dout1_0) AT=1005.025n

.meas tran vdout1_1ck2000 FIND v(dout1_1) AT=1005.025n

.meas tran vdout1_2ck2000 FIND v(dout1_2) AT=1005.025n

.meas tran vdout1_3ck2000 FIND v(dout1_3) AT=1005.025n

.meas tran vdout1_4ck2000 FIND v(dout1_4) AT=1005.025n

.meas tran vdout1_5ck2000 FIND v(dout1_5) AT=1005.025n

.meas tran vdout1_6ck2000 FIND v(dout1_6) AT=1005.025n

.meas tran vdout1_7ck2000 FIND v(dout1_7) AT=1005.025n

.meas tran vdout1_8ck2000 FIND v(dout1_8) AT=1005.025n

.meas tran vdout1_9ck2000 FIND v(dout1_9) AT=1005.025n

.meas tran vdout1_10ck2000 FIND v(dout1_10) AT=1005.025n

.meas tran vdout1_11ck2000 FIND v(dout1_11) AT=1005.025n

.meas tran vdout1_12ck2000 FIND v(dout1_12) AT=1005.025n

.meas tran vdout1_13ck2000 FIND v(dout1_13) AT=1005.025n

.meas tran vdout1_14ck2000 FIND v(dout1_14) AT=1005.025n

.meas tran vdout1_15ck2000 FIND v(dout1_15) AT=1005.025n

.meas tran vdout1_16ck2000 FIND v(dout1_16) AT=1005.025n

.meas tran vdout1_17ck2000 FIND v(dout1_17) AT=1005.025n

.meas tran vdout1_18ck2000 FIND v(dout1_18) AT=1005.025n

.meas tran vdout1_19ck2000 FIND v(dout1_19) AT=1005.025n

.meas tran vdout1_20ck2000 FIND v(dout1_20) AT=1005.025n

.meas tran vdout1_21ck2000 FIND v(dout1_21) AT=1005.025n

.meas tran vdout1_22ck2000 FIND v(dout1_22) AT=1005.025n

.meas tran vdout1_23ck2000 FIND v(dout1_23) AT=1005.025n

.meas tran vdout1_24ck2000 FIND v(dout1_24) AT=1005.025n

.meas tran vdout1_25ck2000 FIND v(dout1_25) AT=1005.025n

.meas tran vdout1_26ck2000 FIND v(dout1_26) AT=1005.025n

.meas tran vdout1_27ck2000 FIND v(dout1_27) AT=1005.025n

.meas tran vdout1_28ck2000 FIND v(dout1_28) AT=1005.025n

.meas tran vdout1_29ck2000 FIND v(dout1_29) AT=1005.025n

.meas tran vdout1_30ck2000 FIND v(dout1_30) AT=1005.025n

.meas tran vdout1_31ck2000 FIND v(dout1_31) AT=1005.025n

.meas tran vdout1_32ck2000 FIND v(dout1_32) AT=1005.025n

.meas tran vdout1_33ck2000 FIND v(dout1_33) AT=1005.025n

.meas tran vdout1_34ck2000 FIND v(dout1_34) AT=1005.025n

.meas tran vdout1_35ck2000 FIND v(dout1_35) AT=1005.025n

.meas tran vdout1_36ck2000 FIND v(dout1_36) AT=1005.025n

.meas tran vdout1_37ck2000 FIND v(dout1_37) AT=1005.025n

.meas tran vdout1_38ck2000 FIND v(dout1_38) AT=1005.025n

.meas tran vdout1_39ck2000 FIND v(dout1_39) AT=1005.025n

.meas tran vdout1_40ck2000 FIND v(dout1_40) AT=1005.025n

.meas tran vdout1_41ck2000 FIND v(dout1_41) AT=1005.025n

.meas tran vdout1_42ck2000 FIND v(dout1_42) AT=1005.025n

.meas tran vdout1_43ck2000 FIND v(dout1_43) AT=1005.025n

.meas tran vdout1_44ck2000 FIND v(dout1_44) AT=1005.025n

.meas tran vdout1_45ck2000 FIND v(dout1_45) AT=1005.025n

.meas tran vdout1_46ck2000 FIND v(dout1_46) AT=1005.025n

.meas tran vdout1_47ck2000 FIND v(dout1_47) AT=1005.025n

.meas tran vdout1_48ck2000 FIND v(dout1_48) AT=1005.025n

.meas tran vdout1_49ck2000 FIND v(dout1_49) AT=1005.025n

.meas tran vdout1_50ck2000 FIND v(dout1_50) AT=1005.025n

.meas tran vdout1_51ck2000 FIND v(dout1_51) AT=1005.025n

.meas tran vdout1_52ck2000 FIND v(dout1_52) AT=1005.025n

.meas tran vdout1_53ck2000 FIND v(dout1_53) AT=1005.025n

.meas tran vdout1_54ck2000 FIND v(dout1_54) AT=1005.025n

.meas tran vdout1_55ck2000 FIND v(dout1_55) AT=1005.025n

.meas tran vdout1_56ck2000 FIND v(dout1_56) AT=1005.025n

.meas tran vdout1_57ck2000 FIND v(dout1_57) AT=1005.025n

.meas tran vdout1_58ck2000 FIND v(dout1_58) AT=1005.025n

.meas tran vdout1_59ck2000 FIND v(dout1_59) AT=1005.025n

.meas tran vdout1_60ck2000 FIND v(dout1_60) AT=1005.025n

.meas tran vdout1_61ck2000 FIND v(dout1_61) AT=1005.025n

.meas tran vdout1_62ck2000 FIND v(dout1_62) AT=1005.025n

.meas tran vdout1_63ck2000 FIND v(dout1_63) AT=1005.025n

.meas tran vdout1_0ck2020 FIND v(dout1_0) AT=1015.025n

.meas tran vdout1_1ck2020 FIND v(dout1_1) AT=1015.025n

.meas tran vdout1_2ck2020 FIND v(dout1_2) AT=1015.025n

.meas tran vdout1_3ck2020 FIND v(dout1_3) AT=1015.025n

.meas tran vdout1_4ck2020 FIND v(dout1_4) AT=1015.025n

.meas tran vdout1_5ck2020 FIND v(dout1_5) AT=1015.025n

.meas tran vdout1_6ck2020 FIND v(dout1_6) AT=1015.025n

.meas tran vdout1_7ck2020 FIND v(dout1_7) AT=1015.025n

.meas tran vdout1_8ck2020 FIND v(dout1_8) AT=1015.025n

.meas tran vdout1_9ck2020 FIND v(dout1_9) AT=1015.025n

.meas tran vdout1_10ck2020 FIND v(dout1_10) AT=1015.025n

.meas tran vdout1_11ck2020 FIND v(dout1_11) AT=1015.025n

.meas tran vdout1_12ck2020 FIND v(dout1_12) AT=1015.025n

.meas tran vdout1_13ck2020 FIND v(dout1_13) AT=1015.025n

.meas tran vdout1_14ck2020 FIND v(dout1_14) AT=1015.025n

.meas tran vdout1_15ck2020 FIND v(dout1_15) AT=1015.025n

.meas tran vdout1_16ck2020 FIND v(dout1_16) AT=1015.025n

.meas tran vdout1_17ck2020 FIND v(dout1_17) AT=1015.025n

.meas tran vdout1_18ck2020 FIND v(dout1_18) AT=1015.025n

.meas tran vdout1_19ck2020 FIND v(dout1_19) AT=1015.025n

.meas tran vdout1_20ck2020 FIND v(dout1_20) AT=1015.025n

.meas tran vdout1_21ck2020 FIND v(dout1_21) AT=1015.025n

.meas tran vdout1_22ck2020 FIND v(dout1_22) AT=1015.025n

.meas tran vdout1_23ck2020 FIND v(dout1_23) AT=1015.025n

.meas tran vdout1_24ck2020 FIND v(dout1_24) AT=1015.025n

.meas tran vdout1_25ck2020 FIND v(dout1_25) AT=1015.025n

.meas tran vdout1_26ck2020 FIND v(dout1_26) AT=1015.025n

.meas tran vdout1_27ck2020 FIND v(dout1_27) AT=1015.025n

.meas tran vdout1_28ck2020 FIND v(dout1_28) AT=1015.025n

.meas tran vdout1_29ck2020 FIND v(dout1_29) AT=1015.025n

.meas tran vdout1_30ck2020 FIND v(dout1_30) AT=1015.025n

.meas tran vdout1_31ck2020 FIND v(dout1_31) AT=1015.025n

.meas tran vdout1_32ck2020 FIND v(dout1_32) AT=1015.025n

.meas tran vdout1_33ck2020 FIND v(dout1_33) AT=1015.025n

.meas tran vdout1_34ck2020 FIND v(dout1_34) AT=1015.025n

.meas tran vdout1_35ck2020 FIND v(dout1_35) AT=1015.025n

.meas tran vdout1_36ck2020 FIND v(dout1_36) AT=1015.025n

.meas tran vdout1_37ck2020 FIND v(dout1_37) AT=1015.025n

.meas tran vdout1_38ck2020 FIND v(dout1_38) AT=1015.025n

.meas tran vdout1_39ck2020 FIND v(dout1_39) AT=1015.025n

.meas tran vdout1_40ck2020 FIND v(dout1_40) AT=1015.025n

.meas tran vdout1_41ck2020 FIND v(dout1_41) AT=1015.025n

.meas tran vdout1_42ck2020 FIND v(dout1_42) AT=1015.025n

.meas tran vdout1_43ck2020 FIND v(dout1_43) AT=1015.025n

.meas tran vdout1_44ck2020 FIND v(dout1_44) AT=1015.025n

.meas tran vdout1_45ck2020 FIND v(dout1_45) AT=1015.025n

.meas tran vdout1_46ck2020 FIND v(dout1_46) AT=1015.025n

.meas tran vdout1_47ck2020 FIND v(dout1_47) AT=1015.025n

.meas tran vdout1_48ck2020 FIND v(dout1_48) AT=1015.025n

.meas tran vdout1_49ck2020 FIND v(dout1_49) AT=1015.025n

.meas tran vdout1_50ck2020 FIND v(dout1_50) AT=1015.025n

.meas tran vdout1_51ck2020 FIND v(dout1_51) AT=1015.025n

.meas tran vdout1_52ck2020 FIND v(dout1_52) AT=1015.025n

.meas tran vdout1_53ck2020 FIND v(dout1_53) AT=1015.025n

.meas tran vdout1_54ck2020 FIND v(dout1_54) AT=1015.025n

.meas tran vdout1_55ck2020 FIND v(dout1_55) AT=1015.025n

.meas tran vdout1_56ck2020 FIND v(dout1_56) AT=1015.025n

.meas tran vdout1_57ck2020 FIND v(dout1_57) AT=1015.025n

.meas tran vdout1_58ck2020 FIND v(dout1_58) AT=1015.025n

.meas tran vdout1_59ck2020 FIND v(dout1_59) AT=1015.025n

.meas tran vdout1_60ck2020 FIND v(dout1_60) AT=1015.025n

.meas tran vdout1_61ck2020 FIND v(dout1_61) AT=1015.025n

.meas tran vdout1_62ck2020 FIND v(dout1_62) AT=1015.025n

.meas tran vdout1_63ck2020 FIND v(dout1_63) AT=1015.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n

.meas tran vdout1_22ck2030 FIND v(dout1_22) AT=1020.025n

.meas tran vdout1_23ck2030 FIND v(dout1_23) AT=1020.025n

.meas tran vdout1_24ck2030 FIND v(dout1_24) AT=1020.025n

.meas tran vdout1_25ck2030 FIND v(dout1_25) AT=1020.025n

.meas tran vdout1_26ck2030 FIND v(dout1_26) AT=1020.025n

.meas tran vdout1_27ck2030 FIND v(dout1_27) AT=1020.025n

.meas tran vdout1_28ck2030 FIND v(dout1_28) AT=1020.025n

.meas tran vdout1_29ck2030 FIND v(dout1_29) AT=1020.025n

.meas tran vdout1_30ck2030 FIND v(dout1_30) AT=1020.025n

.meas tran vdout1_31ck2030 FIND v(dout1_31) AT=1020.025n

.meas tran vdout1_32ck2030 FIND v(dout1_32) AT=1020.025n

.meas tran vdout1_33ck2030 FIND v(dout1_33) AT=1020.025n

.meas tran vdout1_34ck2030 FIND v(dout1_34) AT=1020.025n

.meas tran vdout1_35ck2030 FIND v(dout1_35) AT=1020.025n

.meas tran vdout1_36ck2030 FIND v(dout1_36) AT=1020.025n

.meas tran vdout1_37ck2030 FIND v(dout1_37) AT=1020.025n

.meas tran vdout1_38ck2030 FIND v(dout1_38) AT=1020.025n

.meas tran vdout1_39ck2030 FIND v(dout1_39) AT=1020.025n

.meas tran vdout1_40ck2030 FIND v(dout1_40) AT=1020.025n

.meas tran vdout1_41ck2030 FIND v(dout1_41) AT=1020.025n

.meas tran vdout1_42ck2030 FIND v(dout1_42) AT=1020.025n

.meas tran vdout1_43ck2030 FIND v(dout1_43) AT=1020.025n

.meas tran vdout1_44ck2030 FIND v(dout1_44) AT=1020.025n

.meas tran vdout1_45ck2030 FIND v(dout1_45) AT=1020.025n

.meas tran vdout1_46ck2030 FIND v(dout1_46) AT=1020.025n

.meas tran vdout1_47ck2030 FIND v(dout1_47) AT=1020.025n

.meas tran vdout1_48ck2030 FIND v(dout1_48) AT=1020.025n

.meas tran vdout1_49ck2030 FIND v(dout1_49) AT=1020.025n

.meas tran vdout1_50ck2030 FIND v(dout1_50) AT=1020.025n

.meas tran vdout1_51ck2030 FIND v(dout1_51) AT=1020.025n

.meas tran vdout1_52ck2030 FIND v(dout1_52) AT=1020.025n

.meas tran vdout1_53ck2030 FIND v(dout1_53) AT=1020.025n

.meas tran vdout1_54ck2030 FIND v(dout1_54) AT=1020.025n

.meas tran vdout1_55ck2030 FIND v(dout1_55) AT=1020.025n

.meas tran vdout1_56ck2030 FIND v(dout1_56) AT=1020.025n

.meas tran vdout1_57ck2030 FIND v(dout1_57) AT=1020.025n

.meas tran vdout1_58ck2030 FIND v(dout1_58) AT=1020.025n

.meas tran vdout1_59ck2030 FIND v(dout1_59) AT=1020.025n

.meas tran vdout1_60ck2030 FIND v(dout1_60) AT=1020.025n

.meas tran vdout1_61ck2030 FIND v(dout1_61) AT=1020.025n

.meas tran vdout1_62ck2030 FIND v(dout1_62) AT=1020.025n

.meas tran vdout1_63ck2030 FIND v(dout1_63) AT=1020.025n
