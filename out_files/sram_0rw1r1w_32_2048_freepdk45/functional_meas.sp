.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_16ck60 FIND v(dout1_16) AT=35.025n

.meas tran vdout1_17ck60 FIND v(dout1_17) AT=35.025n

.meas tran vdout1_18ck60 FIND v(dout1_18) AT=35.025n

.meas tran vdout1_19ck60 FIND v(dout1_19) AT=35.025n

.meas tran vdout1_20ck60 FIND v(dout1_20) AT=35.025n

.meas tran vdout1_21ck60 FIND v(dout1_21) AT=35.025n

.meas tran vdout1_22ck60 FIND v(dout1_22) AT=35.025n

.meas tran vdout1_23ck60 FIND v(dout1_23) AT=35.025n

.meas tran vdout1_24ck60 FIND v(dout1_24) AT=35.025n

.meas tran vdout1_25ck60 FIND v(dout1_25) AT=35.025n

.meas tran vdout1_26ck60 FIND v(dout1_26) AT=35.025n

.meas tran vdout1_27ck60 FIND v(dout1_27) AT=35.025n

.meas tran vdout1_28ck60 FIND v(dout1_28) AT=35.025n

.meas tran vdout1_29ck60 FIND v(dout1_29) AT=35.025n

.meas tran vdout1_30ck60 FIND v(dout1_30) AT=35.025n

.meas tran vdout1_31ck60 FIND v(dout1_31) AT=35.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_17ck80 FIND v(dout1_17) AT=45.025n

.meas tran vdout1_18ck80 FIND v(dout1_18) AT=45.025n

.meas tran vdout1_19ck80 FIND v(dout1_19) AT=45.025n

.meas tran vdout1_20ck80 FIND v(dout1_20) AT=45.025n

.meas tran vdout1_21ck80 FIND v(dout1_21) AT=45.025n

.meas tran vdout1_22ck80 FIND v(dout1_22) AT=45.025n

.meas tran vdout1_23ck80 FIND v(dout1_23) AT=45.025n

.meas tran vdout1_24ck80 FIND v(dout1_24) AT=45.025n

.meas tran vdout1_25ck80 FIND v(dout1_25) AT=45.025n

.meas tran vdout1_26ck80 FIND v(dout1_26) AT=45.025n

.meas tran vdout1_27ck80 FIND v(dout1_27) AT=45.025n

.meas tran vdout1_28ck80 FIND v(dout1_28) AT=45.025n

.meas tran vdout1_29ck80 FIND v(dout1_29) AT=45.025n

.meas tran vdout1_30ck80 FIND v(dout1_30) AT=45.025n

.meas tran vdout1_31ck80 FIND v(dout1_31) AT=45.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_17ck100 FIND v(dout1_17) AT=55.025n

.meas tran vdout1_18ck100 FIND v(dout1_18) AT=55.025n

.meas tran vdout1_19ck100 FIND v(dout1_19) AT=55.025n

.meas tran vdout1_20ck100 FIND v(dout1_20) AT=55.025n

.meas tran vdout1_21ck100 FIND v(dout1_21) AT=55.025n

.meas tran vdout1_22ck100 FIND v(dout1_22) AT=55.025n

.meas tran vdout1_23ck100 FIND v(dout1_23) AT=55.025n

.meas tran vdout1_24ck100 FIND v(dout1_24) AT=55.025n

.meas tran vdout1_25ck100 FIND v(dout1_25) AT=55.025n

.meas tran vdout1_26ck100 FIND v(dout1_26) AT=55.025n

.meas tran vdout1_27ck100 FIND v(dout1_27) AT=55.025n

.meas tran vdout1_28ck100 FIND v(dout1_28) AT=55.025n

.meas tran vdout1_29ck100 FIND v(dout1_29) AT=55.025n

.meas tran vdout1_30ck100 FIND v(dout1_30) AT=55.025n

.meas tran vdout1_31ck100 FIND v(dout1_31) AT=55.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_0ck170 FIND v(dout1_0) AT=90.025n

.meas tran vdout1_1ck170 FIND v(dout1_1) AT=90.025n

.meas tran vdout1_2ck170 FIND v(dout1_2) AT=90.025n

.meas tran vdout1_3ck170 FIND v(dout1_3) AT=90.025n

.meas tran vdout1_4ck170 FIND v(dout1_4) AT=90.025n

.meas tran vdout1_5ck170 FIND v(dout1_5) AT=90.025n

.meas tran vdout1_6ck170 FIND v(dout1_6) AT=90.025n

.meas tran vdout1_7ck170 FIND v(dout1_7) AT=90.025n

.meas tran vdout1_8ck170 FIND v(dout1_8) AT=90.025n

.meas tran vdout1_9ck170 FIND v(dout1_9) AT=90.025n

.meas tran vdout1_10ck170 FIND v(dout1_10) AT=90.025n

.meas tran vdout1_11ck170 FIND v(dout1_11) AT=90.025n

.meas tran vdout1_12ck170 FIND v(dout1_12) AT=90.025n

.meas tran vdout1_13ck170 FIND v(dout1_13) AT=90.025n

.meas tran vdout1_14ck170 FIND v(dout1_14) AT=90.025n

.meas tran vdout1_15ck170 FIND v(dout1_15) AT=90.025n

.meas tran vdout1_16ck170 FIND v(dout1_16) AT=90.025n

.meas tran vdout1_17ck170 FIND v(dout1_17) AT=90.025n

.meas tran vdout1_18ck170 FIND v(dout1_18) AT=90.025n

.meas tran vdout1_19ck170 FIND v(dout1_19) AT=90.025n

.meas tran vdout1_20ck170 FIND v(dout1_20) AT=90.025n

.meas tran vdout1_21ck170 FIND v(dout1_21) AT=90.025n

.meas tran vdout1_22ck170 FIND v(dout1_22) AT=90.025n

.meas tran vdout1_23ck170 FIND v(dout1_23) AT=90.025n

.meas tran vdout1_24ck170 FIND v(dout1_24) AT=90.025n

.meas tran vdout1_25ck170 FIND v(dout1_25) AT=90.025n

.meas tran vdout1_26ck170 FIND v(dout1_26) AT=90.025n

.meas tran vdout1_27ck170 FIND v(dout1_27) AT=90.025n

.meas tran vdout1_28ck170 FIND v(dout1_28) AT=90.025n

.meas tran vdout1_29ck170 FIND v(dout1_29) AT=90.025n

.meas tran vdout1_30ck170 FIND v(dout1_30) AT=90.025n

.meas tran vdout1_31ck170 FIND v(dout1_31) AT=90.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_22ck200 FIND v(dout1_22) AT=105.025n

.meas tran vdout1_23ck200 FIND v(dout1_23) AT=105.025n

.meas tran vdout1_24ck200 FIND v(dout1_24) AT=105.025n

.meas tran vdout1_25ck200 FIND v(dout1_25) AT=105.025n

.meas tran vdout1_26ck200 FIND v(dout1_26) AT=105.025n

.meas tran vdout1_27ck200 FIND v(dout1_27) AT=105.025n

.meas tran vdout1_28ck200 FIND v(dout1_28) AT=105.025n

.meas tran vdout1_29ck200 FIND v(dout1_29) AT=105.025n

.meas tran vdout1_30ck200 FIND v(dout1_30) AT=105.025n

.meas tran vdout1_31ck200 FIND v(dout1_31) AT=105.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_17ck240 FIND v(dout1_17) AT=125.025n

.meas tran vdout1_18ck240 FIND v(dout1_18) AT=125.025n

.meas tran vdout1_19ck240 FIND v(dout1_19) AT=125.025n

.meas tran vdout1_20ck240 FIND v(dout1_20) AT=125.025n

.meas tran vdout1_21ck240 FIND v(dout1_21) AT=125.025n

.meas tran vdout1_22ck240 FIND v(dout1_22) AT=125.025n

.meas tran vdout1_23ck240 FIND v(dout1_23) AT=125.025n

.meas tran vdout1_24ck240 FIND v(dout1_24) AT=125.025n

.meas tran vdout1_25ck240 FIND v(dout1_25) AT=125.025n

.meas tran vdout1_26ck240 FIND v(dout1_26) AT=125.025n

.meas tran vdout1_27ck240 FIND v(dout1_27) AT=125.025n

.meas tran vdout1_28ck240 FIND v(dout1_28) AT=125.025n

.meas tran vdout1_29ck240 FIND v(dout1_29) AT=125.025n

.meas tran vdout1_30ck240 FIND v(dout1_30) AT=125.025n

.meas tran vdout1_31ck240 FIND v(dout1_31) AT=125.025n

.meas tran vdout1_0ck260 FIND v(dout1_0) AT=135.025n

.meas tran vdout1_1ck260 FIND v(dout1_1) AT=135.025n

.meas tran vdout1_2ck260 FIND v(dout1_2) AT=135.025n

.meas tran vdout1_3ck260 FIND v(dout1_3) AT=135.025n

.meas tran vdout1_4ck260 FIND v(dout1_4) AT=135.025n

.meas tran vdout1_5ck260 FIND v(dout1_5) AT=135.025n

.meas tran vdout1_6ck260 FIND v(dout1_6) AT=135.025n

.meas tran vdout1_7ck260 FIND v(dout1_7) AT=135.025n

.meas tran vdout1_8ck260 FIND v(dout1_8) AT=135.025n

.meas tran vdout1_9ck260 FIND v(dout1_9) AT=135.025n

.meas tran vdout1_10ck260 FIND v(dout1_10) AT=135.025n

.meas tran vdout1_11ck260 FIND v(dout1_11) AT=135.025n

.meas tran vdout1_12ck260 FIND v(dout1_12) AT=135.025n

.meas tran vdout1_13ck260 FIND v(dout1_13) AT=135.025n

.meas tran vdout1_14ck260 FIND v(dout1_14) AT=135.025n

.meas tran vdout1_15ck260 FIND v(dout1_15) AT=135.025n

.meas tran vdout1_16ck260 FIND v(dout1_16) AT=135.025n

.meas tran vdout1_17ck260 FIND v(dout1_17) AT=135.025n

.meas tran vdout1_18ck260 FIND v(dout1_18) AT=135.025n

.meas tran vdout1_19ck260 FIND v(dout1_19) AT=135.025n

.meas tran vdout1_20ck260 FIND v(dout1_20) AT=135.025n

.meas tran vdout1_21ck260 FIND v(dout1_21) AT=135.025n

.meas tran vdout1_22ck260 FIND v(dout1_22) AT=135.025n

.meas tran vdout1_23ck260 FIND v(dout1_23) AT=135.025n

.meas tran vdout1_24ck260 FIND v(dout1_24) AT=135.025n

.meas tran vdout1_25ck260 FIND v(dout1_25) AT=135.025n

.meas tran vdout1_26ck260 FIND v(dout1_26) AT=135.025n

.meas tran vdout1_27ck260 FIND v(dout1_27) AT=135.025n

.meas tran vdout1_28ck260 FIND v(dout1_28) AT=135.025n

.meas tran vdout1_29ck260 FIND v(dout1_29) AT=135.025n

.meas tran vdout1_30ck260 FIND v(dout1_30) AT=135.025n

.meas tran vdout1_31ck260 FIND v(dout1_31) AT=135.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_19ck290 FIND v(dout1_19) AT=150.025n

.meas tran vdout1_20ck290 FIND v(dout1_20) AT=150.025n

.meas tran vdout1_21ck290 FIND v(dout1_21) AT=150.025n

.meas tran vdout1_22ck290 FIND v(dout1_22) AT=150.025n

.meas tran vdout1_23ck290 FIND v(dout1_23) AT=150.025n

.meas tran vdout1_24ck290 FIND v(dout1_24) AT=150.025n

.meas tran vdout1_25ck290 FIND v(dout1_25) AT=150.025n

.meas tran vdout1_26ck290 FIND v(dout1_26) AT=150.025n

.meas tran vdout1_27ck290 FIND v(dout1_27) AT=150.025n

.meas tran vdout1_28ck290 FIND v(dout1_28) AT=150.025n

.meas tran vdout1_29ck290 FIND v(dout1_29) AT=150.025n

.meas tran vdout1_30ck290 FIND v(dout1_30) AT=150.025n

.meas tran vdout1_31ck290 FIND v(dout1_31) AT=150.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_8ck300 FIND v(dout1_8) AT=155.025n

.meas tran vdout1_9ck300 FIND v(dout1_9) AT=155.025n

.meas tran vdout1_10ck300 FIND v(dout1_10) AT=155.025n

.meas tran vdout1_11ck300 FIND v(dout1_11) AT=155.025n

.meas tran vdout1_12ck300 FIND v(dout1_12) AT=155.025n

.meas tran vdout1_13ck300 FIND v(dout1_13) AT=155.025n

.meas tran vdout1_14ck300 FIND v(dout1_14) AT=155.025n

.meas tran vdout1_15ck300 FIND v(dout1_15) AT=155.025n

.meas tran vdout1_16ck300 FIND v(dout1_16) AT=155.025n

.meas tran vdout1_17ck300 FIND v(dout1_17) AT=155.025n

.meas tran vdout1_18ck300 FIND v(dout1_18) AT=155.025n

.meas tran vdout1_19ck300 FIND v(dout1_19) AT=155.025n

.meas tran vdout1_20ck300 FIND v(dout1_20) AT=155.025n

.meas tran vdout1_21ck300 FIND v(dout1_21) AT=155.025n

.meas tran vdout1_22ck300 FIND v(dout1_22) AT=155.025n

.meas tran vdout1_23ck300 FIND v(dout1_23) AT=155.025n

.meas tran vdout1_24ck300 FIND v(dout1_24) AT=155.025n

.meas tran vdout1_25ck300 FIND v(dout1_25) AT=155.025n

.meas tran vdout1_26ck300 FIND v(dout1_26) AT=155.025n

.meas tran vdout1_27ck300 FIND v(dout1_27) AT=155.025n

.meas tran vdout1_28ck300 FIND v(dout1_28) AT=155.025n

.meas tran vdout1_29ck300 FIND v(dout1_29) AT=155.025n

.meas tran vdout1_30ck300 FIND v(dout1_30) AT=155.025n

.meas tran vdout1_31ck300 FIND v(dout1_31) AT=155.025n

.meas tran vdout1_0ck320 FIND v(dout1_0) AT=165.025n

.meas tran vdout1_1ck320 FIND v(dout1_1) AT=165.025n

.meas tran vdout1_2ck320 FIND v(dout1_2) AT=165.025n

.meas tran vdout1_3ck320 FIND v(dout1_3) AT=165.025n

.meas tran vdout1_4ck320 FIND v(dout1_4) AT=165.025n

.meas tran vdout1_5ck320 FIND v(dout1_5) AT=165.025n

.meas tran vdout1_6ck320 FIND v(dout1_6) AT=165.025n

.meas tran vdout1_7ck320 FIND v(dout1_7) AT=165.025n

.meas tran vdout1_8ck320 FIND v(dout1_8) AT=165.025n

.meas tran vdout1_9ck320 FIND v(dout1_9) AT=165.025n

.meas tran vdout1_10ck320 FIND v(dout1_10) AT=165.025n

.meas tran vdout1_11ck320 FIND v(dout1_11) AT=165.025n

.meas tran vdout1_12ck320 FIND v(dout1_12) AT=165.025n

.meas tran vdout1_13ck320 FIND v(dout1_13) AT=165.025n

.meas tran vdout1_14ck320 FIND v(dout1_14) AT=165.025n

.meas tran vdout1_15ck320 FIND v(dout1_15) AT=165.025n

.meas tran vdout1_16ck320 FIND v(dout1_16) AT=165.025n

.meas tran vdout1_17ck320 FIND v(dout1_17) AT=165.025n

.meas tran vdout1_18ck320 FIND v(dout1_18) AT=165.025n

.meas tran vdout1_19ck320 FIND v(dout1_19) AT=165.025n

.meas tran vdout1_20ck320 FIND v(dout1_20) AT=165.025n

.meas tran vdout1_21ck320 FIND v(dout1_21) AT=165.025n

.meas tran vdout1_22ck320 FIND v(dout1_22) AT=165.025n

.meas tran vdout1_23ck320 FIND v(dout1_23) AT=165.025n

.meas tran vdout1_24ck320 FIND v(dout1_24) AT=165.025n

.meas tran vdout1_25ck320 FIND v(dout1_25) AT=165.025n

.meas tran vdout1_26ck320 FIND v(dout1_26) AT=165.025n

.meas tran vdout1_27ck320 FIND v(dout1_27) AT=165.025n

.meas tran vdout1_28ck320 FIND v(dout1_28) AT=165.025n

.meas tran vdout1_29ck320 FIND v(dout1_29) AT=165.025n

.meas tran vdout1_30ck320 FIND v(dout1_30) AT=165.025n

.meas tran vdout1_31ck320 FIND v(dout1_31) AT=165.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_8ck340 FIND v(dout1_8) AT=175.025n

.meas tran vdout1_9ck340 FIND v(dout1_9) AT=175.025n

.meas tran vdout1_10ck340 FIND v(dout1_10) AT=175.025n

.meas tran vdout1_11ck340 FIND v(dout1_11) AT=175.025n

.meas tran vdout1_12ck340 FIND v(dout1_12) AT=175.025n

.meas tran vdout1_13ck340 FIND v(dout1_13) AT=175.025n

.meas tran vdout1_14ck340 FIND v(dout1_14) AT=175.025n

.meas tran vdout1_15ck340 FIND v(dout1_15) AT=175.025n

.meas tran vdout1_16ck340 FIND v(dout1_16) AT=175.025n

.meas tran vdout1_17ck340 FIND v(dout1_17) AT=175.025n

.meas tran vdout1_18ck340 FIND v(dout1_18) AT=175.025n

.meas tran vdout1_19ck340 FIND v(dout1_19) AT=175.025n

.meas tran vdout1_20ck340 FIND v(dout1_20) AT=175.025n

.meas tran vdout1_21ck340 FIND v(dout1_21) AT=175.025n

.meas tran vdout1_22ck340 FIND v(dout1_22) AT=175.025n

.meas tran vdout1_23ck340 FIND v(dout1_23) AT=175.025n

.meas tran vdout1_24ck340 FIND v(dout1_24) AT=175.025n

.meas tran vdout1_25ck340 FIND v(dout1_25) AT=175.025n

.meas tran vdout1_26ck340 FIND v(dout1_26) AT=175.025n

.meas tran vdout1_27ck340 FIND v(dout1_27) AT=175.025n

.meas tran vdout1_28ck340 FIND v(dout1_28) AT=175.025n

.meas tran vdout1_29ck340 FIND v(dout1_29) AT=175.025n

.meas tran vdout1_30ck340 FIND v(dout1_30) AT=175.025n

.meas tran vdout1_31ck340 FIND v(dout1_31) AT=175.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_22ck370 FIND v(dout1_22) AT=190.025n

.meas tran vdout1_23ck370 FIND v(dout1_23) AT=190.025n

.meas tran vdout1_24ck370 FIND v(dout1_24) AT=190.025n

.meas tran vdout1_25ck370 FIND v(dout1_25) AT=190.025n

.meas tran vdout1_26ck370 FIND v(dout1_26) AT=190.025n

.meas tran vdout1_27ck370 FIND v(dout1_27) AT=190.025n

.meas tran vdout1_28ck370 FIND v(dout1_28) AT=190.025n

.meas tran vdout1_29ck370 FIND v(dout1_29) AT=190.025n

.meas tran vdout1_30ck370 FIND v(dout1_30) AT=190.025n

.meas tran vdout1_31ck370 FIND v(dout1_31) AT=190.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_23ck380 FIND v(dout1_23) AT=195.025n

.meas tran vdout1_24ck380 FIND v(dout1_24) AT=195.025n

.meas tran vdout1_25ck380 FIND v(dout1_25) AT=195.025n

.meas tran vdout1_26ck380 FIND v(dout1_26) AT=195.025n

.meas tran vdout1_27ck380 FIND v(dout1_27) AT=195.025n

.meas tran vdout1_28ck380 FIND v(dout1_28) AT=195.025n

.meas tran vdout1_29ck380 FIND v(dout1_29) AT=195.025n

.meas tran vdout1_30ck380 FIND v(dout1_30) AT=195.025n

.meas tran vdout1_31ck380 FIND v(dout1_31) AT=195.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_19ck400 FIND v(dout1_19) AT=205.025n

.meas tran vdout1_20ck400 FIND v(dout1_20) AT=205.025n

.meas tran vdout1_21ck400 FIND v(dout1_21) AT=205.025n

.meas tran vdout1_22ck400 FIND v(dout1_22) AT=205.025n

.meas tran vdout1_23ck400 FIND v(dout1_23) AT=205.025n

.meas tran vdout1_24ck400 FIND v(dout1_24) AT=205.025n

.meas tran vdout1_25ck400 FIND v(dout1_25) AT=205.025n

.meas tran vdout1_26ck400 FIND v(dout1_26) AT=205.025n

.meas tran vdout1_27ck400 FIND v(dout1_27) AT=205.025n

.meas tran vdout1_28ck400 FIND v(dout1_28) AT=205.025n

.meas tran vdout1_29ck400 FIND v(dout1_29) AT=205.025n

.meas tran vdout1_30ck400 FIND v(dout1_30) AT=205.025n

.meas tran vdout1_31ck400 FIND v(dout1_31) AT=205.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_17ck410 FIND v(dout1_17) AT=210.025n

.meas tran vdout1_18ck410 FIND v(dout1_18) AT=210.025n

.meas tran vdout1_19ck410 FIND v(dout1_19) AT=210.025n

.meas tran vdout1_20ck410 FIND v(dout1_20) AT=210.025n

.meas tran vdout1_21ck410 FIND v(dout1_21) AT=210.025n

.meas tran vdout1_22ck410 FIND v(dout1_22) AT=210.025n

.meas tran vdout1_23ck410 FIND v(dout1_23) AT=210.025n

.meas tran vdout1_24ck410 FIND v(dout1_24) AT=210.025n

.meas tran vdout1_25ck410 FIND v(dout1_25) AT=210.025n

.meas tran vdout1_26ck410 FIND v(dout1_26) AT=210.025n

.meas tran vdout1_27ck410 FIND v(dout1_27) AT=210.025n

.meas tran vdout1_28ck410 FIND v(dout1_28) AT=210.025n

.meas tran vdout1_29ck410 FIND v(dout1_29) AT=210.025n

.meas tran vdout1_30ck410 FIND v(dout1_30) AT=210.025n

.meas tran vdout1_31ck410 FIND v(dout1_31) AT=210.025n

.meas tran vdout1_0ck430 FIND v(dout1_0) AT=220.025n

.meas tran vdout1_1ck430 FIND v(dout1_1) AT=220.025n

.meas tran vdout1_2ck430 FIND v(dout1_2) AT=220.025n

.meas tran vdout1_3ck430 FIND v(dout1_3) AT=220.025n

.meas tran vdout1_4ck430 FIND v(dout1_4) AT=220.025n

.meas tran vdout1_5ck430 FIND v(dout1_5) AT=220.025n

.meas tran vdout1_6ck430 FIND v(dout1_6) AT=220.025n

.meas tran vdout1_7ck430 FIND v(dout1_7) AT=220.025n

.meas tran vdout1_8ck430 FIND v(dout1_8) AT=220.025n

.meas tran vdout1_9ck430 FIND v(dout1_9) AT=220.025n

.meas tran vdout1_10ck430 FIND v(dout1_10) AT=220.025n

.meas tran vdout1_11ck430 FIND v(dout1_11) AT=220.025n

.meas tran vdout1_12ck430 FIND v(dout1_12) AT=220.025n

.meas tran vdout1_13ck430 FIND v(dout1_13) AT=220.025n

.meas tran vdout1_14ck430 FIND v(dout1_14) AT=220.025n

.meas tran vdout1_15ck430 FIND v(dout1_15) AT=220.025n

.meas tran vdout1_16ck430 FIND v(dout1_16) AT=220.025n

.meas tran vdout1_17ck430 FIND v(dout1_17) AT=220.025n

.meas tran vdout1_18ck430 FIND v(dout1_18) AT=220.025n

.meas tran vdout1_19ck430 FIND v(dout1_19) AT=220.025n

.meas tran vdout1_20ck430 FIND v(dout1_20) AT=220.025n

.meas tran vdout1_21ck430 FIND v(dout1_21) AT=220.025n

.meas tran vdout1_22ck430 FIND v(dout1_22) AT=220.025n

.meas tran vdout1_23ck430 FIND v(dout1_23) AT=220.025n

.meas tran vdout1_24ck430 FIND v(dout1_24) AT=220.025n

.meas tran vdout1_25ck430 FIND v(dout1_25) AT=220.025n

.meas tran vdout1_26ck430 FIND v(dout1_26) AT=220.025n

.meas tran vdout1_27ck430 FIND v(dout1_27) AT=220.025n

.meas tran vdout1_28ck430 FIND v(dout1_28) AT=220.025n

.meas tran vdout1_29ck430 FIND v(dout1_29) AT=220.025n

.meas tran vdout1_30ck430 FIND v(dout1_30) AT=220.025n

.meas tran vdout1_31ck430 FIND v(dout1_31) AT=220.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_16ck460 FIND v(dout1_16) AT=235.025n

.meas tran vdout1_17ck460 FIND v(dout1_17) AT=235.025n

.meas tran vdout1_18ck460 FIND v(dout1_18) AT=235.025n

.meas tran vdout1_19ck460 FIND v(dout1_19) AT=235.025n

.meas tran vdout1_20ck460 FIND v(dout1_20) AT=235.025n

.meas tran vdout1_21ck460 FIND v(dout1_21) AT=235.025n

.meas tran vdout1_22ck460 FIND v(dout1_22) AT=235.025n

.meas tran vdout1_23ck460 FIND v(dout1_23) AT=235.025n

.meas tran vdout1_24ck460 FIND v(dout1_24) AT=235.025n

.meas tran vdout1_25ck460 FIND v(dout1_25) AT=235.025n

.meas tran vdout1_26ck460 FIND v(dout1_26) AT=235.025n

.meas tran vdout1_27ck460 FIND v(dout1_27) AT=235.025n

.meas tran vdout1_28ck460 FIND v(dout1_28) AT=235.025n

.meas tran vdout1_29ck460 FIND v(dout1_29) AT=235.025n

.meas tran vdout1_30ck460 FIND v(dout1_30) AT=235.025n

.meas tran vdout1_31ck460 FIND v(dout1_31) AT=235.025n

.meas tran vdout1_0ck470 FIND v(dout1_0) AT=240.025n

.meas tran vdout1_1ck470 FIND v(dout1_1) AT=240.025n

.meas tran vdout1_2ck470 FIND v(dout1_2) AT=240.025n

.meas tran vdout1_3ck470 FIND v(dout1_3) AT=240.025n

.meas tran vdout1_4ck470 FIND v(dout1_4) AT=240.025n

.meas tran vdout1_5ck470 FIND v(dout1_5) AT=240.025n

.meas tran vdout1_6ck470 FIND v(dout1_6) AT=240.025n

.meas tran vdout1_7ck470 FIND v(dout1_7) AT=240.025n

.meas tran vdout1_8ck470 FIND v(dout1_8) AT=240.025n

.meas tran vdout1_9ck470 FIND v(dout1_9) AT=240.025n

.meas tran vdout1_10ck470 FIND v(dout1_10) AT=240.025n

.meas tran vdout1_11ck470 FIND v(dout1_11) AT=240.025n

.meas tran vdout1_12ck470 FIND v(dout1_12) AT=240.025n

.meas tran vdout1_13ck470 FIND v(dout1_13) AT=240.025n

.meas tran vdout1_14ck470 FIND v(dout1_14) AT=240.025n

.meas tran vdout1_15ck470 FIND v(dout1_15) AT=240.025n

.meas tran vdout1_16ck470 FIND v(dout1_16) AT=240.025n

.meas tran vdout1_17ck470 FIND v(dout1_17) AT=240.025n

.meas tran vdout1_18ck470 FIND v(dout1_18) AT=240.025n

.meas tran vdout1_19ck470 FIND v(dout1_19) AT=240.025n

.meas tran vdout1_20ck470 FIND v(dout1_20) AT=240.025n

.meas tran vdout1_21ck470 FIND v(dout1_21) AT=240.025n

.meas tran vdout1_22ck470 FIND v(dout1_22) AT=240.025n

.meas tran vdout1_23ck470 FIND v(dout1_23) AT=240.025n

.meas tran vdout1_24ck470 FIND v(dout1_24) AT=240.025n

.meas tran vdout1_25ck470 FIND v(dout1_25) AT=240.025n

.meas tran vdout1_26ck470 FIND v(dout1_26) AT=240.025n

.meas tran vdout1_27ck470 FIND v(dout1_27) AT=240.025n

.meas tran vdout1_28ck470 FIND v(dout1_28) AT=240.025n

.meas tran vdout1_29ck470 FIND v(dout1_29) AT=240.025n

.meas tran vdout1_30ck470 FIND v(dout1_30) AT=240.025n

.meas tran vdout1_31ck470 FIND v(dout1_31) AT=240.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_22ck480 FIND v(dout1_22) AT=245.025n

.meas tran vdout1_23ck480 FIND v(dout1_23) AT=245.025n

.meas tran vdout1_24ck480 FIND v(dout1_24) AT=245.025n

.meas tran vdout1_25ck480 FIND v(dout1_25) AT=245.025n

.meas tran vdout1_26ck480 FIND v(dout1_26) AT=245.025n

.meas tran vdout1_27ck480 FIND v(dout1_27) AT=245.025n

.meas tran vdout1_28ck480 FIND v(dout1_28) AT=245.025n

.meas tran vdout1_29ck480 FIND v(dout1_29) AT=245.025n

.meas tran vdout1_30ck480 FIND v(dout1_30) AT=245.025n

.meas tran vdout1_31ck480 FIND v(dout1_31) AT=245.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_8ck520 FIND v(dout1_8) AT=265.025n

.meas tran vdout1_9ck520 FIND v(dout1_9) AT=265.025n

.meas tran vdout1_10ck520 FIND v(dout1_10) AT=265.025n

.meas tran vdout1_11ck520 FIND v(dout1_11) AT=265.025n

.meas tran vdout1_12ck520 FIND v(dout1_12) AT=265.025n

.meas tran vdout1_13ck520 FIND v(dout1_13) AT=265.025n

.meas tran vdout1_14ck520 FIND v(dout1_14) AT=265.025n

.meas tran vdout1_15ck520 FIND v(dout1_15) AT=265.025n

.meas tran vdout1_16ck520 FIND v(dout1_16) AT=265.025n

.meas tran vdout1_17ck520 FIND v(dout1_17) AT=265.025n

.meas tran vdout1_18ck520 FIND v(dout1_18) AT=265.025n

.meas tran vdout1_19ck520 FIND v(dout1_19) AT=265.025n

.meas tran vdout1_20ck520 FIND v(dout1_20) AT=265.025n

.meas tran vdout1_21ck520 FIND v(dout1_21) AT=265.025n

.meas tran vdout1_22ck520 FIND v(dout1_22) AT=265.025n

.meas tran vdout1_23ck520 FIND v(dout1_23) AT=265.025n

.meas tran vdout1_24ck520 FIND v(dout1_24) AT=265.025n

.meas tran vdout1_25ck520 FIND v(dout1_25) AT=265.025n

.meas tran vdout1_26ck520 FIND v(dout1_26) AT=265.025n

.meas tran vdout1_27ck520 FIND v(dout1_27) AT=265.025n

.meas tran vdout1_28ck520 FIND v(dout1_28) AT=265.025n

.meas tran vdout1_29ck520 FIND v(dout1_29) AT=265.025n

.meas tran vdout1_30ck520 FIND v(dout1_30) AT=265.025n

.meas tran vdout1_31ck520 FIND v(dout1_31) AT=265.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_16ck550 FIND v(dout1_16) AT=280.025n

.meas tran vdout1_17ck550 FIND v(dout1_17) AT=280.025n

.meas tran vdout1_18ck550 FIND v(dout1_18) AT=280.025n

.meas tran vdout1_19ck550 FIND v(dout1_19) AT=280.025n

.meas tran vdout1_20ck550 FIND v(dout1_20) AT=280.025n

.meas tran vdout1_21ck550 FIND v(dout1_21) AT=280.025n

.meas tran vdout1_22ck550 FIND v(dout1_22) AT=280.025n

.meas tran vdout1_23ck550 FIND v(dout1_23) AT=280.025n

.meas tran vdout1_24ck550 FIND v(dout1_24) AT=280.025n

.meas tran vdout1_25ck550 FIND v(dout1_25) AT=280.025n

.meas tran vdout1_26ck550 FIND v(dout1_26) AT=280.025n

.meas tran vdout1_27ck550 FIND v(dout1_27) AT=280.025n

.meas tran vdout1_28ck550 FIND v(dout1_28) AT=280.025n

.meas tran vdout1_29ck550 FIND v(dout1_29) AT=280.025n

.meas tran vdout1_30ck550 FIND v(dout1_30) AT=280.025n

.meas tran vdout1_31ck550 FIND v(dout1_31) AT=280.025n

.meas tran vdout1_0ck560 FIND v(dout1_0) AT=285.025n

.meas tran vdout1_1ck560 FIND v(dout1_1) AT=285.025n

.meas tran vdout1_2ck560 FIND v(dout1_2) AT=285.025n

.meas tran vdout1_3ck560 FIND v(dout1_3) AT=285.025n

.meas tran vdout1_4ck560 FIND v(dout1_4) AT=285.025n

.meas tran vdout1_5ck560 FIND v(dout1_5) AT=285.025n

.meas tran vdout1_6ck560 FIND v(dout1_6) AT=285.025n

.meas tran vdout1_7ck560 FIND v(dout1_7) AT=285.025n

.meas tran vdout1_8ck560 FIND v(dout1_8) AT=285.025n

.meas tran vdout1_9ck560 FIND v(dout1_9) AT=285.025n

.meas tran vdout1_10ck560 FIND v(dout1_10) AT=285.025n

.meas tran vdout1_11ck560 FIND v(dout1_11) AT=285.025n

.meas tran vdout1_12ck560 FIND v(dout1_12) AT=285.025n

.meas tran vdout1_13ck560 FIND v(dout1_13) AT=285.025n

.meas tran vdout1_14ck560 FIND v(dout1_14) AT=285.025n

.meas tran vdout1_15ck560 FIND v(dout1_15) AT=285.025n

.meas tran vdout1_16ck560 FIND v(dout1_16) AT=285.025n

.meas tran vdout1_17ck560 FIND v(dout1_17) AT=285.025n

.meas tran vdout1_18ck560 FIND v(dout1_18) AT=285.025n

.meas tran vdout1_19ck560 FIND v(dout1_19) AT=285.025n

.meas tran vdout1_20ck560 FIND v(dout1_20) AT=285.025n

.meas tran vdout1_21ck560 FIND v(dout1_21) AT=285.025n

.meas tran vdout1_22ck560 FIND v(dout1_22) AT=285.025n

.meas tran vdout1_23ck560 FIND v(dout1_23) AT=285.025n

.meas tran vdout1_24ck560 FIND v(dout1_24) AT=285.025n

.meas tran vdout1_25ck560 FIND v(dout1_25) AT=285.025n

.meas tran vdout1_26ck560 FIND v(dout1_26) AT=285.025n

.meas tran vdout1_27ck560 FIND v(dout1_27) AT=285.025n

.meas tran vdout1_28ck560 FIND v(dout1_28) AT=285.025n

.meas tran vdout1_29ck560 FIND v(dout1_29) AT=285.025n

.meas tran vdout1_30ck560 FIND v(dout1_30) AT=285.025n

.meas tran vdout1_31ck560 FIND v(dout1_31) AT=285.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_22ck570 FIND v(dout1_22) AT=290.025n

.meas tran vdout1_23ck570 FIND v(dout1_23) AT=290.025n

.meas tran vdout1_24ck570 FIND v(dout1_24) AT=290.025n

.meas tran vdout1_25ck570 FIND v(dout1_25) AT=290.025n

.meas tran vdout1_26ck570 FIND v(dout1_26) AT=290.025n

.meas tran vdout1_27ck570 FIND v(dout1_27) AT=290.025n

.meas tran vdout1_28ck570 FIND v(dout1_28) AT=290.025n

.meas tran vdout1_29ck570 FIND v(dout1_29) AT=290.025n

.meas tran vdout1_30ck570 FIND v(dout1_30) AT=290.025n

.meas tran vdout1_31ck570 FIND v(dout1_31) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_23ck580 FIND v(dout1_23) AT=295.025n

.meas tran vdout1_24ck580 FIND v(dout1_24) AT=295.025n

.meas tran vdout1_25ck580 FIND v(dout1_25) AT=295.025n

.meas tran vdout1_26ck580 FIND v(dout1_26) AT=295.025n

.meas tran vdout1_27ck580 FIND v(dout1_27) AT=295.025n

.meas tran vdout1_28ck580 FIND v(dout1_28) AT=295.025n

.meas tran vdout1_29ck580 FIND v(dout1_29) AT=295.025n

.meas tran vdout1_30ck580 FIND v(dout1_30) AT=295.025n

.meas tran vdout1_31ck580 FIND v(dout1_31) AT=295.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_19ck650 FIND v(dout1_19) AT=330.025n

.meas tran vdout1_20ck650 FIND v(dout1_20) AT=330.025n

.meas tran vdout1_21ck650 FIND v(dout1_21) AT=330.025n

.meas tran vdout1_22ck650 FIND v(dout1_22) AT=330.025n

.meas tran vdout1_23ck650 FIND v(dout1_23) AT=330.025n

.meas tran vdout1_24ck650 FIND v(dout1_24) AT=330.025n

.meas tran vdout1_25ck650 FIND v(dout1_25) AT=330.025n

.meas tran vdout1_26ck650 FIND v(dout1_26) AT=330.025n

.meas tran vdout1_27ck650 FIND v(dout1_27) AT=330.025n

.meas tran vdout1_28ck650 FIND v(dout1_28) AT=330.025n

.meas tran vdout1_29ck650 FIND v(dout1_29) AT=330.025n

.meas tran vdout1_30ck650 FIND v(dout1_30) AT=330.025n

.meas tran vdout1_31ck650 FIND v(dout1_31) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_22ck660 FIND v(dout1_22) AT=335.025n

.meas tran vdout1_23ck660 FIND v(dout1_23) AT=335.025n

.meas tran vdout1_24ck660 FIND v(dout1_24) AT=335.025n

.meas tran vdout1_25ck660 FIND v(dout1_25) AT=335.025n

.meas tran vdout1_26ck660 FIND v(dout1_26) AT=335.025n

.meas tran vdout1_27ck660 FIND v(dout1_27) AT=335.025n

.meas tran vdout1_28ck660 FIND v(dout1_28) AT=335.025n

.meas tran vdout1_29ck660 FIND v(dout1_29) AT=335.025n

.meas tran vdout1_30ck660 FIND v(dout1_30) AT=335.025n

.meas tran vdout1_31ck660 FIND v(dout1_31) AT=335.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_19ck670 FIND v(dout1_19) AT=340.025n

.meas tran vdout1_20ck670 FIND v(dout1_20) AT=340.025n

.meas tran vdout1_21ck670 FIND v(dout1_21) AT=340.025n

.meas tran vdout1_22ck670 FIND v(dout1_22) AT=340.025n

.meas tran vdout1_23ck670 FIND v(dout1_23) AT=340.025n

.meas tran vdout1_24ck670 FIND v(dout1_24) AT=340.025n

.meas tran vdout1_25ck670 FIND v(dout1_25) AT=340.025n

.meas tran vdout1_26ck670 FIND v(dout1_26) AT=340.025n

.meas tran vdout1_27ck670 FIND v(dout1_27) AT=340.025n

.meas tran vdout1_28ck670 FIND v(dout1_28) AT=340.025n

.meas tran vdout1_29ck670 FIND v(dout1_29) AT=340.025n

.meas tran vdout1_30ck670 FIND v(dout1_30) AT=340.025n

.meas tran vdout1_31ck670 FIND v(dout1_31) AT=340.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_19ck680 FIND v(dout1_19) AT=345.025n

.meas tran vdout1_20ck680 FIND v(dout1_20) AT=345.025n

.meas tran vdout1_21ck680 FIND v(dout1_21) AT=345.025n

.meas tran vdout1_22ck680 FIND v(dout1_22) AT=345.025n

.meas tran vdout1_23ck680 FIND v(dout1_23) AT=345.025n

.meas tran vdout1_24ck680 FIND v(dout1_24) AT=345.025n

.meas tran vdout1_25ck680 FIND v(dout1_25) AT=345.025n

.meas tran vdout1_26ck680 FIND v(dout1_26) AT=345.025n

.meas tran vdout1_27ck680 FIND v(dout1_27) AT=345.025n

.meas tran vdout1_28ck680 FIND v(dout1_28) AT=345.025n

.meas tran vdout1_29ck680 FIND v(dout1_29) AT=345.025n

.meas tran vdout1_30ck680 FIND v(dout1_30) AT=345.025n

.meas tran vdout1_31ck680 FIND v(dout1_31) AT=345.025n

.meas tran vdout1_0ck690 FIND v(dout1_0) AT=350.025n

.meas tran vdout1_1ck690 FIND v(dout1_1) AT=350.025n

.meas tran vdout1_2ck690 FIND v(dout1_2) AT=350.025n

.meas tran vdout1_3ck690 FIND v(dout1_3) AT=350.025n

.meas tran vdout1_4ck690 FIND v(dout1_4) AT=350.025n

.meas tran vdout1_5ck690 FIND v(dout1_5) AT=350.025n

.meas tran vdout1_6ck690 FIND v(dout1_6) AT=350.025n

.meas tran vdout1_7ck690 FIND v(dout1_7) AT=350.025n

.meas tran vdout1_8ck690 FIND v(dout1_8) AT=350.025n

.meas tran vdout1_9ck690 FIND v(dout1_9) AT=350.025n

.meas tran vdout1_10ck690 FIND v(dout1_10) AT=350.025n

.meas tran vdout1_11ck690 FIND v(dout1_11) AT=350.025n

.meas tran vdout1_12ck690 FIND v(dout1_12) AT=350.025n

.meas tran vdout1_13ck690 FIND v(dout1_13) AT=350.025n

.meas tran vdout1_14ck690 FIND v(dout1_14) AT=350.025n

.meas tran vdout1_15ck690 FIND v(dout1_15) AT=350.025n

.meas tran vdout1_16ck690 FIND v(dout1_16) AT=350.025n

.meas tran vdout1_17ck690 FIND v(dout1_17) AT=350.025n

.meas tran vdout1_18ck690 FIND v(dout1_18) AT=350.025n

.meas tran vdout1_19ck690 FIND v(dout1_19) AT=350.025n

.meas tran vdout1_20ck690 FIND v(dout1_20) AT=350.025n

.meas tran vdout1_21ck690 FIND v(dout1_21) AT=350.025n

.meas tran vdout1_22ck690 FIND v(dout1_22) AT=350.025n

.meas tran vdout1_23ck690 FIND v(dout1_23) AT=350.025n

.meas tran vdout1_24ck690 FIND v(dout1_24) AT=350.025n

.meas tran vdout1_25ck690 FIND v(dout1_25) AT=350.025n

.meas tran vdout1_26ck690 FIND v(dout1_26) AT=350.025n

.meas tran vdout1_27ck690 FIND v(dout1_27) AT=350.025n

.meas tran vdout1_28ck690 FIND v(dout1_28) AT=350.025n

.meas tran vdout1_29ck690 FIND v(dout1_29) AT=350.025n

.meas tran vdout1_30ck690 FIND v(dout1_30) AT=350.025n

.meas tran vdout1_31ck690 FIND v(dout1_31) AT=350.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_17ck700 FIND v(dout1_17) AT=355.025n

.meas tran vdout1_18ck700 FIND v(dout1_18) AT=355.025n

.meas tran vdout1_19ck700 FIND v(dout1_19) AT=355.025n

.meas tran vdout1_20ck700 FIND v(dout1_20) AT=355.025n

.meas tran vdout1_21ck700 FIND v(dout1_21) AT=355.025n

.meas tran vdout1_22ck700 FIND v(dout1_22) AT=355.025n

.meas tran vdout1_23ck700 FIND v(dout1_23) AT=355.025n

.meas tran vdout1_24ck700 FIND v(dout1_24) AT=355.025n

.meas tran vdout1_25ck700 FIND v(dout1_25) AT=355.025n

.meas tran vdout1_26ck700 FIND v(dout1_26) AT=355.025n

.meas tran vdout1_27ck700 FIND v(dout1_27) AT=355.025n

.meas tran vdout1_28ck700 FIND v(dout1_28) AT=355.025n

.meas tran vdout1_29ck700 FIND v(dout1_29) AT=355.025n

.meas tran vdout1_30ck700 FIND v(dout1_30) AT=355.025n

.meas tran vdout1_31ck700 FIND v(dout1_31) AT=355.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_22ck720 FIND v(dout1_22) AT=365.025n

.meas tran vdout1_23ck720 FIND v(dout1_23) AT=365.025n

.meas tran vdout1_24ck720 FIND v(dout1_24) AT=365.025n

.meas tran vdout1_25ck720 FIND v(dout1_25) AT=365.025n

.meas tran vdout1_26ck720 FIND v(dout1_26) AT=365.025n

.meas tran vdout1_27ck720 FIND v(dout1_27) AT=365.025n

.meas tran vdout1_28ck720 FIND v(dout1_28) AT=365.025n

.meas tran vdout1_29ck720 FIND v(dout1_29) AT=365.025n

.meas tran vdout1_30ck720 FIND v(dout1_30) AT=365.025n

.meas tran vdout1_31ck720 FIND v(dout1_31) AT=365.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_17ck730 FIND v(dout1_17) AT=370.025n

.meas tran vdout1_18ck730 FIND v(dout1_18) AT=370.025n

.meas tran vdout1_19ck730 FIND v(dout1_19) AT=370.025n

.meas tran vdout1_20ck730 FIND v(dout1_20) AT=370.025n

.meas tran vdout1_21ck730 FIND v(dout1_21) AT=370.025n

.meas tran vdout1_22ck730 FIND v(dout1_22) AT=370.025n

.meas tran vdout1_23ck730 FIND v(dout1_23) AT=370.025n

.meas tran vdout1_24ck730 FIND v(dout1_24) AT=370.025n

.meas tran vdout1_25ck730 FIND v(dout1_25) AT=370.025n

.meas tran vdout1_26ck730 FIND v(dout1_26) AT=370.025n

.meas tran vdout1_27ck730 FIND v(dout1_27) AT=370.025n

.meas tran vdout1_28ck730 FIND v(dout1_28) AT=370.025n

.meas tran vdout1_29ck730 FIND v(dout1_29) AT=370.025n

.meas tran vdout1_30ck730 FIND v(dout1_30) AT=370.025n

.meas tran vdout1_31ck730 FIND v(dout1_31) AT=370.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_22ck740 FIND v(dout1_22) AT=375.025n

.meas tran vdout1_23ck740 FIND v(dout1_23) AT=375.025n

.meas tran vdout1_24ck740 FIND v(dout1_24) AT=375.025n

.meas tran vdout1_25ck740 FIND v(dout1_25) AT=375.025n

.meas tran vdout1_26ck740 FIND v(dout1_26) AT=375.025n

.meas tran vdout1_27ck740 FIND v(dout1_27) AT=375.025n

.meas tran vdout1_28ck740 FIND v(dout1_28) AT=375.025n

.meas tran vdout1_29ck740 FIND v(dout1_29) AT=375.025n

.meas tran vdout1_30ck740 FIND v(dout1_30) AT=375.025n

.meas tran vdout1_31ck740 FIND v(dout1_31) AT=375.025n

.meas tran vdout1_0ck750 FIND v(dout1_0) AT=380.025n

.meas tran vdout1_1ck750 FIND v(dout1_1) AT=380.025n

.meas tran vdout1_2ck750 FIND v(dout1_2) AT=380.025n

.meas tran vdout1_3ck750 FIND v(dout1_3) AT=380.025n

.meas tran vdout1_4ck750 FIND v(dout1_4) AT=380.025n

.meas tran vdout1_5ck750 FIND v(dout1_5) AT=380.025n

.meas tran vdout1_6ck750 FIND v(dout1_6) AT=380.025n

.meas tran vdout1_7ck750 FIND v(dout1_7) AT=380.025n

.meas tran vdout1_8ck750 FIND v(dout1_8) AT=380.025n

.meas tran vdout1_9ck750 FIND v(dout1_9) AT=380.025n

.meas tran vdout1_10ck750 FIND v(dout1_10) AT=380.025n

.meas tran vdout1_11ck750 FIND v(dout1_11) AT=380.025n

.meas tran vdout1_12ck750 FIND v(dout1_12) AT=380.025n

.meas tran vdout1_13ck750 FIND v(dout1_13) AT=380.025n

.meas tran vdout1_14ck750 FIND v(dout1_14) AT=380.025n

.meas tran vdout1_15ck750 FIND v(dout1_15) AT=380.025n

.meas tran vdout1_16ck750 FIND v(dout1_16) AT=380.025n

.meas tran vdout1_17ck750 FIND v(dout1_17) AT=380.025n

.meas tran vdout1_18ck750 FIND v(dout1_18) AT=380.025n

.meas tran vdout1_19ck750 FIND v(dout1_19) AT=380.025n

.meas tran vdout1_20ck750 FIND v(dout1_20) AT=380.025n

.meas tran vdout1_21ck750 FIND v(dout1_21) AT=380.025n

.meas tran vdout1_22ck750 FIND v(dout1_22) AT=380.025n

.meas tran vdout1_23ck750 FIND v(dout1_23) AT=380.025n

.meas tran vdout1_24ck750 FIND v(dout1_24) AT=380.025n

.meas tran vdout1_25ck750 FIND v(dout1_25) AT=380.025n

.meas tran vdout1_26ck750 FIND v(dout1_26) AT=380.025n

.meas tran vdout1_27ck750 FIND v(dout1_27) AT=380.025n

.meas tran vdout1_28ck750 FIND v(dout1_28) AT=380.025n

.meas tran vdout1_29ck750 FIND v(dout1_29) AT=380.025n

.meas tran vdout1_30ck750 FIND v(dout1_30) AT=380.025n

.meas tran vdout1_31ck750 FIND v(dout1_31) AT=380.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_23ck770 FIND v(dout1_23) AT=390.025n

.meas tran vdout1_24ck770 FIND v(dout1_24) AT=390.025n

.meas tran vdout1_25ck770 FIND v(dout1_25) AT=390.025n

.meas tran vdout1_26ck770 FIND v(dout1_26) AT=390.025n

.meas tran vdout1_27ck770 FIND v(dout1_27) AT=390.025n

.meas tran vdout1_28ck770 FIND v(dout1_28) AT=390.025n

.meas tran vdout1_29ck770 FIND v(dout1_29) AT=390.025n

.meas tran vdout1_30ck770 FIND v(dout1_30) AT=390.025n

.meas tran vdout1_31ck770 FIND v(dout1_31) AT=390.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_0ck900 FIND v(dout1_0) AT=455.025n

.meas tran vdout1_1ck900 FIND v(dout1_1) AT=455.025n

.meas tran vdout1_2ck900 FIND v(dout1_2) AT=455.025n

.meas tran vdout1_3ck900 FIND v(dout1_3) AT=455.025n

.meas tran vdout1_4ck900 FIND v(dout1_4) AT=455.025n

.meas tran vdout1_5ck900 FIND v(dout1_5) AT=455.025n

.meas tran vdout1_6ck900 FIND v(dout1_6) AT=455.025n

.meas tran vdout1_7ck900 FIND v(dout1_7) AT=455.025n

.meas tran vdout1_8ck900 FIND v(dout1_8) AT=455.025n

.meas tran vdout1_9ck900 FIND v(dout1_9) AT=455.025n

.meas tran vdout1_10ck900 FIND v(dout1_10) AT=455.025n

.meas tran vdout1_11ck900 FIND v(dout1_11) AT=455.025n

.meas tran vdout1_12ck900 FIND v(dout1_12) AT=455.025n

.meas tran vdout1_13ck900 FIND v(dout1_13) AT=455.025n

.meas tran vdout1_14ck900 FIND v(dout1_14) AT=455.025n

.meas tran vdout1_15ck900 FIND v(dout1_15) AT=455.025n

.meas tran vdout1_16ck900 FIND v(dout1_16) AT=455.025n

.meas tran vdout1_17ck900 FIND v(dout1_17) AT=455.025n

.meas tran vdout1_18ck900 FIND v(dout1_18) AT=455.025n

.meas tran vdout1_19ck900 FIND v(dout1_19) AT=455.025n

.meas tran vdout1_20ck900 FIND v(dout1_20) AT=455.025n

.meas tran vdout1_21ck900 FIND v(dout1_21) AT=455.025n

.meas tran vdout1_22ck900 FIND v(dout1_22) AT=455.025n

.meas tran vdout1_23ck900 FIND v(dout1_23) AT=455.025n

.meas tran vdout1_24ck900 FIND v(dout1_24) AT=455.025n

.meas tran vdout1_25ck900 FIND v(dout1_25) AT=455.025n

.meas tran vdout1_26ck900 FIND v(dout1_26) AT=455.025n

.meas tran vdout1_27ck900 FIND v(dout1_27) AT=455.025n

.meas tran vdout1_28ck900 FIND v(dout1_28) AT=455.025n

.meas tran vdout1_29ck900 FIND v(dout1_29) AT=455.025n

.meas tran vdout1_30ck900 FIND v(dout1_30) AT=455.025n

.meas tran vdout1_31ck900 FIND v(dout1_31) AT=455.025n

.meas tran vdout1_0ck910 FIND v(dout1_0) AT=460.025n

.meas tran vdout1_1ck910 FIND v(dout1_1) AT=460.025n

.meas tran vdout1_2ck910 FIND v(dout1_2) AT=460.025n

.meas tran vdout1_3ck910 FIND v(dout1_3) AT=460.025n

.meas tran vdout1_4ck910 FIND v(dout1_4) AT=460.025n

.meas tran vdout1_5ck910 FIND v(dout1_5) AT=460.025n

.meas tran vdout1_6ck910 FIND v(dout1_6) AT=460.025n

.meas tran vdout1_7ck910 FIND v(dout1_7) AT=460.025n

.meas tran vdout1_8ck910 FIND v(dout1_8) AT=460.025n

.meas tran vdout1_9ck910 FIND v(dout1_9) AT=460.025n

.meas tran vdout1_10ck910 FIND v(dout1_10) AT=460.025n

.meas tran vdout1_11ck910 FIND v(dout1_11) AT=460.025n

.meas tran vdout1_12ck910 FIND v(dout1_12) AT=460.025n

.meas tran vdout1_13ck910 FIND v(dout1_13) AT=460.025n

.meas tran vdout1_14ck910 FIND v(dout1_14) AT=460.025n

.meas tran vdout1_15ck910 FIND v(dout1_15) AT=460.025n

.meas tran vdout1_16ck910 FIND v(dout1_16) AT=460.025n

.meas tran vdout1_17ck910 FIND v(dout1_17) AT=460.025n

.meas tran vdout1_18ck910 FIND v(dout1_18) AT=460.025n

.meas tran vdout1_19ck910 FIND v(dout1_19) AT=460.025n

.meas tran vdout1_20ck910 FIND v(dout1_20) AT=460.025n

.meas tran vdout1_21ck910 FIND v(dout1_21) AT=460.025n

.meas tran vdout1_22ck910 FIND v(dout1_22) AT=460.025n

.meas tran vdout1_23ck910 FIND v(dout1_23) AT=460.025n

.meas tran vdout1_24ck910 FIND v(dout1_24) AT=460.025n

.meas tran vdout1_25ck910 FIND v(dout1_25) AT=460.025n

.meas tran vdout1_26ck910 FIND v(dout1_26) AT=460.025n

.meas tran vdout1_27ck910 FIND v(dout1_27) AT=460.025n

.meas tran vdout1_28ck910 FIND v(dout1_28) AT=460.025n

.meas tran vdout1_29ck910 FIND v(dout1_29) AT=460.025n

.meas tran vdout1_30ck910 FIND v(dout1_30) AT=460.025n

.meas tran vdout1_31ck910 FIND v(dout1_31) AT=460.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_22ck950 FIND v(dout1_22) AT=480.025n

.meas tran vdout1_23ck950 FIND v(dout1_23) AT=480.025n

.meas tran vdout1_24ck950 FIND v(dout1_24) AT=480.025n

.meas tran vdout1_25ck950 FIND v(dout1_25) AT=480.025n

.meas tran vdout1_26ck950 FIND v(dout1_26) AT=480.025n

.meas tran vdout1_27ck950 FIND v(dout1_27) AT=480.025n

.meas tran vdout1_28ck950 FIND v(dout1_28) AT=480.025n

.meas tran vdout1_29ck950 FIND v(dout1_29) AT=480.025n

.meas tran vdout1_30ck950 FIND v(dout1_30) AT=480.025n

.meas tran vdout1_31ck950 FIND v(dout1_31) AT=480.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_0ck970 FIND v(dout1_0) AT=490.025n

.meas tran vdout1_1ck970 FIND v(dout1_1) AT=490.025n

.meas tran vdout1_2ck970 FIND v(dout1_2) AT=490.025n

.meas tran vdout1_3ck970 FIND v(dout1_3) AT=490.025n

.meas tran vdout1_4ck970 FIND v(dout1_4) AT=490.025n

.meas tran vdout1_5ck970 FIND v(dout1_5) AT=490.025n

.meas tran vdout1_6ck970 FIND v(dout1_6) AT=490.025n

.meas tran vdout1_7ck970 FIND v(dout1_7) AT=490.025n

.meas tran vdout1_8ck970 FIND v(dout1_8) AT=490.025n

.meas tran vdout1_9ck970 FIND v(dout1_9) AT=490.025n

.meas tran vdout1_10ck970 FIND v(dout1_10) AT=490.025n

.meas tran vdout1_11ck970 FIND v(dout1_11) AT=490.025n

.meas tran vdout1_12ck970 FIND v(dout1_12) AT=490.025n

.meas tran vdout1_13ck970 FIND v(dout1_13) AT=490.025n

.meas tran vdout1_14ck970 FIND v(dout1_14) AT=490.025n

.meas tran vdout1_15ck970 FIND v(dout1_15) AT=490.025n

.meas tran vdout1_16ck970 FIND v(dout1_16) AT=490.025n

.meas tran vdout1_17ck970 FIND v(dout1_17) AT=490.025n

.meas tran vdout1_18ck970 FIND v(dout1_18) AT=490.025n

.meas tran vdout1_19ck970 FIND v(dout1_19) AT=490.025n

.meas tran vdout1_20ck970 FIND v(dout1_20) AT=490.025n

.meas tran vdout1_21ck970 FIND v(dout1_21) AT=490.025n

.meas tran vdout1_22ck970 FIND v(dout1_22) AT=490.025n

.meas tran vdout1_23ck970 FIND v(dout1_23) AT=490.025n

.meas tran vdout1_24ck970 FIND v(dout1_24) AT=490.025n

.meas tran vdout1_25ck970 FIND v(dout1_25) AT=490.025n

.meas tran vdout1_26ck970 FIND v(dout1_26) AT=490.025n

.meas tran vdout1_27ck970 FIND v(dout1_27) AT=490.025n

.meas tran vdout1_28ck970 FIND v(dout1_28) AT=490.025n

.meas tran vdout1_29ck970 FIND v(dout1_29) AT=490.025n

.meas tran vdout1_30ck970 FIND v(dout1_30) AT=490.025n

.meas tran vdout1_31ck970 FIND v(dout1_31) AT=490.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_23ck990 FIND v(dout1_23) AT=500.025n

.meas tran vdout1_24ck990 FIND v(dout1_24) AT=500.025n

.meas tran vdout1_25ck990 FIND v(dout1_25) AT=500.025n

.meas tran vdout1_26ck990 FIND v(dout1_26) AT=500.025n

.meas tran vdout1_27ck990 FIND v(dout1_27) AT=500.025n

.meas tran vdout1_28ck990 FIND v(dout1_28) AT=500.025n

.meas tran vdout1_29ck990 FIND v(dout1_29) AT=500.025n

.meas tran vdout1_30ck990 FIND v(dout1_30) AT=500.025n

.meas tran vdout1_31ck990 FIND v(dout1_31) AT=500.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_17ck1020 FIND v(dout1_17) AT=515.025n

.meas tran vdout1_18ck1020 FIND v(dout1_18) AT=515.025n

.meas tran vdout1_19ck1020 FIND v(dout1_19) AT=515.025n

.meas tran vdout1_20ck1020 FIND v(dout1_20) AT=515.025n

.meas tran vdout1_21ck1020 FIND v(dout1_21) AT=515.025n

.meas tran vdout1_22ck1020 FIND v(dout1_22) AT=515.025n

.meas tran vdout1_23ck1020 FIND v(dout1_23) AT=515.025n

.meas tran vdout1_24ck1020 FIND v(dout1_24) AT=515.025n

.meas tran vdout1_25ck1020 FIND v(dout1_25) AT=515.025n

.meas tran vdout1_26ck1020 FIND v(dout1_26) AT=515.025n

.meas tran vdout1_27ck1020 FIND v(dout1_27) AT=515.025n

.meas tran vdout1_28ck1020 FIND v(dout1_28) AT=515.025n

.meas tran vdout1_29ck1020 FIND v(dout1_29) AT=515.025n

.meas tran vdout1_30ck1020 FIND v(dout1_30) AT=515.025n

.meas tran vdout1_31ck1020 FIND v(dout1_31) AT=515.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_23ck1070 FIND v(dout1_23) AT=540.025n

.meas tran vdout1_24ck1070 FIND v(dout1_24) AT=540.025n

.meas tran vdout1_25ck1070 FIND v(dout1_25) AT=540.025n

.meas tran vdout1_26ck1070 FIND v(dout1_26) AT=540.025n

.meas tran vdout1_27ck1070 FIND v(dout1_27) AT=540.025n

.meas tran vdout1_28ck1070 FIND v(dout1_28) AT=540.025n

.meas tran vdout1_29ck1070 FIND v(dout1_29) AT=540.025n

.meas tran vdout1_30ck1070 FIND v(dout1_30) AT=540.025n

.meas tran vdout1_31ck1070 FIND v(dout1_31) AT=540.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_23ck1090 FIND v(dout1_23) AT=550.025n

.meas tran vdout1_24ck1090 FIND v(dout1_24) AT=550.025n

.meas tran vdout1_25ck1090 FIND v(dout1_25) AT=550.025n

.meas tran vdout1_26ck1090 FIND v(dout1_26) AT=550.025n

.meas tran vdout1_27ck1090 FIND v(dout1_27) AT=550.025n

.meas tran vdout1_28ck1090 FIND v(dout1_28) AT=550.025n

.meas tran vdout1_29ck1090 FIND v(dout1_29) AT=550.025n

.meas tran vdout1_30ck1090 FIND v(dout1_30) AT=550.025n

.meas tran vdout1_31ck1090 FIND v(dout1_31) AT=550.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_22ck1100 FIND v(dout1_22) AT=555.025n

.meas tran vdout1_23ck1100 FIND v(dout1_23) AT=555.025n

.meas tran vdout1_24ck1100 FIND v(dout1_24) AT=555.025n

.meas tran vdout1_25ck1100 FIND v(dout1_25) AT=555.025n

.meas tran vdout1_26ck1100 FIND v(dout1_26) AT=555.025n

.meas tran vdout1_27ck1100 FIND v(dout1_27) AT=555.025n

.meas tran vdout1_28ck1100 FIND v(dout1_28) AT=555.025n

.meas tran vdout1_29ck1100 FIND v(dout1_29) AT=555.025n

.meas tran vdout1_30ck1100 FIND v(dout1_30) AT=555.025n

.meas tran vdout1_31ck1100 FIND v(dout1_31) AT=555.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_19ck1110 FIND v(dout1_19) AT=560.025n

.meas tran vdout1_20ck1110 FIND v(dout1_20) AT=560.025n

.meas tran vdout1_21ck1110 FIND v(dout1_21) AT=560.025n

.meas tran vdout1_22ck1110 FIND v(dout1_22) AT=560.025n

.meas tran vdout1_23ck1110 FIND v(dout1_23) AT=560.025n

.meas tran vdout1_24ck1110 FIND v(dout1_24) AT=560.025n

.meas tran vdout1_25ck1110 FIND v(dout1_25) AT=560.025n

.meas tran vdout1_26ck1110 FIND v(dout1_26) AT=560.025n

.meas tran vdout1_27ck1110 FIND v(dout1_27) AT=560.025n

.meas tran vdout1_28ck1110 FIND v(dout1_28) AT=560.025n

.meas tran vdout1_29ck1110 FIND v(dout1_29) AT=560.025n

.meas tran vdout1_30ck1110 FIND v(dout1_30) AT=560.025n

.meas tran vdout1_31ck1110 FIND v(dout1_31) AT=560.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_16ck1120 FIND v(dout1_16) AT=565.025n

.meas tran vdout1_17ck1120 FIND v(dout1_17) AT=565.025n

.meas tran vdout1_18ck1120 FIND v(dout1_18) AT=565.025n

.meas tran vdout1_19ck1120 FIND v(dout1_19) AT=565.025n

.meas tran vdout1_20ck1120 FIND v(dout1_20) AT=565.025n

.meas tran vdout1_21ck1120 FIND v(dout1_21) AT=565.025n

.meas tran vdout1_22ck1120 FIND v(dout1_22) AT=565.025n

.meas tran vdout1_23ck1120 FIND v(dout1_23) AT=565.025n

.meas tran vdout1_24ck1120 FIND v(dout1_24) AT=565.025n

.meas tran vdout1_25ck1120 FIND v(dout1_25) AT=565.025n

.meas tran vdout1_26ck1120 FIND v(dout1_26) AT=565.025n

.meas tran vdout1_27ck1120 FIND v(dout1_27) AT=565.025n

.meas tran vdout1_28ck1120 FIND v(dout1_28) AT=565.025n

.meas tran vdout1_29ck1120 FIND v(dout1_29) AT=565.025n

.meas tran vdout1_30ck1120 FIND v(dout1_30) AT=565.025n

.meas tran vdout1_31ck1120 FIND v(dout1_31) AT=565.025n

.meas tran vdout1_0ck1130 FIND v(dout1_0) AT=570.025n

.meas tran vdout1_1ck1130 FIND v(dout1_1) AT=570.025n

.meas tran vdout1_2ck1130 FIND v(dout1_2) AT=570.025n

.meas tran vdout1_3ck1130 FIND v(dout1_3) AT=570.025n

.meas tran vdout1_4ck1130 FIND v(dout1_4) AT=570.025n

.meas tran vdout1_5ck1130 FIND v(dout1_5) AT=570.025n

.meas tran vdout1_6ck1130 FIND v(dout1_6) AT=570.025n

.meas tran vdout1_7ck1130 FIND v(dout1_7) AT=570.025n

.meas tran vdout1_8ck1130 FIND v(dout1_8) AT=570.025n

.meas tran vdout1_9ck1130 FIND v(dout1_9) AT=570.025n

.meas tran vdout1_10ck1130 FIND v(dout1_10) AT=570.025n

.meas tran vdout1_11ck1130 FIND v(dout1_11) AT=570.025n

.meas tran vdout1_12ck1130 FIND v(dout1_12) AT=570.025n

.meas tran vdout1_13ck1130 FIND v(dout1_13) AT=570.025n

.meas tran vdout1_14ck1130 FIND v(dout1_14) AT=570.025n

.meas tran vdout1_15ck1130 FIND v(dout1_15) AT=570.025n

.meas tran vdout1_16ck1130 FIND v(dout1_16) AT=570.025n

.meas tran vdout1_17ck1130 FIND v(dout1_17) AT=570.025n

.meas tran vdout1_18ck1130 FIND v(dout1_18) AT=570.025n

.meas tran vdout1_19ck1130 FIND v(dout1_19) AT=570.025n

.meas tran vdout1_20ck1130 FIND v(dout1_20) AT=570.025n

.meas tran vdout1_21ck1130 FIND v(dout1_21) AT=570.025n

.meas tran vdout1_22ck1130 FIND v(dout1_22) AT=570.025n

.meas tran vdout1_23ck1130 FIND v(dout1_23) AT=570.025n

.meas tran vdout1_24ck1130 FIND v(dout1_24) AT=570.025n

.meas tran vdout1_25ck1130 FIND v(dout1_25) AT=570.025n

.meas tran vdout1_26ck1130 FIND v(dout1_26) AT=570.025n

.meas tran vdout1_27ck1130 FIND v(dout1_27) AT=570.025n

.meas tran vdout1_28ck1130 FIND v(dout1_28) AT=570.025n

.meas tran vdout1_29ck1130 FIND v(dout1_29) AT=570.025n

.meas tran vdout1_30ck1130 FIND v(dout1_30) AT=570.025n

.meas tran vdout1_31ck1130 FIND v(dout1_31) AT=570.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_17ck1160 FIND v(dout1_17) AT=585.025n

.meas tran vdout1_18ck1160 FIND v(dout1_18) AT=585.025n

.meas tran vdout1_19ck1160 FIND v(dout1_19) AT=585.025n

.meas tran vdout1_20ck1160 FIND v(dout1_20) AT=585.025n

.meas tran vdout1_21ck1160 FIND v(dout1_21) AT=585.025n

.meas tran vdout1_22ck1160 FIND v(dout1_22) AT=585.025n

.meas tran vdout1_23ck1160 FIND v(dout1_23) AT=585.025n

.meas tran vdout1_24ck1160 FIND v(dout1_24) AT=585.025n

.meas tran vdout1_25ck1160 FIND v(dout1_25) AT=585.025n

.meas tran vdout1_26ck1160 FIND v(dout1_26) AT=585.025n

.meas tran vdout1_27ck1160 FIND v(dout1_27) AT=585.025n

.meas tran vdout1_28ck1160 FIND v(dout1_28) AT=585.025n

.meas tran vdout1_29ck1160 FIND v(dout1_29) AT=585.025n

.meas tran vdout1_30ck1160 FIND v(dout1_30) AT=585.025n

.meas tran vdout1_31ck1160 FIND v(dout1_31) AT=585.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_8ck1180 FIND v(dout1_8) AT=595.025n

.meas tran vdout1_9ck1180 FIND v(dout1_9) AT=595.025n

.meas tran vdout1_10ck1180 FIND v(dout1_10) AT=595.025n

.meas tran vdout1_11ck1180 FIND v(dout1_11) AT=595.025n

.meas tran vdout1_12ck1180 FIND v(dout1_12) AT=595.025n

.meas tran vdout1_13ck1180 FIND v(dout1_13) AT=595.025n

.meas tran vdout1_14ck1180 FIND v(dout1_14) AT=595.025n

.meas tran vdout1_15ck1180 FIND v(dout1_15) AT=595.025n

.meas tran vdout1_16ck1180 FIND v(dout1_16) AT=595.025n

.meas tran vdout1_17ck1180 FIND v(dout1_17) AT=595.025n

.meas tran vdout1_18ck1180 FIND v(dout1_18) AT=595.025n

.meas tran vdout1_19ck1180 FIND v(dout1_19) AT=595.025n

.meas tran vdout1_20ck1180 FIND v(dout1_20) AT=595.025n

.meas tran vdout1_21ck1180 FIND v(dout1_21) AT=595.025n

.meas tran vdout1_22ck1180 FIND v(dout1_22) AT=595.025n

.meas tran vdout1_23ck1180 FIND v(dout1_23) AT=595.025n

.meas tran vdout1_24ck1180 FIND v(dout1_24) AT=595.025n

.meas tran vdout1_25ck1180 FIND v(dout1_25) AT=595.025n

.meas tran vdout1_26ck1180 FIND v(dout1_26) AT=595.025n

.meas tran vdout1_27ck1180 FIND v(dout1_27) AT=595.025n

.meas tran vdout1_28ck1180 FIND v(dout1_28) AT=595.025n

.meas tran vdout1_29ck1180 FIND v(dout1_29) AT=595.025n

.meas tran vdout1_30ck1180 FIND v(dout1_30) AT=595.025n

.meas tran vdout1_31ck1180 FIND v(dout1_31) AT=595.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_16ck1190 FIND v(dout1_16) AT=600.025n

.meas tran vdout1_17ck1190 FIND v(dout1_17) AT=600.025n

.meas tran vdout1_18ck1190 FIND v(dout1_18) AT=600.025n

.meas tran vdout1_19ck1190 FIND v(dout1_19) AT=600.025n

.meas tran vdout1_20ck1190 FIND v(dout1_20) AT=600.025n

.meas tran vdout1_21ck1190 FIND v(dout1_21) AT=600.025n

.meas tran vdout1_22ck1190 FIND v(dout1_22) AT=600.025n

.meas tran vdout1_23ck1190 FIND v(dout1_23) AT=600.025n

.meas tran vdout1_24ck1190 FIND v(dout1_24) AT=600.025n

.meas tran vdout1_25ck1190 FIND v(dout1_25) AT=600.025n

.meas tran vdout1_26ck1190 FIND v(dout1_26) AT=600.025n

.meas tran vdout1_27ck1190 FIND v(dout1_27) AT=600.025n

.meas tran vdout1_28ck1190 FIND v(dout1_28) AT=600.025n

.meas tran vdout1_29ck1190 FIND v(dout1_29) AT=600.025n

.meas tran vdout1_30ck1190 FIND v(dout1_30) AT=600.025n

.meas tran vdout1_31ck1190 FIND v(dout1_31) AT=600.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_23ck1200 FIND v(dout1_23) AT=605.025n

.meas tran vdout1_24ck1200 FIND v(dout1_24) AT=605.025n

.meas tran vdout1_25ck1200 FIND v(dout1_25) AT=605.025n

.meas tran vdout1_26ck1200 FIND v(dout1_26) AT=605.025n

.meas tran vdout1_27ck1200 FIND v(dout1_27) AT=605.025n

.meas tran vdout1_28ck1200 FIND v(dout1_28) AT=605.025n

.meas tran vdout1_29ck1200 FIND v(dout1_29) AT=605.025n

.meas tran vdout1_30ck1200 FIND v(dout1_30) AT=605.025n

.meas tran vdout1_31ck1200 FIND v(dout1_31) AT=605.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_16ck1210 FIND v(dout1_16) AT=610.025n

.meas tran vdout1_17ck1210 FIND v(dout1_17) AT=610.025n

.meas tran vdout1_18ck1210 FIND v(dout1_18) AT=610.025n

.meas tran vdout1_19ck1210 FIND v(dout1_19) AT=610.025n

.meas tran vdout1_20ck1210 FIND v(dout1_20) AT=610.025n

.meas tran vdout1_21ck1210 FIND v(dout1_21) AT=610.025n

.meas tran vdout1_22ck1210 FIND v(dout1_22) AT=610.025n

.meas tran vdout1_23ck1210 FIND v(dout1_23) AT=610.025n

.meas tran vdout1_24ck1210 FIND v(dout1_24) AT=610.025n

.meas tran vdout1_25ck1210 FIND v(dout1_25) AT=610.025n

.meas tran vdout1_26ck1210 FIND v(dout1_26) AT=610.025n

.meas tran vdout1_27ck1210 FIND v(dout1_27) AT=610.025n

.meas tran vdout1_28ck1210 FIND v(dout1_28) AT=610.025n

.meas tran vdout1_29ck1210 FIND v(dout1_29) AT=610.025n

.meas tran vdout1_30ck1210 FIND v(dout1_30) AT=610.025n

.meas tran vdout1_31ck1210 FIND v(dout1_31) AT=610.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_22ck1220 FIND v(dout1_22) AT=615.025n

.meas tran vdout1_23ck1220 FIND v(dout1_23) AT=615.025n

.meas tran vdout1_24ck1220 FIND v(dout1_24) AT=615.025n

.meas tran vdout1_25ck1220 FIND v(dout1_25) AT=615.025n

.meas tran vdout1_26ck1220 FIND v(dout1_26) AT=615.025n

.meas tran vdout1_27ck1220 FIND v(dout1_27) AT=615.025n

.meas tran vdout1_28ck1220 FIND v(dout1_28) AT=615.025n

.meas tran vdout1_29ck1220 FIND v(dout1_29) AT=615.025n

.meas tran vdout1_30ck1220 FIND v(dout1_30) AT=615.025n

.meas tran vdout1_31ck1220 FIND v(dout1_31) AT=615.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_19ck1240 FIND v(dout1_19) AT=625.025n

.meas tran vdout1_20ck1240 FIND v(dout1_20) AT=625.025n

.meas tran vdout1_21ck1240 FIND v(dout1_21) AT=625.025n

.meas tran vdout1_22ck1240 FIND v(dout1_22) AT=625.025n

.meas tran vdout1_23ck1240 FIND v(dout1_23) AT=625.025n

.meas tran vdout1_24ck1240 FIND v(dout1_24) AT=625.025n

.meas tran vdout1_25ck1240 FIND v(dout1_25) AT=625.025n

.meas tran vdout1_26ck1240 FIND v(dout1_26) AT=625.025n

.meas tran vdout1_27ck1240 FIND v(dout1_27) AT=625.025n

.meas tran vdout1_28ck1240 FIND v(dout1_28) AT=625.025n

.meas tran vdout1_29ck1240 FIND v(dout1_29) AT=625.025n

.meas tran vdout1_30ck1240 FIND v(dout1_30) AT=625.025n

.meas tran vdout1_31ck1240 FIND v(dout1_31) AT=625.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_22ck1280 FIND v(dout1_22) AT=645.025n

.meas tran vdout1_23ck1280 FIND v(dout1_23) AT=645.025n

.meas tran vdout1_24ck1280 FIND v(dout1_24) AT=645.025n

.meas tran vdout1_25ck1280 FIND v(dout1_25) AT=645.025n

.meas tran vdout1_26ck1280 FIND v(dout1_26) AT=645.025n

.meas tran vdout1_27ck1280 FIND v(dout1_27) AT=645.025n

.meas tran vdout1_28ck1280 FIND v(dout1_28) AT=645.025n

.meas tran vdout1_29ck1280 FIND v(dout1_29) AT=645.025n

.meas tran vdout1_30ck1280 FIND v(dout1_30) AT=645.025n

.meas tran vdout1_31ck1280 FIND v(dout1_31) AT=645.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_22ck1300 FIND v(dout1_22) AT=655.025n

.meas tran vdout1_23ck1300 FIND v(dout1_23) AT=655.025n

.meas tran vdout1_24ck1300 FIND v(dout1_24) AT=655.025n

.meas tran vdout1_25ck1300 FIND v(dout1_25) AT=655.025n

.meas tran vdout1_26ck1300 FIND v(dout1_26) AT=655.025n

.meas tran vdout1_27ck1300 FIND v(dout1_27) AT=655.025n

.meas tran vdout1_28ck1300 FIND v(dout1_28) AT=655.025n

.meas tran vdout1_29ck1300 FIND v(dout1_29) AT=655.025n

.meas tran vdout1_30ck1300 FIND v(dout1_30) AT=655.025n

.meas tran vdout1_31ck1300 FIND v(dout1_31) AT=655.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_19ck1310 FIND v(dout1_19) AT=660.025n

.meas tran vdout1_20ck1310 FIND v(dout1_20) AT=660.025n

.meas tran vdout1_21ck1310 FIND v(dout1_21) AT=660.025n

.meas tran vdout1_22ck1310 FIND v(dout1_22) AT=660.025n

.meas tran vdout1_23ck1310 FIND v(dout1_23) AT=660.025n

.meas tran vdout1_24ck1310 FIND v(dout1_24) AT=660.025n

.meas tran vdout1_25ck1310 FIND v(dout1_25) AT=660.025n

.meas tran vdout1_26ck1310 FIND v(dout1_26) AT=660.025n

.meas tran vdout1_27ck1310 FIND v(dout1_27) AT=660.025n

.meas tran vdout1_28ck1310 FIND v(dout1_28) AT=660.025n

.meas tran vdout1_29ck1310 FIND v(dout1_29) AT=660.025n

.meas tran vdout1_30ck1310 FIND v(dout1_30) AT=660.025n

.meas tran vdout1_31ck1310 FIND v(dout1_31) AT=660.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_22ck1320 FIND v(dout1_22) AT=665.025n

.meas tran vdout1_23ck1320 FIND v(dout1_23) AT=665.025n

.meas tran vdout1_24ck1320 FIND v(dout1_24) AT=665.025n

.meas tran vdout1_25ck1320 FIND v(dout1_25) AT=665.025n

.meas tran vdout1_26ck1320 FIND v(dout1_26) AT=665.025n

.meas tran vdout1_27ck1320 FIND v(dout1_27) AT=665.025n

.meas tran vdout1_28ck1320 FIND v(dout1_28) AT=665.025n

.meas tran vdout1_29ck1320 FIND v(dout1_29) AT=665.025n

.meas tran vdout1_30ck1320 FIND v(dout1_30) AT=665.025n

.meas tran vdout1_31ck1320 FIND v(dout1_31) AT=665.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_16ck1340 FIND v(dout1_16) AT=675.025n

.meas tran vdout1_17ck1340 FIND v(dout1_17) AT=675.025n

.meas tran vdout1_18ck1340 FIND v(dout1_18) AT=675.025n

.meas tran vdout1_19ck1340 FIND v(dout1_19) AT=675.025n

.meas tran vdout1_20ck1340 FIND v(dout1_20) AT=675.025n

.meas tran vdout1_21ck1340 FIND v(dout1_21) AT=675.025n

.meas tran vdout1_22ck1340 FIND v(dout1_22) AT=675.025n

.meas tran vdout1_23ck1340 FIND v(dout1_23) AT=675.025n

.meas tran vdout1_24ck1340 FIND v(dout1_24) AT=675.025n

.meas tran vdout1_25ck1340 FIND v(dout1_25) AT=675.025n

.meas tran vdout1_26ck1340 FIND v(dout1_26) AT=675.025n

.meas tran vdout1_27ck1340 FIND v(dout1_27) AT=675.025n

.meas tran vdout1_28ck1340 FIND v(dout1_28) AT=675.025n

.meas tran vdout1_29ck1340 FIND v(dout1_29) AT=675.025n

.meas tran vdout1_30ck1340 FIND v(dout1_30) AT=675.025n

.meas tran vdout1_31ck1340 FIND v(dout1_31) AT=675.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_23ck1370 FIND v(dout1_23) AT=690.025n

.meas tran vdout1_24ck1370 FIND v(dout1_24) AT=690.025n

.meas tran vdout1_25ck1370 FIND v(dout1_25) AT=690.025n

.meas tran vdout1_26ck1370 FIND v(dout1_26) AT=690.025n

.meas tran vdout1_27ck1370 FIND v(dout1_27) AT=690.025n

.meas tran vdout1_28ck1370 FIND v(dout1_28) AT=690.025n

.meas tran vdout1_29ck1370 FIND v(dout1_29) AT=690.025n

.meas tran vdout1_30ck1370 FIND v(dout1_30) AT=690.025n

.meas tran vdout1_31ck1370 FIND v(dout1_31) AT=690.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_22ck1410 FIND v(dout1_22) AT=710.025n

.meas tran vdout1_23ck1410 FIND v(dout1_23) AT=710.025n

.meas tran vdout1_24ck1410 FIND v(dout1_24) AT=710.025n

.meas tran vdout1_25ck1410 FIND v(dout1_25) AT=710.025n

.meas tran vdout1_26ck1410 FIND v(dout1_26) AT=710.025n

.meas tran vdout1_27ck1410 FIND v(dout1_27) AT=710.025n

.meas tran vdout1_28ck1410 FIND v(dout1_28) AT=710.025n

.meas tran vdout1_29ck1410 FIND v(dout1_29) AT=710.025n

.meas tran vdout1_30ck1410 FIND v(dout1_30) AT=710.025n

.meas tran vdout1_31ck1410 FIND v(dout1_31) AT=710.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_19ck1430 FIND v(dout1_19) AT=720.025n

.meas tran vdout1_20ck1430 FIND v(dout1_20) AT=720.025n

.meas tran vdout1_21ck1430 FIND v(dout1_21) AT=720.025n

.meas tran vdout1_22ck1430 FIND v(dout1_22) AT=720.025n

.meas tran vdout1_23ck1430 FIND v(dout1_23) AT=720.025n

.meas tran vdout1_24ck1430 FIND v(dout1_24) AT=720.025n

.meas tran vdout1_25ck1430 FIND v(dout1_25) AT=720.025n

.meas tran vdout1_26ck1430 FIND v(dout1_26) AT=720.025n

.meas tran vdout1_27ck1430 FIND v(dout1_27) AT=720.025n

.meas tran vdout1_28ck1430 FIND v(dout1_28) AT=720.025n

.meas tran vdout1_29ck1430 FIND v(dout1_29) AT=720.025n

.meas tran vdout1_30ck1430 FIND v(dout1_30) AT=720.025n

.meas tran vdout1_31ck1430 FIND v(dout1_31) AT=720.025n

.meas tran vdout1_0ck1440 FIND v(dout1_0) AT=725.025n

.meas tran vdout1_1ck1440 FIND v(dout1_1) AT=725.025n

.meas tran vdout1_2ck1440 FIND v(dout1_2) AT=725.025n

.meas tran vdout1_3ck1440 FIND v(dout1_3) AT=725.025n

.meas tran vdout1_4ck1440 FIND v(dout1_4) AT=725.025n

.meas tran vdout1_5ck1440 FIND v(dout1_5) AT=725.025n

.meas tran vdout1_6ck1440 FIND v(dout1_6) AT=725.025n

.meas tran vdout1_7ck1440 FIND v(dout1_7) AT=725.025n

.meas tran vdout1_8ck1440 FIND v(dout1_8) AT=725.025n

.meas tran vdout1_9ck1440 FIND v(dout1_9) AT=725.025n

.meas tran vdout1_10ck1440 FIND v(dout1_10) AT=725.025n

.meas tran vdout1_11ck1440 FIND v(dout1_11) AT=725.025n

.meas tran vdout1_12ck1440 FIND v(dout1_12) AT=725.025n

.meas tran vdout1_13ck1440 FIND v(dout1_13) AT=725.025n

.meas tran vdout1_14ck1440 FIND v(dout1_14) AT=725.025n

.meas tran vdout1_15ck1440 FIND v(dout1_15) AT=725.025n

.meas tran vdout1_16ck1440 FIND v(dout1_16) AT=725.025n

.meas tran vdout1_17ck1440 FIND v(dout1_17) AT=725.025n

.meas tran vdout1_18ck1440 FIND v(dout1_18) AT=725.025n

.meas tran vdout1_19ck1440 FIND v(dout1_19) AT=725.025n

.meas tran vdout1_20ck1440 FIND v(dout1_20) AT=725.025n

.meas tran vdout1_21ck1440 FIND v(dout1_21) AT=725.025n

.meas tran vdout1_22ck1440 FIND v(dout1_22) AT=725.025n

.meas tran vdout1_23ck1440 FIND v(dout1_23) AT=725.025n

.meas tran vdout1_24ck1440 FIND v(dout1_24) AT=725.025n

.meas tran vdout1_25ck1440 FIND v(dout1_25) AT=725.025n

.meas tran vdout1_26ck1440 FIND v(dout1_26) AT=725.025n

.meas tran vdout1_27ck1440 FIND v(dout1_27) AT=725.025n

.meas tran vdout1_28ck1440 FIND v(dout1_28) AT=725.025n

.meas tran vdout1_29ck1440 FIND v(dout1_29) AT=725.025n

.meas tran vdout1_30ck1440 FIND v(dout1_30) AT=725.025n

.meas tran vdout1_31ck1440 FIND v(dout1_31) AT=725.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_22ck1460 FIND v(dout1_22) AT=735.025n

.meas tran vdout1_23ck1460 FIND v(dout1_23) AT=735.025n

.meas tran vdout1_24ck1460 FIND v(dout1_24) AT=735.025n

.meas tran vdout1_25ck1460 FIND v(dout1_25) AT=735.025n

.meas tran vdout1_26ck1460 FIND v(dout1_26) AT=735.025n

.meas tran vdout1_27ck1460 FIND v(dout1_27) AT=735.025n

.meas tran vdout1_28ck1460 FIND v(dout1_28) AT=735.025n

.meas tran vdout1_29ck1460 FIND v(dout1_29) AT=735.025n

.meas tran vdout1_30ck1460 FIND v(dout1_30) AT=735.025n

.meas tran vdout1_31ck1460 FIND v(dout1_31) AT=735.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_8ck1470 FIND v(dout1_8) AT=740.025n

.meas tran vdout1_9ck1470 FIND v(dout1_9) AT=740.025n

.meas tran vdout1_10ck1470 FIND v(dout1_10) AT=740.025n

.meas tran vdout1_11ck1470 FIND v(dout1_11) AT=740.025n

.meas tran vdout1_12ck1470 FIND v(dout1_12) AT=740.025n

.meas tran vdout1_13ck1470 FIND v(dout1_13) AT=740.025n

.meas tran vdout1_14ck1470 FIND v(dout1_14) AT=740.025n

.meas tran vdout1_15ck1470 FIND v(dout1_15) AT=740.025n

.meas tran vdout1_16ck1470 FIND v(dout1_16) AT=740.025n

.meas tran vdout1_17ck1470 FIND v(dout1_17) AT=740.025n

.meas tran vdout1_18ck1470 FIND v(dout1_18) AT=740.025n

.meas tran vdout1_19ck1470 FIND v(dout1_19) AT=740.025n

.meas tran vdout1_20ck1470 FIND v(dout1_20) AT=740.025n

.meas tran vdout1_21ck1470 FIND v(dout1_21) AT=740.025n

.meas tran vdout1_22ck1470 FIND v(dout1_22) AT=740.025n

.meas tran vdout1_23ck1470 FIND v(dout1_23) AT=740.025n

.meas tran vdout1_24ck1470 FIND v(dout1_24) AT=740.025n

.meas tran vdout1_25ck1470 FIND v(dout1_25) AT=740.025n

.meas tran vdout1_26ck1470 FIND v(dout1_26) AT=740.025n

.meas tran vdout1_27ck1470 FIND v(dout1_27) AT=740.025n

.meas tran vdout1_28ck1470 FIND v(dout1_28) AT=740.025n

.meas tran vdout1_29ck1470 FIND v(dout1_29) AT=740.025n

.meas tran vdout1_30ck1470 FIND v(dout1_30) AT=740.025n

.meas tran vdout1_31ck1470 FIND v(dout1_31) AT=740.025n

.meas tran vdout1_0ck1530 FIND v(dout1_0) AT=770.025n

.meas tran vdout1_1ck1530 FIND v(dout1_1) AT=770.025n

.meas tran vdout1_2ck1530 FIND v(dout1_2) AT=770.025n

.meas tran vdout1_3ck1530 FIND v(dout1_3) AT=770.025n

.meas tran vdout1_4ck1530 FIND v(dout1_4) AT=770.025n

.meas tran vdout1_5ck1530 FIND v(dout1_5) AT=770.025n

.meas tran vdout1_6ck1530 FIND v(dout1_6) AT=770.025n

.meas tran vdout1_7ck1530 FIND v(dout1_7) AT=770.025n

.meas tran vdout1_8ck1530 FIND v(dout1_8) AT=770.025n

.meas tran vdout1_9ck1530 FIND v(dout1_9) AT=770.025n

.meas tran vdout1_10ck1530 FIND v(dout1_10) AT=770.025n

.meas tran vdout1_11ck1530 FIND v(dout1_11) AT=770.025n

.meas tran vdout1_12ck1530 FIND v(dout1_12) AT=770.025n

.meas tran vdout1_13ck1530 FIND v(dout1_13) AT=770.025n

.meas tran vdout1_14ck1530 FIND v(dout1_14) AT=770.025n

.meas tran vdout1_15ck1530 FIND v(dout1_15) AT=770.025n

.meas tran vdout1_16ck1530 FIND v(dout1_16) AT=770.025n

.meas tran vdout1_17ck1530 FIND v(dout1_17) AT=770.025n

.meas tran vdout1_18ck1530 FIND v(dout1_18) AT=770.025n

.meas tran vdout1_19ck1530 FIND v(dout1_19) AT=770.025n

.meas tran vdout1_20ck1530 FIND v(dout1_20) AT=770.025n

.meas tran vdout1_21ck1530 FIND v(dout1_21) AT=770.025n

.meas tran vdout1_22ck1530 FIND v(dout1_22) AT=770.025n

.meas tran vdout1_23ck1530 FIND v(dout1_23) AT=770.025n

.meas tran vdout1_24ck1530 FIND v(dout1_24) AT=770.025n

.meas tran vdout1_25ck1530 FIND v(dout1_25) AT=770.025n

.meas tran vdout1_26ck1530 FIND v(dout1_26) AT=770.025n

.meas tran vdout1_27ck1530 FIND v(dout1_27) AT=770.025n

.meas tran vdout1_28ck1530 FIND v(dout1_28) AT=770.025n

.meas tran vdout1_29ck1530 FIND v(dout1_29) AT=770.025n

.meas tran vdout1_30ck1530 FIND v(dout1_30) AT=770.025n

.meas tran vdout1_31ck1530 FIND v(dout1_31) AT=770.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_23ck1540 FIND v(dout1_23) AT=775.025n

.meas tran vdout1_24ck1540 FIND v(dout1_24) AT=775.025n

.meas tran vdout1_25ck1540 FIND v(dout1_25) AT=775.025n

.meas tran vdout1_26ck1540 FIND v(dout1_26) AT=775.025n

.meas tran vdout1_27ck1540 FIND v(dout1_27) AT=775.025n

.meas tran vdout1_28ck1540 FIND v(dout1_28) AT=775.025n

.meas tran vdout1_29ck1540 FIND v(dout1_29) AT=775.025n

.meas tran vdout1_30ck1540 FIND v(dout1_30) AT=775.025n

.meas tran vdout1_31ck1540 FIND v(dout1_31) AT=775.025n

.meas tran vdout1_0ck1550 FIND v(dout1_0) AT=780.025n

.meas tran vdout1_1ck1550 FIND v(dout1_1) AT=780.025n

.meas tran vdout1_2ck1550 FIND v(dout1_2) AT=780.025n

.meas tran vdout1_3ck1550 FIND v(dout1_3) AT=780.025n

.meas tran vdout1_4ck1550 FIND v(dout1_4) AT=780.025n

.meas tran vdout1_5ck1550 FIND v(dout1_5) AT=780.025n

.meas tran vdout1_6ck1550 FIND v(dout1_6) AT=780.025n

.meas tran vdout1_7ck1550 FIND v(dout1_7) AT=780.025n

.meas tran vdout1_8ck1550 FIND v(dout1_8) AT=780.025n

.meas tran vdout1_9ck1550 FIND v(dout1_9) AT=780.025n

.meas tran vdout1_10ck1550 FIND v(dout1_10) AT=780.025n

.meas tran vdout1_11ck1550 FIND v(dout1_11) AT=780.025n

.meas tran vdout1_12ck1550 FIND v(dout1_12) AT=780.025n

.meas tran vdout1_13ck1550 FIND v(dout1_13) AT=780.025n

.meas tran vdout1_14ck1550 FIND v(dout1_14) AT=780.025n

.meas tran vdout1_15ck1550 FIND v(dout1_15) AT=780.025n

.meas tran vdout1_16ck1550 FIND v(dout1_16) AT=780.025n

.meas tran vdout1_17ck1550 FIND v(dout1_17) AT=780.025n

.meas tran vdout1_18ck1550 FIND v(dout1_18) AT=780.025n

.meas tran vdout1_19ck1550 FIND v(dout1_19) AT=780.025n

.meas tran vdout1_20ck1550 FIND v(dout1_20) AT=780.025n

.meas tran vdout1_21ck1550 FIND v(dout1_21) AT=780.025n

.meas tran vdout1_22ck1550 FIND v(dout1_22) AT=780.025n

.meas tran vdout1_23ck1550 FIND v(dout1_23) AT=780.025n

.meas tran vdout1_24ck1550 FIND v(dout1_24) AT=780.025n

.meas tran vdout1_25ck1550 FIND v(dout1_25) AT=780.025n

.meas tran vdout1_26ck1550 FIND v(dout1_26) AT=780.025n

.meas tran vdout1_27ck1550 FIND v(dout1_27) AT=780.025n

.meas tran vdout1_28ck1550 FIND v(dout1_28) AT=780.025n

.meas tran vdout1_29ck1550 FIND v(dout1_29) AT=780.025n

.meas tran vdout1_30ck1550 FIND v(dout1_30) AT=780.025n

.meas tran vdout1_31ck1550 FIND v(dout1_31) AT=780.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_17ck1640 FIND v(dout1_17) AT=825.025n

.meas tran vdout1_18ck1640 FIND v(dout1_18) AT=825.025n

.meas tran vdout1_19ck1640 FIND v(dout1_19) AT=825.025n

.meas tran vdout1_20ck1640 FIND v(dout1_20) AT=825.025n

.meas tran vdout1_21ck1640 FIND v(dout1_21) AT=825.025n

.meas tran vdout1_22ck1640 FIND v(dout1_22) AT=825.025n

.meas tran vdout1_23ck1640 FIND v(dout1_23) AT=825.025n

.meas tran vdout1_24ck1640 FIND v(dout1_24) AT=825.025n

.meas tran vdout1_25ck1640 FIND v(dout1_25) AT=825.025n

.meas tran vdout1_26ck1640 FIND v(dout1_26) AT=825.025n

.meas tran vdout1_27ck1640 FIND v(dout1_27) AT=825.025n

.meas tran vdout1_28ck1640 FIND v(dout1_28) AT=825.025n

.meas tran vdout1_29ck1640 FIND v(dout1_29) AT=825.025n

.meas tran vdout1_30ck1640 FIND v(dout1_30) AT=825.025n

.meas tran vdout1_31ck1640 FIND v(dout1_31) AT=825.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_19ck1650 FIND v(dout1_19) AT=830.025n

.meas tran vdout1_20ck1650 FIND v(dout1_20) AT=830.025n

.meas tran vdout1_21ck1650 FIND v(dout1_21) AT=830.025n

.meas tran vdout1_22ck1650 FIND v(dout1_22) AT=830.025n

.meas tran vdout1_23ck1650 FIND v(dout1_23) AT=830.025n

.meas tran vdout1_24ck1650 FIND v(dout1_24) AT=830.025n

.meas tran vdout1_25ck1650 FIND v(dout1_25) AT=830.025n

.meas tran vdout1_26ck1650 FIND v(dout1_26) AT=830.025n

.meas tran vdout1_27ck1650 FIND v(dout1_27) AT=830.025n

.meas tran vdout1_28ck1650 FIND v(dout1_28) AT=830.025n

.meas tran vdout1_29ck1650 FIND v(dout1_29) AT=830.025n

.meas tran vdout1_30ck1650 FIND v(dout1_30) AT=830.025n

.meas tran vdout1_31ck1650 FIND v(dout1_31) AT=830.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_19ck1710 FIND v(dout1_19) AT=860.025n

.meas tran vdout1_20ck1710 FIND v(dout1_20) AT=860.025n

.meas tran vdout1_21ck1710 FIND v(dout1_21) AT=860.025n

.meas tran vdout1_22ck1710 FIND v(dout1_22) AT=860.025n

.meas tran vdout1_23ck1710 FIND v(dout1_23) AT=860.025n

.meas tran vdout1_24ck1710 FIND v(dout1_24) AT=860.025n

.meas tran vdout1_25ck1710 FIND v(dout1_25) AT=860.025n

.meas tran vdout1_26ck1710 FIND v(dout1_26) AT=860.025n

.meas tran vdout1_27ck1710 FIND v(dout1_27) AT=860.025n

.meas tran vdout1_28ck1710 FIND v(dout1_28) AT=860.025n

.meas tran vdout1_29ck1710 FIND v(dout1_29) AT=860.025n

.meas tran vdout1_30ck1710 FIND v(dout1_30) AT=860.025n

.meas tran vdout1_31ck1710 FIND v(dout1_31) AT=860.025n

.meas tran vdout1_0ck1740 FIND v(dout1_0) AT=875.025n

.meas tran vdout1_1ck1740 FIND v(dout1_1) AT=875.025n

.meas tran vdout1_2ck1740 FIND v(dout1_2) AT=875.025n

.meas tran vdout1_3ck1740 FIND v(dout1_3) AT=875.025n

.meas tran vdout1_4ck1740 FIND v(dout1_4) AT=875.025n

.meas tran vdout1_5ck1740 FIND v(dout1_5) AT=875.025n

.meas tran vdout1_6ck1740 FIND v(dout1_6) AT=875.025n

.meas tran vdout1_7ck1740 FIND v(dout1_7) AT=875.025n

.meas tran vdout1_8ck1740 FIND v(dout1_8) AT=875.025n

.meas tran vdout1_9ck1740 FIND v(dout1_9) AT=875.025n

.meas tran vdout1_10ck1740 FIND v(dout1_10) AT=875.025n

.meas tran vdout1_11ck1740 FIND v(dout1_11) AT=875.025n

.meas tran vdout1_12ck1740 FIND v(dout1_12) AT=875.025n

.meas tran vdout1_13ck1740 FIND v(dout1_13) AT=875.025n

.meas tran vdout1_14ck1740 FIND v(dout1_14) AT=875.025n

.meas tran vdout1_15ck1740 FIND v(dout1_15) AT=875.025n

.meas tran vdout1_16ck1740 FIND v(dout1_16) AT=875.025n

.meas tran vdout1_17ck1740 FIND v(dout1_17) AT=875.025n

.meas tran vdout1_18ck1740 FIND v(dout1_18) AT=875.025n

.meas tran vdout1_19ck1740 FIND v(dout1_19) AT=875.025n

.meas tran vdout1_20ck1740 FIND v(dout1_20) AT=875.025n

.meas tran vdout1_21ck1740 FIND v(dout1_21) AT=875.025n

.meas tran vdout1_22ck1740 FIND v(dout1_22) AT=875.025n

.meas tran vdout1_23ck1740 FIND v(dout1_23) AT=875.025n

.meas tran vdout1_24ck1740 FIND v(dout1_24) AT=875.025n

.meas tran vdout1_25ck1740 FIND v(dout1_25) AT=875.025n

.meas tran vdout1_26ck1740 FIND v(dout1_26) AT=875.025n

.meas tran vdout1_27ck1740 FIND v(dout1_27) AT=875.025n

.meas tran vdout1_28ck1740 FIND v(dout1_28) AT=875.025n

.meas tran vdout1_29ck1740 FIND v(dout1_29) AT=875.025n

.meas tran vdout1_30ck1740 FIND v(dout1_30) AT=875.025n

.meas tran vdout1_31ck1740 FIND v(dout1_31) AT=875.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_22ck1750 FIND v(dout1_22) AT=880.025n

.meas tran vdout1_23ck1750 FIND v(dout1_23) AT=880.025n

.meas tran vdout1_24ck1750 FIND v(dout1_24) AT=880.025n

.meas tran vdout1_25ck1750 FIND v(dout1_25) AT=880.025n

.meas tran vdout1_26ck1750 FIND v(dout1_26) AT=880.025n

.meas tran vdout1_27ck1750 FIND v(dout1_27) AT=880.025n

.meas tran vdout1_28ck1750 FIND v(dout1_28) AT=880.025n

.meas tran vdout1_29ck1750 FIND v(dout1_29) AT=880.025n

.meas tran vdout1_30ck1750 FIND v(dout1_30) AT=880.025n

.meas tran vdout1_31ck1750 FIND v(dout1_31) AT=880.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_16ck1760 FIND v(dout1_16) AT=885.025n

.meas tran vdout1_17ck1760 FIND v(dout1_17) AT=885.025n

.meas tran vdout1_18ck1760 FIND v(dout1_18) AT=885.025n

.meas tran vdout1_19ck1760 FIND v(dout1_19) AT=885.025n

.meas tran vdout1_20ck1760 FIND v(dout1_20) AT=885.025n

.meas tran vdout1_21ck1760 FIND v(dout1_21) AT=885.025n

.meas tran vdout1_22ck1760 FIND v(dout1_22) AT=885.025n

.meas tran vdout1_23ck1760 FIND v(dout1_23) AT=885.025n

.meas tran vdout1_24ck1760 FIND v(dout1_24) AT=885.025n

.meas tran vdout1_25ck1760 FIND v(dout1_25) AT=885.025n

.meas tran vdout1_26ck1760 FIND v(dout1_26) AT=885.025n

.meas tran vdout1_27ck1760 FIND v(dout1_27) AT=885.025n

.meas tran vdout1_28ck1760 FIND v(dout1_28) AT=885.025n

.meas tran vdout1_29ck1760 FIND v(dout1_29) AT=885.025n

.meas tran vdout1_30ck1760 FIND v(dout1_30) AT=885.025n

.meas tran vdout1_31ck1760 FIND v(dout1_31) AT=885.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_19ck1780 FIND v(dout1_19) AT=895.025n

.meas tran vdout1_20ck1780 FIND v(dout1_20) AT=895.025n

.meas tran vdout1_21ck1780 FIND v(dout1_21) AT=895.025n

.meas tran vdout1_22ck1780 FIND v(dout1_22) AT=895.025n

.meas tran vdout1_23ck1780 FIND v(dout1_23) AT=895.025n

.meas tran vdout1_24ck1780 FIND v(dout1_24) AT=895.025n

.meas tran vdout1_25ck1780 FIND v(dout1_25) AT=895.025n

.meas tran vdout1_26ck1780 FIND v(dout1_26) AT=895.025n

.meas tran vdout1_27ck1780 FIND v(dout1_27) AT=895.025n

.meas tran vdout1_28ck1780 FIND v(dout1_28) AT=895.025n

.meas tran vdout1_29ck1780 FIND v(dout1_29) AT=895.025n

.meas tran vdout1_30ck1780 FIND v(dout1_30) AT=895.025n

.meas tran vdout1_31ck1780 FIND v(dout1_31) AT=895.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_23ck1830 FIND v(dout1_23) AT=920.025n

.meas tran vdout1_24ck1830 FIND v(dout1_24) AT=920.025n

.meas tran vdout1_25ck1830 FIND v(dout1_25) AT=920.025n

.meas tran vdout1_26ck1830 FIND v(dout1_26) AT=920.025n

.meas tran vdout1_27ck1830 FIND v(dout1_27) AT=920.025n

.meas tran vdout1_28ck1830 FIND v(dout1_28) AT=920.025n

.meas tran vdout1_29ck1830 FIND v(dout1_29) AT=920.025n

.meas tran vdout1_30ck1830 FIND v(dout1_30) AT=920.025n

.meas tran vdout1_31ck1830 FIND v(dout1_31) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_8ck1850 FIND v(dout1_8) AT=930.025n

.meas tran vdout1_9ck1850 FIND v(dout1_9) AT=930.025n

.meas tran vdout1_10ck1850 FIND v(dout1_10) AT=930.025n

.meas tran vdout1_11ck1850 FIND v(dout1_11) AT=930.025n

.meas tran vdout1_12ck1850 FIND v(dout1_12) AT=930.025n

.meas tran vdout1_13ck1850 FIND v(dout1_13) AT=930.025n

.meas tran vdout1_14ck1850 FIND v(dout1_14) AT=930.025n

.meas tran vdout1_15ck1850 FIND v(dout1_15) AT=930.025n

.meas tran vdout1_16ck1850 FIND v(dout1_16) AT=930.025n

.meas tran vdout1_17ck1850 FIND v(dout1_17) AT=930.025n

.meas tran vdout1_18ck1850 FIND v(dout1_18) AT=930.025n

.meas tran vdout1_19ck1850 FIND v(dout1_19) AT=930.025n

.meas tran vdout1_20ck1850 FIND v(dout1_20) AT=930.025n

.meas tran vdout1_21ck1850 FIND v(dout1_21) AT=930.025n

.meas tran vdout1_22ck1850 FIND v(dout1_22) AT=930.025n

.meas tran vdout1_23ck1850 FIND v(dout1_23) AT=930.025n

.meas tran vdout1_24ck1850 FIND v(dout1_24) AT=930.025n

.meas tran vdout1_25ck1850 FIND v(dout1_25) AT=930.025n

.meas tran vdout1_26ck1850 FIND v(dout1_26) AT=930.025n

.meas tran vdout1_27ck1850 FIND v(dout1_27) AT=930.025n

.meas tran vdout1_28ck1850 FIND v(dout1_28) AT=930.025n

.meas tran vdout1_29ck1850 FIND v(dout1_29) AT=930.025n

.meas tran vdout1_30ck1850 FIND v(dout1_30) AT=930.025n

.meas tran vdout1_31ck1850 FIND v(dout1_31) AT=930.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_8ck1860 FIND v(dout1_8) AT=935.025n

.meas tran vdout1_9ck1860 FIND v(dout1_9) AT=935.025n

.meas tran vdout1_10ck1860 FIND v(dout1_10) AT=935.025n

.meas tran vdout1_11ck1860 FIND v(dout1_11) AT=935.025n

.meas tran vdout1_12ck1860 FIND v(dout1_12) AT=935.025n

.meas tran vdout1_13ck1860 FIND v(dout1_13) AT=935.025n

.meas tran vdout1_14ck1860 FIND v(dout1_14) AT=935.025n

.meas tran vdout1_15ck1860 FIND v(dout1_15) AT=935.025n

.meas tran vdout1_16ck1860 FIND v(dout1_16) AT=935.025n

.meas tran vdout1_17ck1860 FIND v(dout1_17) AT=935.025n

.meas tran vdout1_18ck1860 FIND v(dout1_18) AT=935.025n

.meas tran vdout1_19ck1860 FIND v(dout1_19) AT=935.025n

.meas tran vdout1_20ck1860 FIND v(dout1_20) AT=935.025n

.meas tran vdout1_21ck1860 FIND v(dout1_21) AT=935.025n

.meas tran vdout1_22ck1860 FIND v(dout1_22) AT=935.025n

.meas tran vdout1_23ck1860 FIND v(dout1_23) AT=935.025n

.meas tran vdout1_24ck1860 FIND v(dout1_24) AT=935.025n

.meas tran vdout1_25ck1860 FIND v(dout1_25) AT=935.025n

.meas tran vdout1_26ck1860 FIND v(dout1_26) AT=935.025n

.meas tran vdout1_27ck1860 FIND v(dout1_27) AT=935.025n

.meas tran vdout1_28ck1860 FIND v(dout1_28) AT=935.025n

.meas tran vdout1_29ck1860 FIND v(dout1_29) AT=935.025n

.meas tran vdout1_30ck1860 FIND v(dout1_30) AT=935.025n

.meas tran vdout1_31ck1860 FIND v(dout1_31) AT=935.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_23ck1890 FIND v(dout1_23) AT=950.025n

.meas tran vdout1_24ck1890 FIND v(dout1_24) AT=950.025n

.meas tran vdout1_25ck1890 FIND v(dout1_25) AT=950.025n

.meas tran vdout1_26ck1890 FIND v(dout1_26) AT=950.025n

.meas tran vdout1_27ck1890 FIND v(dout1_27) AT=950.025n

.meas tran vdout1_28ck1890 FIND v(dout1_28) AT=950.025n

.meas tran vdout1_29ck1890 FIND v(dout1_29) AT=950.025n

.meas tran vdout1_30ck1890 FIND v(dout1_30) AT=950.025n

.meas tran vdout1_31ck1890 FIND v(dout1_31) AT=950.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_8ck1900 FIND v(dout1_8) AT=955.025n

.meas tran vdout1_9ck1900 FIND v(dout1_9) AT=955.025n

.meas tran vdout1_10ck1900 FIND v(dout1_10) AT=955.025n

.meas tran vdout1_11ck1900 FIND v(dout1_11) AT=955.025n

.meas tran vdout1_12ck1900 FIND v(dout1_12) AT=955.025n

.meas tran vdout1_13ck1900 FIND v(dout1_13) AT=955.025n

.meas tran vdout1_14ck1900 FIND v(dout1_14) AT=955.025n

.meas tran vdout1_15ck1900 FIND v(dout1_15) AT=955.025n

.meas tran vdout1_16ck1900 FIND v(dout1_16) AT=955.025n

.meas tran vdout1_17ck1900 FIND v(dout1_17) AT=955.025n

.meas tran vdout1_18ck1900 FIND v(dout1_18) AT=955.025n

.meas tran vdout1_19ck1900 FIND v(dout1_19) AT=955.025n

.meas tran vdout1_20ck1900 FIND v(dout1_20) AT=955.025n

.meas tran vdout1_21ck1900 FIND v(dout1_21) AT=955.025n

.meas tran vdout1_22ck1900 FIND v(dout1_22) AT=955.025n

.meas tran vdout1_23ck1900 FIND v(dout1_23) AT=955.025n

.meas tran vdout1_24ck1900 FIND v(dout1_24) AT=955.025n

.meas tran vdout1_25ck1900 FIND v(dout1_25) AT=955.025n

.meas tran vdout1_26ck1900 FIND v(dout1_26) AT=955.025n

.meas tran vdout1_27ck1900 FIND v(dout1_27) AT=955.025n

.meas tran vdout1_28ck1900 FIND v(dout1_28) AT=955.025n

.meas tran vdout1_29ck1900 FIND v(dout1_29) AT=955.025n

.meas tran vdout1_30ck1900 FIND v(dout1_30) AT=955.025n

.meas tran vdout1_31ck1900 FIND v(dout1_31) AT=955.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_23ck1910 FIND v(dout1_23) AT=960.025n

.meas tran vdout1_24ck1910 FIND v(dout1_24) AT=960.025n

.meas tran vdout1_25ck1910 FIND v(dout1_25) AT=960.025n

.meas tran vdout1_26ck1910 FIND v(dout1_26) AT=960.025n

.meas tran vdout1_27ck1910 FIND v(dout1_27) AT=960.025n

.meas tran vdout1_28ck1910 FIND v(dout1_28) AT=960.025n

.meas tran vdout1_29ck1910 FIND v(dout1_29) AT=960.025n

.meas tran vdout1_30ck1910 FIND v(dout1_30) AT=960.025n

.meas tran vdout1_31ck1910 FIND v(dout1_31) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_23ck1920 FIND v(dout1_23) AT=965.025n

.meas tran vdout1_24ck1920 FIND v(dout1_24) AT=965.025n

.meas tran vdout1_25ck1920 FIND v(dout1_25) AT=965.025n

.meas tran vdout1_26ck1920 FIND v(dout1_26) AT=965.025n

.meas tran vdout1_27ck1920 FIND v(dout1_27) AT=965.025n

.meas tran vdout1_28ck1920 FIND v(dout1_28) AT=965.025n

.meas tran vdout1_29ck1920 FIND v(dout1_29) AT=965.025n

.meas tran vdout1_30ck1920 FIND v(dout1_30) AT=965.025n

.meas tran vdout1_31ck1920 FIND v(dout1_31) AT=965.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_17ck1930 FIND v(dout1_17) AT=970.025n

.meas tran vdout1_18ck1930 FIND v(dout1_18) AT=970.025n

.meas tran vdout1_19ck1930 FIND v(dout1_19) AT=970.025n

.meas tran vdout1_20ck1930 FIND v(dout1_20) AT=970.025n

.meas tran vdout1_21ck1930 FIND v(dout1_21) AT=970.025n

.meas tran vdout1_22ck1930 FIND v(dout1_22) AT=970.025n

.meas tran vdout1_23ck1930 FIND v(dout1_23) AT=970.025n

.meas tran vdout1_24ck1930 FIND v(dout1_24) AT=970.025n

.meas tran vdout1_25ck1930 FIND v(dout1_25) AT=970.025n

.meas tran vdout1_26ck1930 FIND v(dout1_26) AT=970.025n

.meas tran vdout1_27ck1930 FIND v(dout1_27) AT=970.025n

.meas tran vdout1_28ck1930 FIND v(dout1_28) AT=970.025n

.meas tran vdout1_29ck1930 FIND v(dout1_29) AT=970.025n

.meas tran vdout1_30ck1930 FIND v(dout1_30) AT=970.025n

.meas tran vdout1_31ck1930 FIND v(dout1_31) AT=970.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_0ck1970 FIND v(dout1_0) AT=990.025n

.meas tran vdout1_1ck1970 FIND v(dout1_1) AT=990.025n

.meas tran vdout1_2ck1970 FIND v(dout1_2) AT=990.025n

.meas tran vdout1_3ck1970 FIND v(dout1_3) AT=990.025n

.meas tran vdout1_4ck1970 FIND v(dout1_4) AT=990.025n

.meas tran vdout1_5ck1970 FIND v(dout1_5) AT=990.025n

.meas tran vdout1_6ck1970 FIND v(dout1_6) AT=990.025n

.meas tran vdout1_7ck1970 FIND v(dout1_7) AT=990.025n

.meas tran vdout1_8ck1970 FIND v(dout1_8) AT=990.025n

.meas tran vdout1_9ck1970 FIND v(dout1_9) AT=990.025n

.meas tran vdout1_10ck1970 FIND v(dout1_10) AT=990.025n

.meas tran vdout1_11ck1970 FIND v(dout1_11) AT=990.025n

.meas tran vdout1_12ck1970 FIND v(dout1_12) AT=990.025n

.meas tran vdout1_13ck1970 FIND v(dout1_13) AT=990.025n

.meas tran vdout1_14ck1970 FIND v(dout1_14) AT=990.025n

.meas tran vdout1_15ck1970 FIND v(dout1_15) AT=990.025n

.meas tran vdout1_16ck1970 FIND v(dout1_16) AT=990.025n

.meas tran vdout1_17ck1970 FIND v(dout1_17) AT=990.025n

.meas tran vdout1_18ck1970 FIND v(dout1_18) AT=990.025n

.meas tran vdout1_19ck1970 FIND v(dout1_19) AT=990.025n

.meas tran vdout1_20ck1970 FIND v(dout1_20) AT=990.025n

.meas tran vdout1_21ck1970 FIND v(dout1_21) AT=990.025n

.meas tran vdout1_22ck1970 FIND v(dout1_22) AT=990.025n

.meas tran vdout1_23ck1970 FIND v(dout1_23) AT=990.025n

.meas tran vdout1_24ck1970 FIND v(dout1_24) AT=990.025n

.meas tran vdout1_25ck1970 FIND v(dout1_25) AT=990.025n

.meas tran vdout1_26ck1970 FIND v(dout1_26) AT=990.025n

.meas tran vdout1_27ck1970 FIND v(dout1_27) AT=990.025n

.meas tran vdout1_28ck1970 FIND v(dout1_28) AT=990.025n

.meas tran vdout1_29ck1970 FIND v(dout1_29) AT=990.025n

.meas tran vdout1_30ck1970 FIND v(dout1_30) AT=990.025n

.meas tran vdout1_31ck1970 FIND v(dout1_31) AT=990.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_17ck1990 FIND v(dout1_17) AT=1000.025n

.meas tran vdout1_18ck1990 FIND v(dout1_18) AT=1000.025n

.meas tran vdout1_19ck1990 FIND v(dout1_19) AT=1000.025n

.meas tran vdout1_20ck1990 FIND v(dout1_20) AT=1000.025n

.meas tran vdout1_21ck1990 FIND v(dout1_21) AT=1000.025n

.meas tran vdout1_22ck1990 FIND v(dout1_22) AT=1000.025n

.meas tran vdout1_23ck1990 FIND v(dout1_23) AT=1000.025n

.meas tran vdout1_24ck1990 FIND v(dout1_24) AT=1000.025n

.meas tran vdout1_25ck1990 FIND v(dout1_25) AT=1000.025n

.meas tran vdout1_26ck1990 FIND v(dout1_26) AT=1000.025n

.meas tran vdout1_27ck1990 FIND v(dout1_27) AT=1000.025n

.meas tran vdout1_28ck1990 FIND v(dout1_28) AT=1000.025n

.meas tran vdout1_29ck1990 FIND v(dout1_29) AT=1000.025n

.meas tran vdout1_30ck1990 FIND v(dout1_30) AT=1000.025n

.meas tran vdout1_31ck1990 FIND v(dout1_31) AT=1000.025n

.meas tran vdout1_0ck2000 FIND v(dout1_0) AT=1005.025n

.meas tran vdout1_1ck2000 FIND v(dout1_1) AT=1005.025n

.meas tran vdout1_2ck2000 FIND v(dout1_2) AT=1005.025n

.meas tran vdout1_3ck2000 FIND v(dout1_3) AT=1005.025n

.meas tran vdout1_4ck2000 FIND v(dout1_4) AT=1005.025n

.meas tran vdout1_5ck2000 FIND v(dout1_5) AT=1005.025n

.meas tran vdout1_6ck2000 FIND v(dout1_6) AT=1005.025n

.meas tran vdout1_7ck2000 FIND v(dout1_7) AT=1005.025n

.meas tran vdout1_8ck2000 FIND v(dout1_8) AT=1005.025n

.meas tran vdout1_9ck2000 FIND v(dout1_9) AT=1005.025n

.meas tran vdout1_10ck2000 FIND v(dout1_10) AT=1005.025n

.meas tran vdout1_11ck2000 FIND v(dout1_11) AT=1005.025n

.meas tran vdout1_12ck2000 FIND v(dout1_12) AT=1005.025n

.meas tran vdout1_13ck2000 FIND v(dout1_13) AT=1005.025n

.meas tran vdout1_14ck2000 FIND v(dout1_14) AT=1005.025n

.meas tran vdout1_15ck2000 FIND v(dout1_15) AT=1005.025n

.meas tran vdout1_16ck2000 FIND v(dout1_16) AT=1005.025n

.meas tran vdout1_17ck2000 FIND v(dout1_17) AT=1005.025n

.meas tran vdout1_18ck2000 FIND v(dout1_18) AT=1005.025n

.meas tran vdout1_19ck2000 FIND v(dout1_19) AT=1005.025n

.meas tran vdout1_20ck2000 FIND v(dout1_20) AT=1005.025n

.meas tran vdout1_21ck2000 FIND v(dout1_21) AT=1005.025n

.meas tran vdout1_22ck2000 FIND v(dout1_22) AT=1005.025n

.meas tran vdout1_23ck2000 FIND v(dout1_23) AT=1005.025n

.meas tran vdout1_24ck2000 FIND v(dout1_24) AT=1005.025n

.meas tran vdout1_25ck2000 FIND v(dout1_25) AT=1005.025n

.meas tran vdout1_26ck2000 FIND v(dout1_26) AT=1005.025n

.meas tran vdout1_27ck2000 FIND v(dout1_27) AT=1005.025n

.meas tran vdout1_28ck2000 FIND v(dout1_28) AT=1005.025n

.meas tran vdout1_29ck2000 FIND v(dout1_29) AT=1005.025n

.meas tran vdout1_30ck2000 FIND v(dout1_30) AT=1005.025n

.meas tran vdout1_31ck2000 FIND v(dout1_31) AT=1005.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_17ck2010 FIND v(dout1_17) AT=1010.025n

.meas tran vdout1_18ck2010 FIND v(dout1_18) AT=1010.025n

.meas tran vdout1_19ck2010 FIND v(dout1_19) AT=1010.025n

.meas tran vdout1_20ck2010 FIND v(dout1_20) AT=1010.025n

.meas tran vdout1_21ck2010 FIND v(dout1_21) AT=1010.025n

.meas tran vdout1_22ck2010 FIND v(dout1_22) AT=1010.025n

.meas tran vdout1_23ck2010 FIND v(dout1_23) AT=1010.025n

.meas tran vdout1_24ck2010 FIND v(dout1_24) AT=1010.025n

.meas tran vdout1_25ck2010 FIND v(dout1_25) AT=1010.025n

.meas tran vdout1_26ck2010 FIND v(dout1_26) AT=1010.025n

.meas tran vdout1_27ck2010 FIND v(dout1_27) AT=1010.025n

.meas tran vdout1_28ck2010 FIND v(dout1_28) AT=1010.025n

.meas tran vdout1_29ck2010 FIND v(dout1_29) AT=1010.025n

.meas tran vdout1_30ck2010 FIND v(dout1_30) AT=1010.025n

.meas tran vdout1_31ck2010 FIND v(dout1_31) AT=1010.025n

.meas tran vdout1_0ck2020 FIND v(dout1_0) AT=1015.025n

.meas tran vdout1_1ck2020 FIND v(dout1_1) AT=1015.025n

.meas tran vdout1_2ck2020 FIND v(dout1_2) AT=1015.025n

.meas tran vdout1_3ck2020 FIND v(dout1_3) AT=1015.025n

.meas tran vdout1_4ck2020 FIND v(dout1_4) AT=1015.025n

.meas tran vdout1_5ck2020 FIND v(dout1_5) AT=1015.025n

.meas tran vdout1_6ck2020 FIND v(dout1_6) AT=1015.025n

.meas tran vdout1_7ck2020 FIND v(dout1_7) AT=1015.025n

.meas tran vdout1_8ck2020 FIND v(dout1_8) AT=1015.025n

.meas tran vdout1_9ck2020 FIND v(dout1_9) AT=1015.025n

.meas tran vdout1_10ck2020 FIND v(dout1_10) AT=1015.025n

.meas tran vdout1_11ck2020 FIND v(dout1_11) AT=1015.025n

.meas tran vdout1_12ck2020 FIND v(dout1_12) AT=1015.025n

.meas tran vdout1_13ck2020 FIND v(dout1_13) AT=1015.025n

.meas tran vdout1_14ck2020 FIND v(dout1_14) AT=1015.025n

.meas tran vdout1_15ck2020 FIND v(dout1_15) AT=1015.025n

.meas tran vdout1_16ck2020 FIND v(dout1_16) AT=1015.025n

.meas tran vdout1_17ck2020 FIND v(dout1_17) AT=1015.025n

.meas tran vdout1_18ck2020 FIND v(dout1_18) AT=1015.025n

.meas tran vdout1_19ck2020 FIND v(dout1_19) AT=1015.025n

.meas tran vdout1_20ck2020 FIND v(dout1_20) AT=1015.025n

.meas tran vdout1_21ck2020 FIND v(dout1_21) AT=1015.025n

.meas tran vdout1_22ck2020 FIND v(dout1_22) AT=1015.025n

.meas tran vdout1_23ck2020 FIND v(dout1_23) AT=1015.025n

.meas tran vdout1_24ck2020 FIND v(dout1_24) AT=1015.025n

.meas tran vdout1_25ck2020 FIND v(dout1_25) AT=1015.025n

.meas tran vdout1_26ck2020 FIND v(dout1_26) AT=1015.025n

.meas tran vdout1_27ck2020 FIND v(dout1_27) AT=1015.025n

.meas tran vdout1_28ck2020 FIND v(dout1_28) AT=1015.025n

.meas tran vdout1_29ck2020 FIND v(dout1_29) AT=1015.025n

.meas tran vdout1_30ck2020 FIND v(dout1_30) AT=1015.025n

.meas tran vdout1_31ck2020 FIND v(dout1_31) AT=1015.025n
