.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_0ck50 FIND v(dout1_0) AT=30.025n

.meas tran vdout1_1ck50 FIND v(dout1_1) AT=30.025n

.meas tran vdout1_2ck50 FIND v(dout1_2) AT=30.025n

.meas tran vdout1_3ck50 FIND v(dout1_3) AT=30.025n

.meas tran vdout1_4ck50 FIND v(dout1_4) AT=30.025n

.meas tran vdout1_5ck50 FIND v(dout1_5) AT=30.025n

.meas tran vdout1_6ck50 FIND v(dout1_6) AT=30.025n

.meas tran vdout1_7ck50 FIND v(dout1_7) AT=30.025n

.meas tran vdout1_8ck50 FIND v(dout1_8) AT=30.025n

.meas tran vdout1_9ck50 FIND v(dout1_9) AT=30.025n

.meas tran vdout1_10ck50 FIND v(dout1_10) AT=30.025n

.meas tran vdout1_11ck50 FIND v(dout1_11) AT=30.025n

.meas tran vdout1_12ck50 FIND v(dout1_12) AT=30.025n

.meas tran vdout1_13ck50 FIND v(dout1_13) AT=30.025n

.meas tran vdout1_14ck50 FIND v(dout1_14) AT=30.025n

.meas tran vdout1_15ck50 FIND v(dout1_15) AT=30.025n

.meas tran vdout1_16ck50 FIND v(dout1_16) AT=30.025n

.meas tran vdout1_17ck50 FIND v(dout1_17) AT=30.025n

.meas tran vdout1_18ck50 FIND v(dout1_18) AT=30.025n

.meas tran vdout1_19ck50 FIND v(dout1_19) AT=30.025n

.meas tran vdout1_20ck50 FIND v(dout1_20) AT=30.025n

.meas tran vdout1_21ck50 FIND v(dout1_21) AT=30.025n

.meas tran vdout1_0ck70 FIND v(dout1_0) AT=40.025n

.meas tran vdout1_1ck70 FIND v(dout1_1) AT=40.025n

.meas tran vdout1_2ck70 FIND v(dout1_2) AT=40.025n

.meas tran vdout1_3ck70 FIND v(dout1_3) AT=40.025n

.meas tran vdout1_4ck70 FIND v(dout1_4) AT=40.025n

.meas tran vdout1_5ck70 FIND v(dout1_5) AT=40.025n

.meas tran vdout1_6ck70 FIND v(dout1_6) AT=40.025n

.meas tran vdout1_7ck70 FIND v(dout1_7) AT=40.025n

.meas tran vdout1_8ck70 FIND v(dout1_8) AT=40.025n

.meas tran vdout1_9ck70 FIND v(dout1_9) AT=40.025n

.meas tran vdout1_10ck70 FIND v(dout1_10) AT=40.025n

.meas tran vdout1_11ck70 FIND v(dout1_11) AT=40.025n

.meas tran vdout1_12ck70 FIND v(dout1_12) AT=40.025n

.meas tran vdout1_13ck70 FIND v(dout1_13) AT=40.025n

.meas tran vdout1_14ck70 FIND v(dout1_14) AT=40.025n

.meas tran vdout1_15ck70 FIND v(dout1_15) AT=40.025n

.meas tran vdout1_16ck70 FIND v(dout1_16) AT=40.025n

.meas tran vdout1_17ck70 FIND v(dout1_17) AT=40.025n

.meas tran vdout1_18ck70 FIND v(dout1_18) AT=40.025n

.meas tran vdout1_19ck70 FIND v(dout1_19) AT=40.025n

.meas tran vdout1_20ck70 FIND v(dout1_20) AT=40.025n

.meas tran vdout1_21ck70 FIND v(dout1_21) AT=40.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_19ck150 FIND v(dout1_19) AT=80.025n

.meas tran vdout1_20ck150 FIND v(dout1_20) AT=80.025n

.meas tran vdout1_21ck150 FIND v(dout1_21) AT=80.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_17ck160 FIND v(dout1_17) AT=85.025n

.meas tran vdout1_18ck160 FIND v(dout1_18) AT=85.025n

.meas tran vdout1_19ck160 FIND v(dout1_19) AT=85.025n

.meas tran vdout1_20ck160 FIND v(dout1_20) AT=85.025n

.meas tran vdout1_21ck160 FIND v(dout1_21) AT=85.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_0ck210 FIND v(dout1_0) AT=110.025n

.meas tran vdout1_1ck210 FIND v(dout1_1) AT=110.025n

.meas tran vdout1_2ck210 FIND v(dout1_2) AT=110.025n

.meas tran vdout1_3ck210 FIND v(dout1_3) AT=110.025n

.meas tran vdout1_4ck210 FIND v(dout1_4) AT=110.025n

.meas tran vdout1_5ck210 FIND v(dout1_5) AT=110.025n

.meas tran vdout1_6ck210 FIND v(dout1_6) AT=110.025n

.meas tran vdout1_7ck210 FIND v(dout1_7) AT=110.025n

.meas tran vdout1_8ck210 FIND v(dout1_8) AT=110.025n

.meas tran vdout1_9ck210 FIND v(dout1_9) AT=110.025n

.meas tran vdout1_10ck210 FIND v(dout1_10) AT=110.025n

.meas tran vdout1_11ck210 FIND v(dout1_11) AT=110.025n

.meas tran vdout1_12ck210 FIND v(dout1_12) AT=110.025n

.meas tran vdout1_13ck210 FIND v(dout1_13) AT=110.025n

.meas tran vdout1_14ck210 FIND v(dout1_14) AT=110.025n

.meas tran vdout1_15ck210 FIND v(dout1_15) AT=110.025n

.meas tran vdout1_16ck210 FIND v(dout1_16) AT=110.025n

.meas tran vdout1_17ck210 FIND v(dout1_17) AT=110.025n

.meas tran vdout1_18ck210 FIND v(dout1_18) AT=110.025n

.meas tran vdout1_19ck210 FIND v(dout1_19) AT=110.025n

.meas tran vdout1_20ck210 FIND v(dout1_20) AT=110.025n

.meas tran vdout1_21ck210 FIND v(dout1_21) AT=110.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_17ck330 FIND v(dout1_17) AT=170.025n

.meas tran vdout1_18ck330 FIND v(dout1_18) AT=170.025n

.meas tran vdout1_19ck330 FIND v(dout1_19) AT=170.025n

.meas tran vdout1_20ck330 FIND v(dout1_20) AT=170.025n

.meas tran vdout1_21ck330 FIND v(dout1_21) AT=170.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_8ck340 FIND v(dout1_8) AT=175.025n

.meas tran vdout1_9ck340 FIND v(dout1_9) AT=175.025n

.meas tran vdout1_10ck340 FIND v(dout1_10) AT=175.025n

.meas tran vdout1_11ck340 FIND v(dout1_11) AT=175.025n

.meas tran vdout1_12ck340 FIND v(dout1_12) AT=175.025n

.meas tran vdout1_13ck340 FIND v(dout1_13) AT=175.025n

.meas tran vdout1_14ck340 FIND v(dout1_14) AT=175.025n

.meas tran vdout1_15ck340 FIND v(dout1_15) AT=175.025n

.meas tran vdout1_16ck340 FIND v(dout1_16) AT=175.025n

.meas tran vdout1_17ck340 FIND v(dout1_17) AT=175.025n

.meas tran vdout1_18ck340 FIND v(dout1_18) AT=175.025n

.meas tran vdout1_19ck340 FIND v(dout1_19) AT=175.025n

.meas tran vdout1_20ck340 FIND v(dout1_20) AT=175.025n

.meas tran vdout1_21ck340 FIND v(dout1_21) AT=175.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_19ck400 FIND v(dout1_19) AT=205.025n

.meas tran vdout1_20ck400 FIND v(dout1_20) AT=205.025n

.meas tran vdout1_21ck400 FIND v(dout1_21) AT=205.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_17ck410 FIND v(dout1_17) AT=210.025n

.meas tran vdout1_18ck410 FIND v(dout1_18) AT=210.025n

.meas tran vdout1_19ck410 FIND v(dout1_19) AT=210.025n

.meas tran vdout1_20ck410 FIND v(dout1_20) AT=210.025n

.meas tran vdout1_21ck410 FIND v(dout1_21) AT=210.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_19ck420 FIND v(dout1_19) AT=215.025n

.meas tran vdout1_20ck420 FIND v(dout1_20) AT=215.025n

.meas tran vdout1_21ck420 FIND v(dout1_21) AT=215.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_16ck440 FIND v(dout1_16) AT=225.025n

.meas tran vdout1_17ck440 FIND v(dout1_17) AT=225.025n

.meas tran vdout1_18ck440 FIND v(dout1_18) AT=225.025n

.meas tran vdout1_19ck440 FIND v(dout1_19) AT=225.025n

.meas tran vdout1_20ck440 FIND v(dout1_20) AT=225.025n

.meas tran vdout1_21ck440 FIND v(dout1_21) AT=225.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_19ck490 FIND v(dout1_19) AT=250.025n

.meas tran vdout1_20ck490 FIND v(dout1_20) AT=250.025n

.meas tran vdout1_21ck490 FIND v(dout1_21) AT=250.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_16ck550 FIND v(dout1_16) AT=280.025n

.meas tran vdout1_17ck550 FIND v(dout1_17) AT=280.025n

.meas tran vdout1_18ck550 FIND v(dout1_18) AT=280.025n

.meas tran vdout1_19ck550 FIND v(dout1_19) AT=280.025n

.meas tran vdout1_20ck550 FIND v(dout1_20) AT=280.025n

.meas tran vdout1_21ck550 FIND v(dout1_21) AT=280.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_8ck620 FIND v(dout1_8) AT=315.025n

.meas tran vdout1_9ck620 FIND v(dout1_9) AT=315.025n

.meas tran vdout1_10ck620 FIND v(dout1_10) AT=315.025n

.meas tran vdout1_11ck620 FIND v(dout1_11) AT=315.025n

.meas tran vdout1_12ck620 FIND v(dout1_12) AT=315.025n

.meas tran vdout1_13ck620 FIND v(dout1_13) AT=315.025n

.meas tran vdout1_14ck620 FIND v(dout1_14) AT=315.025n

.meas tran vdout1_15ck620 FIND v(dout1_15) AT=315.025n

.meas tran vdout1_16ck620 FIND v(dout1_16) AT=315.025n

.meas tran vdout1_17ck620 FIND v(dout1_17) AT=315.025n

.meas tran vdout1_18ck620 FIND v(dout1_18) AT=315.025n

.meas tran vdout1_19ck620 FIND v(dout1_19) AT=315.025n

.meas tran vdout1_20ck620 FIND v(dout1_20) AT=315.025n

.meas tran vdout1_21ck620 FIND v(dout1_21) AT=315.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_8ck630 FIND v(dout1_8) AT=320.025n

.meas tran vdout1_9ck630 FIND v(dout1_9) AT=320.025n

.meas tran vdout1_10ck630 FIND v(dout1_10) AT=320.025n

.meas tran vdout1_11ck630 FIND v(dout1_11) AT=320.025n

.meas tran vdout1_12ck630 FIND v(dout1_12) AT=320.025n

.meas tran vdout1_13ck630 FIND v(dout1_13) AT=320.025n

.meas tran vdout1_14ck630 FIND v(dout1_14) AT=320.025n

.meas tran vdout1_15ck630 FIND v(dout1_15) AT=320.025n

.meas tran vdout1_16ck630 FIND v(dout1_16) AT=320.025n

.meas tran vdout1_17ck630 FIND v(dout1_17) AT=320.025n

.meas tran vdout1_18ck630 FIND v(dout1_18) AT=320.025n

.meas tran vdout1_19ck630 FIND v(dout1_19) AT=320.025n

.meas tran vdout1_20ck630 FIND v(dout1_20) AT=320.025n

.meas tran vdout1_21ck630 FIND v(dout1_21) AT=320.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_19ck640 FIND v(dout1_19) AT=325.025n

.meas tran vdout1_20ck640 FIND v(dout1_20) AT=325.025n

.meas tran vdout1_21ck640 FIND v(dout1_21) AT=325.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_19ck650 FIND v(dout1_19) AT=330.025n

.meas tran vdout1_20ck650 FIND v(dout1_20) AT=330.025n

.meas tran vdout1_21ck650 FIND v(dout1_21) AT=330.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_19ck670 FIND v(dout1_19) AT=340.025n

.meas tran vdout1_20ck670 FIND v(dout1_20) AT=340.025n

.meas tran vdout1_21ck670 FIND v(dout1_21) AT=340.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_17ck730 FIND v(dout1_17) AT=370.025n

.meas tran vdout1_18ck730 FIND v(dout1_18) AT=370.025n

.meas tran vdout1_19ck730 FIND v(dout1_19) AT=370.025n

.meas tran vdout1_20ck730 FIND v(dout1_20) AT=370.025n

.meas tran vdout1_21ck730 FIND v(dout1_21) AT=370.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_19ck760 FIND v(dout1_19) AT=385.025n

.meas tran vdout1_20ck760 FIND v(dout1_20) AT=385.025n

.meas tran vdout1_21ck760 FIND v(dout1_21) AT=385.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_8ck810 FIND v(dout1_8) AT=410.025n

.meas tran vdout1_9ck810 FIND v(dout1_9) AT=410.025n

.meas tran vdout1_10ck810 FIND v(dout1_10) AT=410.025n

.meas tran vdout1_11ck810 FIND v(dout1_11) AT=410.025n

.meas tran vdout1_12ck810 FIND v(dout1_12) AT=410.025n

.meas tran vdout1_13ck810 FIND v(dout1_13) AT=410.025n

.meas tran vdout1_14ck810 FIND v(dout1_14) AT=410.025n

.meas tran vdout1_15ck810 FIND v(dout1_15) AT=410.025n

.meas tran vdout1_16ck810 FIND v(dout1_16) AT=410.025n

.meas tran vdout1_17ck810 FIND v(dout1_17) AT=410.025n

.meas tran vdout1_18ck810 FIND v(dout1_18) AT=410.025n

.meas tran vdout1_19ck810 FIND v(dout1_19) AT=410.025n

.meas tran vdout1_20ck810 FIND v(dout1_20) AT=410.025n

.meas tran vdout1_21ck810 FIND v(dout1_21) AT=410.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_0ck940 FIND v(dout1_0) AT=475.025n

.meas tran vdout1_1ck940 FIND v(dout1_1) AT=475.025n

.meas tran vdout1_2ck940 FIND v(dout1_2) AT=475.025n

.meas tran vdout1_3ck940 FIND v(dout1_3) AT=475.025n

.meas tran vdout1_4ck940 FIND v(dout1_4) AT=475.025n

.meas tran vdout1_5ck940 FIND v(dout1_5) AT=475.025n

.meas tran vdout1_6ck940 FIND v(dout1_6) AT=475.025n

.meas tran vdout1_7ck940 FIND v(dout1_7) AT=475.025n

.meas tran vdout1_8ck940 FIND v(dout1_8) AT=475.025n

.meas tran vdout1_9ck940 FIND v(dout1_9) AT=475.025n

.meas tran vdout1_10ck940 FIND v(dout1_10) AT=475.025n

.meas tran vdout1_11ck940 FIND v(dout1_11) AT=475.025n

.meas tran vdout1_12ck940 FIND v(dout1_12) AT=475.025n

.meas tran vdout1_13ck940 FIND v(dout1_13) AT=475.025n

.meas tran vdout1_14ck940 FIND v(dout1_14) AT=475.025n

.meas tran vdout1_15ck940 FIND v(dout1_15) AT=475.025n

.meas tran vdout1_16ck940 FIND v(dout1_16) AT=475.025n

.meas tran vdout1_17ck940 FIND v(dout1_17) AT=475.025n

.meas tran vdout1_18ck940 FIND v(dout1_18) AT=475.025n

.meas tran vdout1_19ck940 FIND v(dout1_19) AT=475.025n

.meas tran vdout1_20ck940 FIND v(dout1_20) AT=475.025n

.meas tran vdout1_21ck940 FIND v(dout1_21) AT=475.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_16ck980 FIND v(dout1_16) AT=495.025n

.meas tran vdout1_17ck980 FIND v(dout1_17) AT=495.025n

.meas tran vdout1_18ck980 FIND v(dout1_18) AT=495.025n

.meas tran vdout1_19ck980 FIND v(dout1_19) AT=495.025n

.meas tran vdout1_20ck980 FIND v(dout1_20) AT=495.025n

.meas tran vdout1_21ck980 FIND v(dout1_21) AT=495.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_19ck1110 FIND v(dout1_19) AT=560.025n

.meas tran vdout1_20ck1110 FIND v(dout1_20) AT=560.025n

.meas tran vdout1_21ck1110 FIND v(dout1_21) AT=560.025n

.meas tran vdout1_0ck1150 FIND v(dout1_0) AT=580.025n

.meas tran vdout1_1ck1150 FIND v(dout1_1) AT=580.025n

.meas tran vdout1_2ck1150 FIND v(dout1_2) AT=580.025n

.meas tran vdout1_3ck1150 FIND v(dout1_3) AT=580.025n

.meas tran vdout1_4ck1150 FIND v(dout1_4) AT=580.025n

.meas tran vdout1_5ck1150 FIND v(dout1_5) AT=580.025n

.meas tran vdout1_6ck1150 FIND v(dout1_6) AT=580.025n

.meas tran vdout1_7ck1150 FIND v(dout1_7) AT=580.025n

.meas tran vdout1_8ck1150 FIND v(dout1_8) AT=580.025n

.meas tran vdout1_9ck1150 FIND v(dout1_9) AT=580.025n

.meas tran vdout1_10ck1150 FIND v(dout1_10) AT=580.025n

.meas tran vdout1_11ck1150 FIND v(dout1_11) AT=580.025n

.meas tran vdout1_12ck1150 FIND v(dout1_12) AT=580.025n

.meas tran vdout1_13ck1150 FIND v(dout1_13) AT=580.025n

.meas tran vdout1_14ck1150 FIND v(dout1_14) AT=580.025n

.meas tran vdout1_15ck1150 FIND v(dout1_15) AT=580.025n

.meas tran vdout1_16ck1150 FIND v(dout1_16) AT=580.025n

.meas tran vdout1_17ck1150 FIND v(dout1_17) AT=580.025n

.meas tran vdout1_18ck1150 FIND v(dout1_18) AT=580.025n

.meas tran vdout1_19ck1150 FIND v(dout1_19) AT=580.025n

.meas tran vdout1_20ck1150 FIND v(dout1_20) AT=580.025n

.meas tran vdout1_21ck1150 FIND v(dout1_21) AT=580.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_17ck1160 FIND v(dout1_17) AT=585.025n

.meas tran vdout1_18ck1160 FIND v(dout1_18) AT=585.025n

.meas tran vdout1_19ck1160 FIND v(dout1_19) AT=585.025n

.meas tran vdout1_20ck1160 FIND v(dout1_20) AT=585.025n

.meas tran vdout1_21ck1160 FIND v(dout1_21) AT=585.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_16ck1210 FIND v(dout1_16) AT=610.025n

.meas tran vdout1_17ck1210 FIND v(dout1_17) AT=610.025n

.meas tran vdout1_18ck1210 FIND v(dout1_18) AT=610.025n

.meas tran vdout1_19ck1210 FIND v(dout1_19) AT=610.025n

.meas tran vdout1_20ck1210 FIND v(dout1_20) AT=610.025n

.meas tran vdout1_21ck1210 FIND v(dout1_21) AT=610.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_17ck1230 FIND v(dout1_17) AT=620.025n

.meas tran vdout1_18ck1230 FIND v(dout1_18) AT=620.025n

.meas tran vdout1_19ck1230 FIND v(dout1_19) AT=620.025n

.meas tran vdout1_20ck1230 FIND v(dout1_20) AT=620.025n

.meas tran vdout1_21ck1230 FIND v(dout1_21) AT=620.025n

.meas tran vdout1_0ck1250 FIND v(dout1_0) AT=630.025n

.meas tran vdout1_1ck1250 FIND v(dout1_1) AT=630.025n

.meas tran vdout1_2ck1250 FIND v(dout1_2) AT=630.025n

.meas tran vdout1_3ck1250 FIND v(dout1_3) AT=630.025n

.meas tran vdout1_4ck1250 FIND v(dout1_4) AT=630.025n

.meas tran vdout1_5ck1250 FIND v(dout1_5) AT=630.025n

.meas tran vdout1_6ck1250 FIND v(dout1_6) AT=630.025n

.meas tran vdout1_7ck1250 FIND v(dout1_7) AT=630.025n

.meas tran vdout1_8ck1250 FIND v(dout1_8) AT=630.025n

.meas tran vdout1_9ck1250 FIND v(dout1_9) AT=630.025n

.meas tran vdout1_10ck1250 FIND v(dout1_10) AT=630.025n

.meas tran vdout1_11ck1250 FIND v(dout1_11) AT=630.025n

.meas tran vdout1_12ck1250 FIND v(dout1_12) AT=630.025n

.meas tran vdout1_13ck1250 FIND v(dout1_13) AT=630.025n

.meas tran vdout1_14ck1250 FIND v(dout1_14) AT=630.025n

.meas tran vdout1_15ck1250 FIND v(dout1_15) AT=630.025n

.meas tran vdout1_16ck1250 FIND v(dout1_16) AT=630.025n

.meas tran vdout1_17ck1250 FIND v(dout1_17) AT=630.025n

.meas tran vdout1_18ck1250 FIND v(dout1_18) AT=630.025n

.meas tran vdout1_19ck1250 FIND v(dout1_19) AT=630.025n

.meas tran vdout1_20ck1250 FIND v(dout1_20) AT=630.025n

.meas tran vdout1_21ck1250 FIND v(dout1_21) AT=630.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_17ck1260 FIND v(dout1_17) AT=635.025n

.meas tran vdout1_18ck1260 FIND v(dout1_18) AT=635.025n

.meas tran vdout1_19ck1260 FIND v(dout1_19) AT=635.025n

.meas tran vdout1_20ck1260 FIND v(dout1_20) AT=635.025n

.meas tran vdout1_21ck1260 FIND v(dout1_21) AT=635.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_8ck1270 FIND v(dout1_8) AT=640.025n

.meas tran vdout1_9ck1270 FIND v(dout1_9) AT=640.025n

.meas tran vdout1_10ck1270 FIND v(dout1_10) AT=640.025n

.meas tran vdout1_11ck1270 FIND v(dout1_11) AT=640.025n

.meas tran vdout1_12ck1270 FIND v(dout1_12) AT=640.025n

.meas tran vdout1_13ck1270 FIND v(dout1_13) AT=640.025n

.meas tran vdout1_14ck1270 FIND v(dout1_14) AT=640.025n

.meas tran vdout1_15ck1270 FIND v(dout1_15) AT=640.025n

.meas tran vdout1_16ck1270 FIND v(dout1_16) AT=640.025n

.meas tran vdout1_17ck1270 FIND v(dout1_17) AT=640.025n

.meas tran vdout1_18ck1270 FIND v(dout1_18) AT=640.025n

.meas tran vdout1_19ck1270 FIND v(dout1_19) AT=640.025n

.meas tran vdout1_20ck1270 FIND v(dout1_20) AT=640.025n

.meas tran vdout1_21ck1270 FIND v(dout1_21) AT=640.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_17ck1290 FIND v(dout1_17) AT=650.025n

.meas tran vdout1_18ck1290 FIND v(dout1_18) AT=650.025n

.meas tran vdout1_19ck1290 FIND v(dout1_19) AT=650.025n

.meas tran vdout1_20ck1290 FIND v(dout1_20) AT=650.025n

.meas tran vdout1_21ck1290 FIND v(dout1_21) AT=650.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_17ck1300 FIND v(dout1_17) AT=655.025n

.meas tran vdout1_18ck1300 FIND v(dout1_18) AT=655.025n

.meas tran vdout1_19ck1300 FIND v(dout1_19) AT=655.025n

.meas tran vdout1_20ck1300 FIND v(dout1_20) AT=655.025n

.meas tran vdout1_21ck1300 FIND v(dout1_21) AT=655.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_19ck1310 FIND v(dout1_19) AT=660.025n

.meas tran vdout1_20ck1310 FIND v(dout1_20) AT=660.025n

.meas tran vdout1_21ck1310 FIND v(dout1_21) AT=660.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_19ck1430 FIND v(dout1_19) AT=720.025n

.meas tran vdout1_20ck1430 FIND v(dout1_20) AT=720.025n

.meas tran vdout1_21ck1430 FIND v(dout1_21) AT=720.025n

.meas tran vdout1_0ck1440 FIND v(dout1_0) AT=725.025n

.meas tran vdout1_1ck1440 FIND v(dout1_1) AT=725.025n

.meas tran vdout1_2ck1440 FIND v(dout1_2) AT=725.025n

.meas tran vdout1_3ck1440 FIND v(dout1_3) AT=725.025n

.meas tran vdout1_4ck1440 FIND v(dout1_4) AT=725.025n

.meas tran vdout1_5ck1440 FIND v(dout1_5) AT=725.025n

.meas tran vdout1_6ck1440 FIND v(dout1_6) AT=725.025n

.meas tran vdout1_7ck1440 FIND v(dout1_7) AT=725.025n

.meas tran vdout1_8ck1440 FIND v(dout1_8) AT=725.025n

.meas tran vdout1_9ck1440 FIND v(dout1_9) AT=725.025n

.meas tran vdout1_10ck1440 FIND v(dout1_10) AT=725.025n

.meas tran vdout1_11ck1440 FIND v(dout1_11) AT=725.025n

.meas tran vdout1_12ck1440 FIND v(dout1_12) AT=725.025n

.meas tran vdout1_13ck1440 FIND v(dout1_13) AT=725.025n

.meas tran vdout1_14ck1440 FIND v(dout1_14) AT=725.025n

.meas tran vdout1_15ck1440 FIND v(dout1_15) AT=725.025n

.meas tran vdout1_16ck1440 FIND v(dout1_16) AT=725.025n

.meas tran vdout1_17ck1440 FIND v(dout1_17) AT=725.025n

.meas tran vdout1_18ck1440 FIND v(dout1_18) AT=725.025n

.meas tran vdout1_19ck1440 FIND v(dout1_19) AT=725.025n

.meas tran vdout1_20ck1440 FIND v(dout1_20) AT=725.025n

.meas tran vdout1_21ck1440 FIND v(dout1_21) AT=725.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_0ck1550 FIND v(dout1_0) AT=780.025n

.meas tran vdout1_1ck1550 FIND v(dout1_1) AT=780.025n

.meas tran vdout1_2ck1550 FIND v(dout1_2) AT=780.025n

.meas tran vdout1_3ck1550 FIND v(dout1_3) AT=780.025n

.meas tran vdout1_4ck1550 FIND v(dout1_4) AT=780.025n

.meas tran vdout1_5ck1550 FIND v(dout1_5) AT=780.025n

.meas tran vdout1_6ck1550 FIND v(dout1_6) AT=780.025n

.meas tran vdout1_7ck1550 FIND v(dout1_7) AT=780.025n

.meas tran vdout1_8ck1550 FIND v(dout1_8) AT=780.025n

.meas tran vdout1_9ck1550 FIND v(dout1_9) AT=780.025n

.meas tran vdout1_10ck1550 FIND v(dout1_10) AT=780.025n

.meas tran vdout1_11ck1550 FIND v(dout1_11) AT=780.025n

.meas tran vdout1_12ck1550 FIND v(dout1_12) AT=780.025n

.meas tran vdout1_13ck1550 FIND v(dout1_13) AT=780.025n

.meas tran vdout1_14ck1550 FIND v(dout1_14) AT=780.025n

.meas tran vdout1_15ck1550 FIND v(dout1_15) AT=780.025n

.meas tran vdout1_16ck1550 FIND v(dout1_16) AT=780.025n

.meas tran vdout1_17ck1550 FIND v(dout1_17) AT=780.025n

.meas tran vdout1_18ck1550 FIND v(dout1_18) AT=780.025n

.meas tran vdout1_19ck1550 FIND v(dout1_19) AT=780.025n

.meas tran vdout1_20ck1550 FIND v(dout1_20) AT=780.025n

.meas tran vdout1_21ck1550 FIND v(dout1_21) AT=780.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_19ck1590 FIND v(dout1_19) AT=800.025n

.meas tran vdout1_20ck1590 FIND v(dout1_20) AT=800.025n

.meas tran vdout1_21ck1590 FIND v(dout1_21) AT=800.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_19ck1600 FIND v(dout1_19) AT=805.025n

.meas tran vdout1_20ck1600 FIND v(dout1_20) AT=805.025n

.meas tran vdout1_21ck1600 FIND v(dout1_21) AT=805.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_19ck1650 FIND v(dout1_19) AT=830.025n

.meas tran vdout1_20ck1650 FIND v(dout1_20) AT=830.025n

.meas tran vdout1_21ck1650 FIND v(dout1_21) AT=830.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_19ck1700 FIND v(dout1_19) AT=855.025n

.meas tran vdout1_20ck1700 FIND v(dout1_20) AT=855.025n

.meas tran vdout1_21ck1700 FIND v(dout1_21) AT=855.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_16ck1720 FIND v(dout1_16) AT=865.025n

.meas tran vdout1_17ck1720 FIND v(dout1_17) AT=865.025n

.meas tran vdout1_18ck1720 FIND v(dout1_18) AT=865.025n

.meas tran vdout1_19ck1720 FIND v(dout1_19) AT=865.025n

.meas tran vdout1_20ck1720 FIND v(dout1_20) AT=865.025n

.meas tran vdout1_21ck1720 FIND v(dout1_21) AT=865.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_16ck1760 FIND v(dout1_16) AT=885.025n

.meas tran vdout1_17ck1760 FIND v(dout1_17) AT=885.025n

.meas tran vdout1_18ck1760 FIND v(dout1_18) AT=885.025n

.meas tran vdout1_19ck1760 FIND v(dout1_19) AT=885.025n

.meas tran vdout1_20ck1760 FIND v(dout1_20) AT=885.025n

.meas tran vdout1_21ck1760 FIND v(dout1_21) AT=885.025n

.meas tran vdout1_0ck1790 FIND v(dout1_0) AT=900.025n

.meas tran vdout1_1ck1790 FIND v(dout1_1) AT=900.025n

.meas tran vdout1_2ck1790 FIND v(dout1_2) AT=900.025n

.meas tran vdout1_3ck1790 FIND v(dout1_3) AT=900.025n

.meas tran vdout1_4ck1790 FIND v(dout1_4) AT=900.025n

.meas tran vdout1_5ck1790 FIND v(dout1_5) AT=900.025n

.meas tran vdout1_6ck1790 FIND v(dout1_6) AT=900.025n

.meas tran vdout1_7ck1790 FIND v(dout1_7) AT=900.025n

.meas tran vdout1_8ck1790 FIND v(dout1_8) AT=900.025n

.meas tran vdout1_9ck1790 FIND v(dout1_9) AT=900.025n

.meas tran vdout1_10ck1790 FIND v(dout1_10) AT=900.025n

.meas tran vdout1_11ck1790 FIND v(dout1_11) AT=900.025n

.meas tran vdout1_12ck1790 FIND v(dout1_12) AT=900.025n

.meas tran vdout1_13ck1790 FIND v(dout1_13) AT=900.025n

.meas tran vdout1_14ck1790 FIND v(dout1_14) AT=900.025n

.meas tran vdout1_15ck1790 FIND v(dout1_15) AT=900.025n

.meas tran vdout1_16ck1790 FIND v(dout1_16) AT=900.025n

.meas tran vdout1_17ck1790 FIND v(dout1_17) AT=900.025n

.meas tran vdout1_18ck1790 FIND v(dout1_18) AT=900.025n

.meas tran vdout1_19ck1790 FIND v(dout1_19) AT=900.025n

.meas tran vdout1_20ck1790 FIND v(dout1_20) AT=900.025n

.meas tran vdout1_21ck1790 FIND v(dout1_21) AT=900.025n

.meas tran vdout1_0ck1800 FIND v(dout1_0) AT=905.025n

.meas tran vdout1_1ck1800 FIND v(dout1_1) AT=905.025n

.meas tran vdout1_2ck1800 FIND v(dout1_2) AT=905.025n

.meas tran vdout1_3ck1800 FIND v(dout1_3) AT=905.025n

.meas tran vdout1_4ck1800 FIND v(dout1_4) AT=905.025n

.meas tran vdout1_5ck1800 FIND v(dout1_5) AT=905.025n

.meas tran vdout1_6ck1800 FIND v(dout1_6) AT=905.025n

.meas tran vdout1_7ck1800 FIND v(dout1_7) AT=905.025n

.meas tran vdout1_8ck1800 FIND v(dout1_8) AT=905.025n

.meas tran vdout1_9ck1800 FIND v(dout1_9) AT=905.025n

.meas tran vdout1_10ck1800 FIND v(dout1_10) AT=905.025n

.meas tran vdout1_11ck1800 FIND v(dout1_11) AT=905.025n

.meas tran vdout1_12ck1800 FIND v(dout1_12) AT=905.025n

.meas tran vdout1_13ck1800 FIND v(dout1_13) AT=905.025n

.meas tran vdout1_14ck1800 FIND v(dout1_14) AT=905.025n

.meas tran vdout1_15ck1800 FIND v(dout1_15) AT=905.025n

.meas tran vdout1_16ck1800 FIND v(dout1_16) AT=905.025n

.meas tran vdout1_17ck1800 FIND v(dout1_17) AT=905.025n

.meas tran vdout1_18ck1800 FIND v(dout1_18) AT=905.025n

.meas tran vdout1_19ck1800 FIND v(dout1_19) AT=905.025n

.meas tran vdout1_20ck1800 FIND v(dout1_20) AT=905.025n

.meas tran vdout1_21ck1800 FIND v(dout1_21) AT=905.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_8ck1860 FIND v(dout1_8) AT=935.025n

.meas tran vdout1_9ck1860 FIND v(dout1_9) AT=935.025n

.meas tran vdout1_10ck1860 FIND v(dout1_10) AT=935.025n

.meas tran vdout1_11ck1860 FIND v(dout1_11) AT=935.025n

.meas tran vdout1_12ck1860 FIND v(dout1_12) AT=935.025n

.meas tran vdout1_13ck1860 FIND v(dout1_13) AT=935.025n

.meas tran vdout1_14ck1860 FIND v(dout1_14) AT=935.025n

.meas tran vdout1_15ck1860 FIND v(dout1_15) AT=935.025n

.meas tran vdout1_16ck1860 FIND v(dout1_16) AT=935.025n

.meas tran vdout1_17ck1860 FIND v(dout1_17) AT=935.025n

.meas tran vdout1_18ck1860 FIND v(dout1_18) AT=935.025n

.meas tran vdout1_19ck1860 FIND v(dout1_19) AT=935.025n

.meas tran vdout1_20ck1860 FIND v(dout1_20) AT=935.025n

.meas tran vdout1_21ck1860 FIND v(dout1_21) AT=935.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_17ck1930 FIND v(dout1_17) AT=970.025n

.meas tran vdout1_18ck1930 FIND v(dout1_18) AT=970.025n

.meas tran vdout1_19ck1930 FIND v(dout1_19) AT=970.025n

.meas tran vdout1_20ck1930 FIND v(dout1_20) AT=970.025n

.meas tran vdout1_21ck1930 FIND v(dout1_21) AT=970.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_0ck1960 FIND v(dout1_0) AT=985.025n

.meas tran vdout1_1ck1960 FIND v(dout1_1) AT=985.025n

.meas tran vdout1_2ck1960 FIND v(dout1_2) AT=985.025n

.meas tran vdout1_3ck1960 FIND v(dout1_3) AT=985.025n

.meas tran vdout1_4ck1960 FIND v(dout1_4) AT=985.025n

.meas tran vdout1_5ck1960 FIND v(dout1_5) AT=985.025n

.meas tran vdout1_6ck1960 FIND v(dout1_6) AT=985.025n

.meas tran vdout1_7ck1960 FIND v(dout1_7) AT=985.025n

.meas tran vdout1_8ck1960 FIND v(dout1_8) AT=985.025n

.meas tran vdout1_9ck1960 FIND v(dout1_9) AT=985.025n

.meas tran vdout1_10ck1960 FIND v(dout1_10) AT=985.025n

.meas tran vdout1_11ck1960 FIND v(dout1_11) AT=985.025n

.meas tran vdout1_12ck1960 FIND v(dout1_12) AT=985.025n

.meas tran vdout1_13ck1960 FIND v(dout1_13) AT=985.025n

.meas tran vdout1_14ck1960 FIND v(dout1_14) AT=985.025n

.meas tran vdout1_15ck1960 FIND v(dout1_15) AT=985.025n

.meas tran vdout1_16ck1960 FIND v(dout1_16) AT=985.025n

.meas tran vdout1_17ck1960 FIND v(dout1_17) AT=985.025n

.meas tran vdout1_18ck1960 FIND v(dout1_18) AT=985.025n

.meas tran vdout1_19ck1960 FIND v(dout1_19) AT=985.025n

.meas tran vdout1_20ck1960 FIND v(dout1_20) AT=985.025n

.meas tran vdout1_21ck1960 FIND v(dout1_21) AT=985.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n
