.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_32ck40 FIND v(dout1_32) AT=25.025n

.meas tran vdout1_33ck40 FIND v(dout1_33) AT=25.025n

.meas tran vdout1_34ck40 FIND v(dout1_34) AT=25.025n

.meas tran vdout1_35ck40 FIND v(dout1_35) AT=25.025n

.meas tran vdout1_36ck40 FIND v(dout1_36) AT=25.025n

.meas tran vdout1_37ck40 FIND v(dout1_37) AT=25.025n

.meas tran vdout1_38ck40 FIND v(dout1_38) AT=25.025n

.meas tran vdout1_39ck40 FIND v(dout1_39) AT=25.025n

.meas tran vdout1_40ck40 FIND v(dout1_40) AT=25.025n

.meas tran vdout1_41ck40 FIND v(dout1_41) AT=25.025n

.meas tran vdout1_42ck40 FIND v(dout1_42) AT=25.025n

.meas tran vdout1_43ck40 FIND v(dout1_43) AT=25.025n

.meas tran vdout1_44ck40 FIND v(dout1_44) AT=25.025n

.meas tran vdout1_45ck40 FIND v(dout1_45) AT=25.025n

.meas tran vdout1_46ck40 FIND v(dout1_46) AT=25.025n

.meas tran vdout1_47ck40 FIND v(dout1_47) AT=25.025n

.meas tran vdout1_48ck40 FIND v(dout1_48) AT=25.025n

.meas tran vdout1_49ck40 FIND v(dout1_49) AT=25.025n

.meas tran vdout1_50ck40 FIND v(dout1_50) AT=25.025n

.meas tran vdout1_51ck40 FIND v(dout1_51) AT=25.025n

.meas tran vdout1_52ck40 FIND v(dout1_52) AT=25.025n

.meas tran vdout1_53ck40 FIND v(dout1_53) AT=25.025n

.meas tran vdout1_54ck40 FIND v(dout1_54) AT=25.025n

.meas tran vdout1_55ck40 FIND v(dout1_55) AT=25.025n

.meas tran vdout1_56ck40 FIND v(dout1_56) AT=25.025n

.meas tran vdout1_57ck40 FIND v(dout1_57) AT=25.025n

.meas tran vdout1_58ck40 FIND v(dout1_58) AT=25.025n

.meas tran vdout1_59ck40 FIND v(dout1_59) AT=25.025n

.meas tran vdout1_60ck40 FIND v(dout1_60) AT=25.025n

.meas tran vdout1_61ck40 FIND v(dout1_61) AT=25.025n

.meas tran vdout1_62ck40 FIND v(dout1_62) AT=25.025n

.meas tran vdout1_63ck40 FIND v(dout1_63) AT=25.025n

.meas tran vdout1_64ck40 FIND v(dout1_64) AT=25.025n

.meas tran vdout1_65ck40 FIND v(dout1_65) AT=25.025n

.meas tran vdout1_66ck40 FIND v(dout1_66) AT=25.025n

.meas tran vdout1_67ck40 FIND v(dout1_67) AT=25.025n

.meas tran vdout1_68ck40 FIND v(dout1_68) AT=25.025n

.meas tran vdout1_69ck40 FIND v(dout1_69) AT=25.025n

.meas tran vdout1_70ck40 FIND v(dout1_70) AT=25.025n

.meas tran vdout1_71ck40 FIND v(dout1_71) AT=25.025n

.meas tran vdout1_72ck40 FIND v(dout1_72) AT=25.025n

.meas tran vdout1_73ck40 FIND v(dout1_73) AT=25.025n

.meas tran vdout1_74ck40 FIND v(dout1_74) AT=25.025n

.meas tran vdout1_75ck40 FIND v(dout1_75) AT=25.025n

.meas tran vdout1_76ck40 FIND v(dout1_76) AT=25.025n

.meas tran vdout1_77ck40 FIND v(dout1_77) AT=25.025n

.meas tran vdout1_78ck40 FIND v(dout1_78) AT=25.025n

.meas tran vdout1_79ck40 FIND v(dout1_79) AT=25.025n

.meas tran vdout1_80ck40 FIND v(dout1_80) AT=25.025n

.meas tran vdout1_81ck40 FIND v(dout1_81) AT=25.025n

.meas tran vdout1_82ck40 FIND v(dout1_82) AT=25.025n

.meas tran vdout1_83ck40 FIND v(dout1_83) AT=25.025n

.meas tran vdout1_84ck40 FIND v(dout1_84) AT=25.025n

.meas tran vdout1_85ck40 FIND v(dout1_85) AT=25.025n

.meas tran vdout1_86ck40 FIND v(dout1_86) AT=25.025n

.meas tran vdout1_87ck40 FIND v(dout1_87) AT=25.025n

.meas tran vdout1_88ck40 FIND v(dout1_88) AT=25.025n

.meas tran vdout1_89ck40 FIND v(dout1_89) AT=25.025n

.meas tran vdout1_90ck40 FIND v(dout1_90) AT=25.025n

.meas tran vdout1_91ck40 FIND v(dout1_91) AT=25.025n

.meas tran vdout1_92ck40 FIND v(dout1_92) AT=25.025n

.meas tran vdout1_93ck40 FIND v(dout1_93) AT=25.025n

.meas tran vdout1_94ck40 FIND v(dout1_94) AT=25.025n

.meas tran vdout1_95ck40 FIND v(dout1_95) AT=25.025n

.meas tran vdout1_96ck40 FIND v(dout1_96) AT=25.025n

.meas tran vdout1_97ck40 FIND v(dout1_97) AT=25.025n

.meas tran vdout1_98ck40 FIND v(dout1_98) AT=25.025n

.meas tran vdout1_99ck40 FIND v(dout1_99) AT=25.025n

.meas tran vdout1_100ck40 FIND v(dout1_100) AT=25.025n

.meas tran vdout1_101ck40 FIND v(dout1_101) AT=25.025n

.meas tran vdout1_102ck40 FIND v(dout1_102) AT=25.025n

.meas tran vdout1_103ck40 FIND v(dout1_103) AT=25.025n

.meas tran vdout1_104ck40 FIND v(dout1_104) AT=25.025n

.meas tran vdout1_105ck40 FIND v(dout1_105) AT=25.025n

.meas tran vdout1_106ck40 FIND v(dout1_106) AT=25.025n

.meas tran vdout1_107ck40 FIND v(dout1_107) AT=25.025n

.meas tran vdout1_108ck40 FIND v(dout1_108) AT=25.025n

.meas tran vdout1_109ck40 FIND v(dout1_109) AT=25.025n

.meas tran vdout1_110ck40 FIND v(dout1_110) AT=25.025n

.meas tran vdout1_111ck40 FIND v(dout1_111) AT=25.025n

.meas tran vdout1_112ck40 FIND v(dout1_112) AT=25.025n

.meas tran vdout1_113ck40 FIND v(dout1_113) AT=25.025n

.meas tran vdout1_114ck40 FIND v(dout1_114) AT=25.025n

.meas tran vdout1_115ck40 FIND v(dout1_115) AT=25.025n

.meas tran vdout1_116ck40 FIND v(dout1_116) AT=25.025n

.meas tran vdout1_117ck40 FIND v(dout1_117) AT=25.025n

.meas tran vdout1_118ck40 FIND v(dout1_118) AT=25.025n

.meas tran vdout1_119ck40 FIND v(dout1_119) AT=25.025n

.meas tran vdout1_120ck40 FIND v(dout1_120) AT=25.025n

.meas tran vdout1_121ck40 FIND v(dout1_121) AT=25.025n

.meas tran vdout1_122ck40 FIND v(dout1_122) AT=25.025n

.meas tran vdout1_123ck40 FIND v(dout1_123) AT=25.025n

.meas tran vdout1_124ck40 FIND v(dout1_124) AT=25.025n

.meas tran vdout1_125ck40 FIND v(dout1_125) AT=25.025n

.meas tran vdout1_126ck40 FIND v(dout1_126) AT=25.025n

.meas tran vdout1_127ck40 FIND v(dout1_127) AT=25.025n

.meas tran vdout1_128ck40 FIND v(dout1_128) AT=25.025n

.meas tran vdout1_129ck40 FIND v(dout1_129) AT=25.025n

.meas tran vdout1_130ck40 FIND v(dout1_130) AT=25.025n

.meas tran vdout1_131ck40 FIND v(dout1_131) AT=25.025n

.meas tran vdout1_132ck40 FIND v(dout1_132) AT=25.025n

.meas tran vdout1_133ck40 FIND v(dout1_133) AT=25.025n

.meas tran vdout1_134ck40 FIND v(dout1_134) AT=25.025n

.meas tran vdout1_135ck40 FIND v(dout1_135) AT=25.025n

.meas tran vdout1_136ck40 FIND v(dout1_136) AT=25.025n

.meas tran vdout1_137ck40 FIND v(dout1_137) AT=25.025n

.meas tran vdout1_138ck40 FIND v(dout1_138) AT=25.025n

.meas tran vdout1_139ck40 FIND v(dout1_139) AT=25.025n

.meas tran vdout1_140ck40 FIND v(dout1_140) AT=25.025n

.meas tran vdout1_141ck40 FIND v(dout1_141) AT=25.025n

.meas tran vdout1_142ck40 FIND v(dout1_142) AT=25.025n

.meas tran vdout1_143ck40 FIND v(dout1_143) AT=25.025n

.meas tran vdout1_144ck40 FIND v(dout1_144) AT=25.025n

.meas tran vdout1_145ck40 FIND v(dout1_145) AT=25.025n

.meas tran vdout1_146ck40 FIND v(dout1_146) AT=25.025n

.meas tran vdout1_147ck40 FIND v(dout1_147) AT=25.025n

.meas tran vdout1_148ck40 FIND v(dout1_148) AT=25.025n

.meas tran vdout1_149ck40 FIND v(dout1_149) AT=25.025n

.meas tran vdout1_150ck40 FIND v(dout1_150) AT=25.025n

.meas tran vdout1_151ck40 FIND v(dout1_151) AT=25.025n

.meas tran vdout1_152ck40 FIND v(dout1_152) AT=25.025n

.meas tran vdout1_153ck40 FIND v(dout1_153) AT=25.025n

.meas tran vdout1_154ck40 FIND v(dout1_154) AT=25.025n

.meas tran vdout1_155ck40 FIND v(dout1_155) AT=25.025n

.meas tran vdout1_156ck40 FIND v(dout1_156) AT=25.025n

.meas tran vdout1_157ck40 FIND v(dout1_157) AT=25.025n

.meas tran vdout1_158ck40 FIND v(dout1_158) AT=25.025n

.meas tran vdout1_159ck40 FIND v(dout1_159) AT=25.025n

.meas tran vdout1_160ck40 FIND v(dout1_160) AT=25.025n

.meas tran vdout1_161ck40 FIND v(dout1_161) AT=25.025n

.meas tran vdout1_162ck40 FIND v(dout1_162) AT=25.025n

.meas tran vdout1_163ck40 FIND v(dout1_163) AT=25.025n

.meas tran vdout1_164ck40 FIND v(dout1_164) AT=25.025n

.meas tran vdout1_165ck40 FIND v(dout1_165) AT=25.025n

.meas tran vdout1_166ck40 FIND v(dout1_166) AT=25.025n

.meas tran vdout1_167ck40 FIND v(dout1_167) AT=25.025n

.meas tran vdout1_168ck40 FIND v(dout1_168) AT=25.025n

.meas tran vdout1_169ck40 FIND v(dout1_169) AT=25.025n

.meas tran vdout1_170ck40 FIND v(dout1_170) AT=25.025n

.meas tran vdout1_171ck40 FIND v(dout1_171) AT=25.025n

.meas tran vdout1_172ck40 FIND v(dout1_172) AT=25.025n

.meas tran vdout1_173ck40 FIND v(dout1_173) AT=25.025n

.meas tran vdout1_174ck40 FIND v(dout1_174) AT=25.025n

.meas tran vdout1_175ck40 FIND v(dout1_175) AT=25.025n

.meas tran vdout1_176ck40 FIND v(dout1_176) AT=25.025n

.meas tran vdout1_177ck40 FIND v(dout1_177) AT=25.025n

.meas tran vdout1_178ck40 FIND v(dout1_178) AT=25.025n

.meas tran vdout1_179ck40 FIND v(dout1_179) AT=25.025n

.meas tran vdout1_180ck40 FIND v(dout1_180) AT=25.025n

.meas tran vdout1_181ck40 FIND v(dout1_181) AT=25.025n

.meas tran vdout1_182ck40 FIND v(dout1_182) AT=25.025n

.meas tran vdout1_183ck40 FIND v(dout1_183) AT=25.025n

.meas tran vdout1_184ck40 FIND v(dout1_184) AT=25.025n

.meas tran vdout1_185ck40 FIND v(dout1_185) AT=25.025n

.meas tran vdout1_186ck40 FIND v(dout1_186) AT=25.025n

.meas tran vdout1_187ck40 FIND v(dout1_187) AT=25.025n

.meas tran vdout1_188ck40 FIND v(dout1_188) AT=25.025n

.meas tran vdout1_189ck40 FIND v(dout1_189) AT=25.025n

.meas tran vdout1_190ck40 FIND v(dout1_190) AT=25.025n

.meas tran vdout1_191ck40 FIND v(dout1_191) AT=25.025n

.meas tran vdout1_192ck40 FIND v(dout1_192) AT=25.025n

.meas tran vdout1_193ck40 FIND v(dout1_193) AT=25.025n

.meas tran vdout1_194ck40 FIND v(dout1_194) AT=25.025n

.meas tran vdout1_195ck40 FIND v(dout1_195) AT=25.025n

.meas tran vdout1_196ck40 FIND v(dout1_196) AT=25.025n

.meas tran vdout1_197ck40 FIND v(dout1_197) AT=25.025n

.meas tran vdout1_198ck40 FIND v(dout1_198) AT=25.025n

.meas tran vdout1_199ck40 FIND v(dout1_199) AT=25.025n

.meas tran vdout1_200ck40 FIND v(dout1_200) AT=25.025n

.meas tran vdout1_201ck40 FIND v(dout1_201) AT=25.025n

.meas tran vdout1_202ck40 FIND v(dout1_202) AT=25.025n

.meas tran vdout1_203ck40 FIND v(dout1_203) AT=25.025n

.meas tran vdout1_204ck40 FIND v(dout1_204) AT=25.025n

.meas tran vdout1_205ck40 FIND v(dout1_205) AT=25.025n

.meas tran vdout1_206ck40 FIND v(dout1_206) AT=25.025n

.meas tran vdout1_207ck40 FIND v(dout1_207) AT=25.025n

.meas tran vdout1_208ck40 FIND v(dout1_208) AT=25.025n

.meas tran vdout1_209ck40 FIND v(dout1_209) AT=25.025n

.meas tran vdout1_210ck40 FIND v(dout1_210) AT=25.025n

.meas tran vdout1_211ck40 FIND v(dout1_211) AT=25.025n

.meas tran vdout1_212ck40 FIND v(dout1_212) AT=25.025n

.meas tran vdout1_213ck40 FIND v(dout1_213) AT=25.025n

.meas tran vdout1_214ck40 FIND v(dout1_214) AT=25.025n

.meas tran vdout1_215ck40 FIND v(dout1_215) AT=25.025n

.meas tran vdout1_216ck40 FIND v(dout1_216) AT=25.025n

.meas tran vdout1_217ck40 FIND v(dout1_217) AT=25.025n

.meas tran vdout1_218ck40 FIND v(dout1_218) AT=25.025n

.meas tran vdout1_219ck40 FIND v(dout1_219) AT=25.025n

.meas tran vdout1_220ck40 FIND v(dout1_220) AT=25.025n

.meas tran vdout1_221ck40 FIND v(dout1_221) AT=25.025n

.meas tran vdout1_222ck40 FIND v(dout1_222) AT=25.025n

.meas tran vdout1_223ck40 FIND v(dout1_223) AT=25.025n

.meas tran vdout1_224ck40 FIND v(dout1_224) AT=25.025n

.meas tran vdout1_225ck40 FIND v(dout1_225) AT=25.025n

.meas tran vdout1_226ck40 FIND v(dout1_226) AT=25.025n

.meas tran vdout1_227ck40 FIND v(dout1_227) AT=25.025n

.meas tran vdout1_228ck40 FIND v(dout1_228) AT=25.025n

.meas tran vdout1_229ck40 FIND v(dout1_229) AT=25.025n

.meas tran vdout1_230ck40 FIND v(dout1_230) AT=25.025n

.meas tran vdout1_231ck40 FIND v(dout1_231) AT=25.025n

.meas tran vdout1_232ck40 FIND v(dout1_232) AT=25.025n

.meas tran vdout1_233ck40 FIND v(dout1_233) AT=25.025n

.meas tran vdout1_234ck40 FIND v(dout1_234) AT=25.025n

.meas tran vdout1_235ck40 FIND v(dout1_235) AT=25.025n

.meas tran vdout1_236ck40 FIND v(dout1_236) AT=25.025n

.meas tran vdout1_237ck40 FIND v(dout1_237) AT=25.025n

.meas tran vdout1_238ck40 FIND v(dout1_238) AT=25.025n

.meas tran vdout1_239ck40 FIND v(dout1_239) AT=25.025n

.meas tran vdout1_240ck40 FIND v(dout1_240) AT=25.025n

.meas tran vdout1_241ck40 FIND v(dout1_241) AT=25.025n

.meas tran vdout1_242ck40 FIND v(dout1_242) AT=25.025n

.meas tran vdout1_243ck40 FIND v(dout1_243) AT=25.025n

.meas tran vdout1_244ck40 FIND v(dout1_244) AT=25.025n

.meas tran vdout1_245ck40 FIND v(dout1_245) AT=25.025n

.meas tran vdout1_246ck40 FIND v(dout1_246) AT=25.025n

.meas tran vdout1_247ck40 FIND v(dout1_247) AT=25.025n

.meas tran vdout1_248ck40 FIND v(dout1_248) AT=25.025n

.meas tran vdout1_249ck40 FIND v(dout1_249) AT=25.025n

.meas tran vdout1_250ck40 FIND v(dout1_250) AT=25.025n

.meas tran vdout1_251ck40 FIND v(dout1_251) AT=25.025n

.meas tran vdout1_252ck40 FIND v(dout1_252) AT=25.025n

.meas tran vdout1_253ck40 FIND v(dout1_253) AT=25.025n

.meas tran vdout1_254ck40 FIND v(dout1_254) AT=25.025n

.meas tran vdout1_255ck40 FIND v(dout1_255) AT=25.025n

.meas tran vdout1_256ck40 FIND v(dout1_256) AT=25.025n

.meas tran vdout1_257ck40 FIND v(dout1_257) AT=25.025n

.meas tran vdout1_258ck40 FIND v(dout1_258) AT=25.025n

.meas tran vdout1_259ck40 FIND v(dout1_259) AT=25.025n

.meas tran vdout1_260ck40 FIND v(dout1_260) AT=25.025n

.meas tran vdout1_261ck40 FIND v(dout1_261) AT=25.025n

.meas tran vdout1_262ck40 FIND v(dout1_262) AT=25.025n

.meas tran vdout1_263ck40 FIND v(dout1_263) AT=25.025n

.meas tran vdout1_264ck40 FIND v(dout1_264) AT=25.025n

.meas tran vdout1_265ck40 FIND v(dout1_265) AT=25.025n

.meas tran vdout1_266ck40 FIND v(dout1_266) AT=25.025n

.meas tran vdout1_267ck40 FIND v(dout1_267) AT=25.025n

.meas tran vdout1_268ck40 FIND v(dout1_268) AT=25.025n

.meas tran vdout1_269ck40 FIND v(dout1_269) AT=25.025n

.meas tran vdout1_270ck40 FIND v(dout1_270) AT=25.025n

.meas tran vdout1_271ck40 FIND v(dout1_271) AT=25.025n

.meas tran vdout1_272ck40 FIND v(dout1_272) AT=25.025n

.meas tran vdout1_273ck40 FIND v(dout1_273) AT=25.025n

.meas tran vdout1_274ck40 FIND v(dout1_274) AT=25.025n

.meas tran vdout1_275ck40 FIND v(dout1_275) AT=25.025n

.meas tran vdout1_276ck40 FIND v(dout1_276) AT=25.025n

.meas tran vdout1_277ck40 FIND v(dout1_277) AT=25.025n

.meas tran vdout1_278ck40 FIND v(dout1_278) AT=25.025n

.meas tran vdout1_279ck40 FIND v(dout1_279) AT=25.025n

.meas tran vdout1_280ck40 FIND v(dout1_280) AT=25.025n

.meas tran vdout1_281ck40 FIND v(dout1_281) AT=25.025n

.meas tran vdout1_282ck40 FIND v(dout1_282) AT=25.025n

.meas tran vdout1_283ck40 FIND v(dout1_283) AT=25.025n

.meas tran vdout1_284ck40 FIND v(dout1_284) AT=25.025n

.meas tran vdout1_285ck40 FIND v(dout1_285) AT=25.025n

.meas tran vdout1_286ck40 FIND v(dout1_286) AT=25.025n

.meas tran vdout1_287ck40 FIND v(dout1_287) AT=25.025n

.meas tran vdout1_288ck40 FIND v(dout1_288) AT=25.025n

.meas tran vdout1_289ck40 FIND v(dout1_289) AT=25.025n

.meas tran vdout1_290ck40 FIND v(dout1_290) AT=25.025n

.meas tran vdout1_291ck40 FIND v(dout1_291) AT=25.025n

.meas tran vdout1_292ck40 FIND v(dout1_292) AT=25.025n

.meas tran vdout1_293ck40 FIND v(dout1_293) AT=25.025n

.meas tran vdout1_294ck40 FIND v(dout1_294) AT=25.025n

.meas tran vdout1_295ck40 FIND v(dout1_295) AT=25.025n

.meas tran vdout1_296ck40 FIND v(dout1_296) AT=25.025n

.meas tran vdout1_297ck40 FIND v(dout1_297) AT=25.025n

.meas tran vdout1_298ck40 FIND v(dout1_298) AT=25.025n

.meas tran vdout1_299ck40 FIND v(dout1_299) AT=25.025n

.meas tran vdout1_300ck40 FIND v(dout1_300) AT=25.025n

.meas tran vdout1_301ck40 FIND v(dout1_301) AT=25.025n

.meas tran vdout1_302ck40 FIND v(dout1_302) AT=25.025n

.meas tran vdout1_303ck40 FIND v(dout1_303) AT=25.025n

.meas tran vdout1_304ck40 FIND v(dout1_304) AT=25.025n

.meas tran vdout1_305ck40 FIND v(dout1_305) AT=25.025n

.meas tran vdout1_306ck40 FIND v(dout1_306) AT=25.025n

.meas tran vdout1_307ck40 FIND v(dout1_307) AT=25.025n

.meas tran vdout1_308ck40 FIND v(dout1_308) AT=25.025n

.meas tran vdout1_309ck40 FIND v(dout1_309) AT=25.025n

.meas tran vdout1_310ck40 FIND v(dout1_310) AT=25.025n

.meas tran vdout1_311ck40 FIND v(dout1_311) AT=25.025n

.meas tran vdout1_312ck40 FIND v(dout1_312) AT=25.025n

.meas tran vdout1_313ck40 FIND v(dout1_313) AT=25.025n

.meas tran vdout1_314ck40 FIND v(dout1_314) AT=25.025n

.meas tran vdout1_315ck40 FIND v(dout1_315) AT=25.025n

.meas tran vdout1_316ck40 FIND v(dout1_316) AT=25.025n

.meas tran vdout1_317ck40 FIND v(dout1_317) AT=25.025n

.meas tran vdout1_318ck40 FIND v(dout1_318) AT=25.025n

.meas tran vdout1_319ck40 FIND v(dout1_319) AT=25.025n

.meas tran vdout1_320ck40 FIND v(dout1_320) AT=25.025n

.meas tran vdout1_321ck40 FIND v(dout1_321) AT=25.025n

.meas tran vdout1_322ck40 FIND v(dout1_322) AT=25.025n

.meas tran vdout1_323ck40 FIND v(dout1_323) AT=25.025n

.meas tran vdout1_324ck40 FIND v(dout1_324) AT=25.025n

.meas tran vdout1_325ck40 FIND v(dout1_325) AT=25.025n

.meas tran vdout1_326ck40 FIND v(dout1_326) AT=25.025n

.meas tran vdout1_327ck40 FIND v(dout1_327) AT=25.025n

.meas tran vdout1_328ck40 FIND v(dout1_328) AT=25.025n

.meas tran vdout1_329ck40 FIND v(dout1_329) AT=25.025n

.meas tran vdout1_330ck40 FIND v(dout1_330) AT=25.025n

.meas tran vdout1_331ck40 FIND v(dout1_331) AT=25.025n

.meas tran vdout1_332ck40 FIND v(dout1_332) AT=25.025n

.meas tran vdout1_333ck40 FIND v(dout1_333) AT=25.025n

.meas tran vdout1_334ck40 FIND v(dout1_334) AT=25.025n

.meas tran vdout1_335ck40 FIND v(dout1_335) AT=25.025n

.meas tran vdout1_336ck40 FIND v(dout1_336) AT=25.025n

.meas tran vdout1_337ck40 FIND v(dout1_337) AT=25.025n

.meas tran vdout1_338ck40 FIND v(dout1_338) AT=25.025n

.meas tran vdout1_339ck40 FIND v(dout1_339) AT=25.025n

.meas tran vdout1_340ck40 FIND v(dout1_340) AT=25.025n

.meas tran vdout1_341ck40 FIND v(dout1_341) AT=25.025n

.meas tran vdout1_342ck40 FIND v(dout1_342) AT=25.025n

.meas tran vdout1_343ck40 FIND v(dout1_343) AT=25.025n

.meas tran vdout1_344ck40 FIND v(dout1_344) AT=25.025n

.meas tran vdout1_345ck40 FIND v(dout1_345) AT=25.025n

.meas tran vdout1_346ck40 FIND v(dout1_346) AT=25.025n

.meas tran vdout1_347ck40 FIND v(dout1_347) AT=25.025n

.meas tran vdout1_348ck40 FIND v(dout1_348) AT=25.025n

.meas tran vdout1_349ck40 FIND v(dout1_349) AT=25.025n

.meas tran vdout1_350ck40 FIND v(dout1_350) AT=25.025n

.meas tran vdout1_351ck40 FIND v(dout1_351) AT=25.025n

.meas tran vdout1_352ck40 FIND v(dout1_352) AT=25.025n

.meas tran vdout1_353ck40 FIND v(dout1_353) AT=25.025n

.meas tran vdout1_354ck40 FIND v(dout1_354) AT=25.025n

.meas tran vdout1_355ck40 FIND v(dout1_355) AT=25.025n

.meas tran vdout1_356ck40 FIND v(dout1_356) AT=25.025n

.meas tran vdout1_357ck40 FIND v(dout1_357) AT=25.025n

.meas tran vdout1_358ck40 FIND v(dout1_358) AT=25.025n

.meas tran vdout1_359ck40 FIND v(dout1_359) AT=25.025n

.meas tran vdout1_360ck40 FIND v(dout1_360) AT=25.025n

.meas tran vdout1_361ck40 FIND v(dout1_361) AT=25.025n

.meas tran vdout1_362ck40 FIND v(dout1_362) AT=25.025n

.meas tran vdout1_363ck40 FIND v(dout1_363) AT=25.025n

.meas tran vdout1_364ck40 FIND v(dout1_364) AT=25.025n

.meas tran vdout1_365ck40 FIND v(dout1_365) AT=25.025n

.meas tran vdout1_366ck40 FIND v(dout1_366) AT=25.025n

.meas tran vdout1_367ck40 FIND v(dout1_367) AT=25.025n

.meas tran vdout1_368ck40 FIND v(dout1_368) AT=25.025n

.meas tran vdout1_369ck40 FIND v(dout1_369) AT=25.025n

.meas tran vdout1_370ck40 FIND v(dout1_370) AT=25.025n

.meas tran vdout1_371ck40 FIND v(dout1_371) AT=25.025n

.meas tran vdout1_372ck40 FIND v(dout1_372) AT=25.025n

.meas tran vdout1_373ck40 FIND v(dout1_373) AT=25.025n

.meas tran vdout1_374ck40 FIND v(dout1_374) AT=25.025n

.meas tran vdout1_375ck40 FIND v(dout1_375) AT=25.025n

.meas tran vdout1_376ck40 FIND v(dout1_376) AT=25.025n

.meas tran vdout1_377ck40 FIND v(dout1_377) AT=25.025n

.meas tran vdout1_378ck40 FIND v(dout1_378) AT=25.025n

.meas tran vdout1_379ck40 FIND v(dout1_379) AT=25.025n

.meas tran vdout1_380ck40 FIND v(dout1_380) AT=25.025n

.meas tran vdout1_381ck40 FIND v(dout1_381) AT=25.025n

.meas tran vdout1_382ck40 FIND v(dout1_382) AT=25.025n

.meas tran vdout1_383ck40 FIND v(dout1_383) AT=25.025n

.meas tran vdout1_384ck40 FIND v(dout1_384) AT=25.025n

.meas tran vdout1_385ck40 FIND v(dout1_385) AT=25.025n

.meas tran vdout1_386ck40 FIND v(dout1_386) AT=25.025n

.meas tran vdout1_387ck40 FIND v(dout1_387) AT=25.025n

.meas tran vdout1_388ck40 FIND v(dout1_388) AT=25.025n

.meas tran vdout1_389ck40 FIND v(dout1_389) AT=25.025n

.meas tran vdout1_390ck40 FIND v(dout1_390) AT=25.025n

.meas tran vdout1_391ck40 FIND v(dout1_391) AT=25.025n

.meas tran vdout1_392ck40 FIND v(dout1_392) AT=25.025n

.meas tran vdout1_393ck40 FIND v(dout1_393) AT=25.025n

.meas tran vdout1_394ck40 FIND v(dout1_394) AT=25.025n

.meas tran vdout1_395ck40 FIND v(dout1_395) AT=25.025n

.meas tran vdout1_396ck40 FIND v(dout1_396) AT=25.025n

.meas tran vdout1_397ck40 FIND v(dout1_397) AT=25.025n

.meas tran vdout1_398ck40 FIND v(dout1_398) AT=25.025n

.meas tran vdout1_399ck40 FIND v(dout1_399) AT=25.025n

.meas tran vdout1_400ck40 FIND v(dout1_400) AT=25.025n

.meas tran vdout1_401ck40 FIND v(dout1_401) AT=25.025n

.meas tran vdout1_402ck40 FIND v(dout1_402) AT=25.025n

.meas tran vdout1_403ck40 FIND v(dout1_403) AT=25.025n

.meas tran vdout1_404ck40 FIND v(dout1_404) AT=25.025n

.meas tran vdout1_405ck40 FIND v(dout1_405) AT=25.025n

.meas tran vdout1_406ck40 FIND v(dout1_406) AT=25.025n

.meas tran vdout1_407ck40 FIND v(dout1_407) AT=25.025n

.meas tran vdout1_408ck40 FIND v(dout1_408) AT=25.025n

.meas tran vdout1_409ck40 FIND v(dout1_409) AT=25.025n

.meas tran vdout1_410ck40 FIND v(dout1_410) AT=25.025n

.meas tran vdout1_411ck40 FIND v(dout1_411) AT=25.025n

.meas tran vdout1_412ck40 FIND v(dout1_412) AT=25.025n

.meas tran vdout1_413ck40 FIND v(dout1_413) AT=25.025n

.meas tran vdout1_414ck40 FIND v(dout1_414) AT=25.025n

.meas tran vdout1_415ck40 FIND v(dout1_415) AT=25.025n

.meas tran vdout1_416ck40 FIND v(dout1_416) AT=25.025n

.meas tran vdout1_417ck40 FIND v(dout1_417) AT=25.025n

.meas tran vdout1_418ck40 FIND v(dout1_418) AT=25.025n

.meas tran vdout1_419ck40 FIND v(dout1_419) AT=25.025n

.meas tran vdout1_420ck40 FIND v(dout1_420) AT=25.025n

.meas tran vdout1_421ck40 FIND v(dout1_421) AT=25.025n

.meas tran vdout1_422ck40 FIND v(dout1_422) AT=25.025n

.meas tran vdout1_423ck40 FIND v(dout1_423) AT=25.025n

.meas tran vdout1_424ck40 FIND v(dout1_424) AT=25.025n

.meas tran vdout1_425ck40 FIND v(dout1_425) AT=25.025n

.meas tran vdout1_426ck40 FIND v(dout1_426) AT=25.025n

.meas tran vdout1_427ck40 FIND v(dout1_427) AT=25.025n

.meas tran vdout1_428ck40 FIND v(dout1_428) AT=25.025n

.meas tran vdout1_429ck40 FIND v(dout1_429) AT=25.025n

.meas tran vdout1_430ck40 FIND v(dout1_430) AT=25.025n

.meas tran vdout1_431ck40 FIND v(dout1_431) AT=25.025n

.meas tran vdout1_432ck40 FIND v(dout1_432) AT=25.025n

.meas tran vdout1_433ck40 FIND v(dout1_433) AT=25.025n

.meas tran vdout1_434ck40 FIND v(dout1_434) AT=25.025n

.meas tran vdout1_435ck40 FIND v(dout1_435) AT=25.025n

.meas tran vdout1_436ck40 FIND v(dout1_436) AT=25.025n

.meas tran vdout1_437ck40 FIND v(dout1_437) AT=25.025n

.meas tran vdout1_438ck40 FIND v(dout1_438) AT=25.025n

.meas tran vdout1_439ck40 FIND v(dout1_439) AT=25.025n

.meas tran vdout1_440ck40 FIND v(dout1_440) AT=25.025n

.meas tran vdout1_441ck40 FIND v(dout1_441) AT=25.025n

.meas tran vdout1_442ck40 FIND v(dout1_442) AT=25.025n

.meas tran vdout1_443ck40 FIND v(dout1_443) AT=25.025n

.meas tran vdout1_444ck40 FIND v(dout1_444) AT=25.025n

.meas tran vdout1_445ck40 FIND v(dout1_445) AT=25.025n

.meas tran vdout1_446ck40 FIND v(dout1_446) AT=25.025n

.meas tran vdout1_447ck40 FIND v(dout1_447) AT=25.025n

.meas tran vdout1_448ck40 FIND v(dout1_448) AT=25.025n

.meas tran vdout1_449ck40 FIND v(dout1_449) AT=25.025n

.meas tran vdout1_450ck40 FIND v(dout1_450) AT=25.025n

.meas tran vdout1_451ck40 FIND v(dout1_451) AT=25.025n

.meas tran vdout1_452ck40 FIND v(dout1_452) AT=25.025n

.meas tran vdout1_453ck40 FIND v(dout1_453) AT=25.025n

.meas tran vdout1_454ck40 FIND v(dout1_454) AT=25.025n

.meas tran vdout1_455ck40 FIND v(dout1_455) AT=25.025n

.meas tran vdout1_456ck40 FIND v(dout1_456) AT=25.025n

.meas tran vdout1_457ck40 FIND v(dout1_457) AT=25.025n

.meas tran vdout1_458ck40 FIND v(dout1_458) AT=25.025n

.meas tran vdout1_459ck40 FIND v(dout1_459) AT=25.025n

.meas tran vdout1_460ck40 FIND v(dout1_460) AT=25.025n

.meas tran vdout1_461ck40 FIND v(dout1_461) AT=25.025n

.meas tran vdout1_462ck40 FIND v(dout1_462) AT=25.025n

.meas tran vdout1_463ck40 FIND v(dout1_463) AT=25.025n

.meas tran vdout1_464ck40 FIND v(dout1_464) AT=25.025n

.meas tran vdout1_465ck40 FIND v(dout1_465) AT=25.025n

.meas tran vdout1_466ck40 FIND v(dout1_466) AT=25.025n

.meas tran vdout1_467ck40 FIND v(dout1_467) AT=25.025n

.meas tran vdout1_468ck40 FIND v(dout1_468) AT=25.025n

.meas tran vdout1_469ck40 FIND v(dout1_469) AT=25.025n

.meas tran vdout1_470ck40 FIND v(dout1_470) AT=25.025n

.meas tran vdout1_471ck40 FIND v(dout1_471) AT=25.025n

.meas tran vdout1_472ck40 FIND v(dout1_472) AT=25.025n

.meas tran vdout1_473ck40 FIND v(dout1_473) AT=25.025n

.meas tran vdout1_474ck40 FIND v(dout1_474) AT=25.025n

.meas tran vdout1_475ck40 FIND v(dout1_475) AT=25.025n

.meas tran vdout1_476ck40 FIND v(dout1_476) AT=25.025n

.meas tran vdout1_477ck40 FIND v(dout1_477) AT=25.025n

.meas tran vdout1_478ck40 FIND v(dout1_478) AT=25.025n

.meas tran vdout1_479ck40 FIND v(dout1_479) AT=25.025n

.meas tran vdout1_480ck40 FIND v(dout1_480) AT=25.025n

.meas tran vdout1_481ck40 FIND v(dout1_481) AT=25.025n

.meas tran vdout1_482ck40 FIND v(dout1_482) AT=25.025n

.meas tran vdout1_483ck40 FIND v(dout1_483) AT=25.025n

.meas tran vdout1_484ck40 FIND v(dout1_484) AT=25.025n

.meas tran vdout1_485ck40 FIND v(dout1_485) AT=25.025n

.meas tran vdout1_486ck40 FIND v(dout1_486) AT=25.025n

.meas tran vdout1_487ck40 FIND v(dout1_487) AT=25.025n

.meas tran vdout1_488ck40 FIND v(dout1_488) AT=25.025n

.meas tran vdout1_489ck40 FIND v(dout1_489) AT=25.025n

.meas tran vdout1_490ck40 FIND v(dout1_490) AT=25.025n

.meas tran vdout1_491ck40 FIND v(dout1_491) AT=25.025n

.meas tran vdout1_492ck40 FIND v(dout1_492) AT=25.025n

.meas tran vdout1_493ck40 FIND v(dout1_493) AT=25.025n

.meas tran vdout1_494ck40 FIND v(dout1_494) AT=25.025n

.meas tran vdout1_495ck40 FIND v(dout1_495) AT=25.025n

.meas tran vdout1_496ck40 FIND v(dout1_496) AT=25.025n

.meas tran vdout1_497ck40 FIND v(dout1_497) AT=25.025n

.meas tran vdout1_498ck40 FIND v(dout1_498) AT=25.025n

.meas tran vdout1_499ck40 FIND v(dout1_499) AT=25.025n

.meas tran vdout1_500ck40 FIND v(dout1_500) AT=25.025n

.meas tran vdout1_501ck40 FIND v(dout1_501) AT=25.025n

.meas tran vdout1_502ck40 FIND v(dout1_502) AT=25.025n

.meas tran vdout1_503ck40 FIND v(dout1_503) AT=25.025n

.meas tran vdout1_504ck40 FIND v(dout1_504) AT=25.025n

.meas tran vdout1_505ck40 FIND v(dout1_505) AT=25.025n

.meas tran vdout1_506ck40 FIND v(dout1_506) AT=25.025n

.meas tran vdout1_507ck40 FIND v(dout1_507) AT=25.025n

.meas tran vdout1_508ck40 FIND v(dout1_508) AT=25.025n

.meas tran vdout1_509ck40 FIND v(dout1_509) AT=25.025n

.meas tran vdout1_510ck40 FIND v(dout1_510) AT=25.025n

.meas tran vdout1_511ck40 FIND v(dout1_511) AT=25.025n

.meas tran vdout1_0ck50 FIND v(dout1_0) AT=30.025n

.meas tran vdout1_1ck50 FIND v(dout1_1) AT=30.025n

.meas tran vdout1_2ck50 FIND v(dout1_2) AT=30.025n

.meas tran vdout1_3ck50 FIND v(dout1_3) AT=30.025n

.meas tran vdout1_4ck50 FIND v(dout1_4) AT=30.025n

.meas tran vdout1_5ck50 FIND v(dout1_5) AT=30.025n

.meas tran vdout1_6ck50 FIND v(dout1_6) AT=30.025n

.meas tran vdout1_7ck50 FIND v(dout1_7) AT=30.025n

.meas tran vdout1_8ck50 FIND v(dout1_8) AT=30.025n

.meas tran vdout1_9ck50 FIND v(dout1_9) AT=30.025n

.meas tran vdout1_10ck50 FIND v(dout1_10) AT=30.025n

.meas tran vdout1_11ck50 FIND v(dout1_11) AT=30.025n

.meas tran vdout1_12ck50 FIND v(dout1_12) AT=30.025n

.meas tran vdout1_13ck50 FIND v(dout1_13) AT=30.025n

.meas tran vdout1_14ck50 FIND v(dout1_14) AT=30.025n

.meas tran vdout1_15ck50 FIND v(dout1_15) AT=30.025n

.meas tran vdout1_16ck50 FIND v(dout1_16) AT=30.025n

.meas tran vdout1_17ck50 FIND v(dout1_17) AT=30.025n

.meas tran vdout1_18ck50 FIND v(dout1_18) AT=30.025n

.meas tran vdout1_19ck50 FIND v(dout1_19) AT=30.025n

.meas tran vdout1_20ck50 FIND v(dout1_20) AT=30.025n

.meas tran vdout1_21ck50 FIND v(dout1_21) AT=30.025n

.meas tran vdout1_22ck50 FIND v(dout1_22) AT=30.025n

.meas tran vdout1_23ck50 FIND v(dout1_23) AT=30.025n

.meas tran vdout1_24ck50 FIND v(dout1_24) AT=30.025n

.meas tran vdout1_25ck50 FIND v(dout1_25) AT=30.025n

.meas tran vdout1_26ck50 FIND v(dout1_26) AT=30.025n

.meas tran vdout1_27ck50 FIND v(dout1_27) AT=30.025n

.meas tran vdout1_28ck50 FIND v(dout1_28) AT=30.025n

.meas tran vdout1_29ck50 FIND v(dout1_29) AT=30.025n

.meas tran vdout1_30ck50 FIND v(dout1_30) AT=30.025n

.meas tran vdout1_31ck50 FIND v(dout1_31) AT=30.025n

.meas tran vdout1_32ck50 FIND v(dout1_32) AT=30.025n

.meas tran vdout1_33ck50 FIND v(dout1_33) AT=30.025n

.meas tran vdout1_34ck50 FIND v(dout1_34) AT=30.025n

.meas tran vdout1_35ck50 FIND v(dout1_35) AT=30.025n

.meas tran vdout1_36ck50 FIND v(dout1_36) AT=30.025n

.meas tran vdout1_37ck50 FIND v(dout1_37) AT=30.025n

.meas tran vdout1_38ck50 FIND v(dout1_38) AT=30.025n

.meas tran vdout1_39ck50 FIND v(dout1_39) AT=30.025n

.meas tran vdout1_40ck50 FIND v(dout1_40) AT=30.025n

.meas tran vdout1_41ck50 FIND v(dout1_41) AT=30.025n

.meas tran vdout1_42ck50 FIND v(dout1_42) AT=30.025n

.meas tran vdout1_43ck50 FIND v(dout1_43) AT=30.025n

.meas tran vdout1_44ck50 FIND v(dout1_44) AT=30.025n

.meas tran vdout1_45ck50 FIND v(dout1_45) AT=30.025n

.meas tran vdout1_46ck50 FIND v(dout1_46) AT=30.025n

.meas tran vdout1_47ck50 FIND v(dout1_47) AT=30.025n

.meas tran vdout1_48ck50 FIND v(dout1_48) AT=30.025n

.meas tran vdout1_49ck50 FIND v(dout1_49) AT=30.025n

.meas tran vdout1_50ck50 FIND v(dout1_50) AT=30.025n

.meas tran vdout1_51ck50 FIND v(dout1_51) AT=30.025n

.meas tran vdout1_52ck50 FIND v(dout1_52) AT=30.025n

.meas tran vdout1_53ck50 FIND v(dout1_53) AT=30.025n

.meas tran vdout1_54ck50 FIND v(dout1_54) AT=30.025n

.meas tran vdout1_55ck50 FIND v(dout1_55) AT=30.025n

.meas tran vdout1_56ck50 FIND v(dout1_56) AT=30.025n

.meas tran vdout1_57ck50 FIND v(dout1_57) AT=30.025n

.meas tran vdout1_58ck50 FIND v(dout1_58) AT=30.025n

.meas tran vdout1_59ck50 FIND v(dout1_59) AT=30.025n

.meas tran vdout1_60ck50 FIND v(dout1_60) AT=30.025n

.meas tran vdout1_61ck50 FIND v(dout1_61) AT=30.025n

.meas tran vdout1_62ck50 FIND v(dout1_62) AT=30.025n

.meas tran vdout1_63ck50 FIND v(dout1_63) AT=30.025n

.meas tran vdout1_64ck50 FIND v(dout1_64) AT=30.025n

.meas tran vdout1_65ck50 FIND v(dout1_65) AT=30.025n

.meas tran vdout1_66ck50 FIND v(dout1_66) AT=30.025n

.meas tran vdout1_67ck50 FIND v(dout1_67) AT=30.025n

.meas tran vdout1_68ck50 FIND v(dout1_68) AT=30.025n

.meas tran vdout1_69ck50 FIND v(dout1_69) AT=30.025n

.meas tran vdout1_70ck50 FIND v(dout1_70) AT=30.025n

.meas tran vdout1_71ck50 FIND v(dout1_71) AT=30.025n

.meas tran vdout1_72ck50 FIND v(dout1_72) AT=30.025n

.meas tran vdout1_73ck50 FIND v(dout1_73) AT=30.025n

.meas tran vdout1_74ck50 FIND v(dout1_74) AT=30.025n

.meas tran vdout1_75ck50 FIND v(dout1_75) AT=30.025n

.meas tran vdout1_76ck50 FIND v(dout1_76) AT=30.025n

.meas tran vdout1_77ck50 FIND v(dout1_77) AT=30.025n

.meas tran vdout1_78ck50 FIND v(dout1_78) AT=30.025n

.meas tran vdout1_79ck50 FIND v(dout1_79) AT=30.025n

.meas tran vdout1_80ck50 FIND v(dout1_80) AT=30.025n

.meas tran vdout1_81ck50 FIND v(dout1_81) AT=30.025n

.meas tran vdout1_82ck50 FIND v(dout1_82) AT=30.025n

.meas tran vdout1_83ck50 FIND v(dout1_83) AT=30.025n

.meas tran vdout1_84ck50 FIND v(dout1_84) AT=30.025n

.meas tran vdout1_85ck50 FIND v(dout1_85) AT=30.025n

.meas tran vdout1_86ck50 FIND v(dout1_86) AT=30.025n

.meas tran vdout1_87ck50 FIND v(dout1_87) AT=30.025n

.meas tran vdout1_88ck50 FIND v(dout1_88) AT=30.025n

.meas tran vdout1_89ck50 FIND v(dout1_89) AT=30.025n

.meas tran vdout1_90ck50 FIND v(dout1_90) AT=30.025n

.meas tran vdout1_91ck50 FIND v(dout1_91) AT=30.025n

.meas tran vdout1_92ck50 FIND v(dout1_92) AT=30.025n

.meas tran vdout1_93ck50 FIND v(dout1_93) AT=30.025n

.meas tran vdout1_94ck50 FIND v(dout1_94) AT=30.025n

.meas tran vdout1_95ck50 FIND v(dout1_95) AT=30.025n

.meas tran vdout1_96ck50 FIND v(dout1_96) AT=30.025n

.meas tran vdout1_97ck50 FIND v(dout1_97) AT=30.025n

.meas tran vdout1_98ck50 FIND v(dout1_98) AT=30.025n

.meas tran vdout1_99ck50 FIND v(dout1_99) AT=30.025n

.meas tran vdout1_100ck50 FIND v(dout1_100) AT=30.025n

.meas tran vdout1_101ck50 FIND v(dout1_101) AT=30.025n

.meas tran vdout1_102ck50 FIND v(dout1_102) AT=30.025n

.meas tran vdout1_103ck50 FIND v(dout1_103) AT=30.025n

.meas tran vdout1_104ck50 FIND v(dout1_104) AT=30.025n

.meas tran vdout1_105ck50 FIND v(dout1_105) AT=30.025n

.meas tran vdout1_106ck50 FIND v(dout1_106) AT=30.025n

.meas tran vdout1_107ck50 FIND v(dout1_107) AT=30.025n

.meas tran vdout1_108ck50 FIND v(dout1_108) AT=30.025n

.meas tran vdout1_109ck50 FIND v(dout1_109) AT=30.025n

.meas tran vdout1_110ck50 FIND v(dout1_110) AT=30.025n

.meas tran vdout1_111ck50 FIND v(dout1_111) AT=30.025n

.meas tran vdout1_112ck50 FIND v(dout1_112) AT=30.025n

.meas tran vdout1_113ck50 FIND v(dout1_113) AT=30.025n

.meas tran vdout1_114ck50 FIND v(dout1_114) AT=30.025n

.meas tran vdout1_115ck50 FIND v(dout1_115) AT=30.025n

.meas tran vdout1_116ck50 FIND v(dout1_116) AT=30.025n

.meas tran vdout1_117ck50 FIND v(dout1_117) AT=30.025n

.meas tran vdout1_118ck50 FIND v(dout1_118) AT=30.025n

.meas tran vdout1_119ck50 FIND v(dout1_119) AT=30.025n

.meas tran vdout1_120ck50 FIND v(dout1_120) AT=30.025n

.meas tran vdout1_121ck50 FIND v(dout1_121) AT=30.025n

.meas tran vdout1_122ck50 FIND v(dout1_122) AT=30.025n

.meas tran vdout1_123ck50 FIND v(dout1_123) AT=30.025n

.meas tran vdout1_124ck50 FIND v(dout1_124) AT=30.025n

.meas tran vdout1_125ck50 FIND v(dout1_125) AT=30.025n

.meas tran vdout1_126ck50 FIND v(dout1_126) AT=30.025n

.meas tran vdout1_127ck50 FIND v(dout1_127) AT=30.025n

.meas tran vdout1_128ck50 FIND v(dout1_128) AT=30.025n

.meas tran vdout1_129ck50 FIND v(dout1_129) AT=30.025n

.meas tran vdout1_130ck50 FIND v(dout1_130) AT=30.025n

.meas tran vdout1_131ck50 FIND v(dout1_131) AT=30.025n

.meas tran vdout1_132ck50 FIND v(dout1_132) AT=30.025n

.meas tran vdout1_133ck50 FIND v(dout1_133) AT=30.025n

.meas tran vdout1_134ck50 FIND v(dout1_134) AT=30.025n

.meas tran vdout1_135ck50 FIND v(dout1_135) AT=30.025n

.meas tran vdout1_136ck50 FIND v(dout1_136) AT=30.025n

.meas tran vdout1_137ck50 FIND v(dout1_137) AT=30.025n

.meas tran vdout1_138ck50 FIND v(dout1_138) AT=30.025n

.meas tran vdout1_139ck50 FIND v(dout1_139) AT=30.025n

.meas tran vdout1_140ck50 FIND v(dout1_140) AT=30.025n

.meas tran vdout1_141ck50 FIND v(dout1_141) AT=30.025n

.meas tran vdout1_142ck50 FIND v(dout1_142) AT=30.025n

.meas tran vdout1_143ck50 FIND v(dout1_143) AT=30.025n

.meas tran vdout1_144ck50 FIND v(dout1_144) AT=30.025n

.meas tran vdout1_145ck50 FIND v(dout1_145) AT=30.025n

.meas tran vdout1_146ck50 FIND v(dout1_146) AT=30.025n

.meas tran vdout1_147ck50 FIND v(dout1_147) AT=30.025n

.meas tran vdout1_148ck50 FIND v(dout1_148) AT=30.025n

.meas tran vdout1_149ck50 FIND v(dout1_149) AT=30.025n

.meas tran vdout1_150ck50 FIND v(dout1_150) AT=30.025n

.meas tran vdout1_151ck50 FIND v(dout1_151) AT=30.025n

.meas tran vdout1_152ck50 FIND v(dout1_152) AT=30.025n

.meas tran vdout1_153ck50 FIND v(dout1_153) AT=30.025n

.meas tran vdout1_154ck50 FIND v(dout1_154) AT=30.025n

.meas tran vdout1_155ck50 FIND v(dout1_155) AT=30.025n

.meas tran vdout1_156ck50 FIND v(dout1_156) AT=30.025n

.meas tran vdout1_157ck50 FIND v(dout1_157) AT=30.025n

.meas tran vdout1_158ck50 FIND v(dout1_158) AT=30.025n

.meas tran vdout1_159ck50 FIND v(dout1_159) AT=30.025n

.meas tran vdout1_160ck50 FIND v(dout1_160) AT=30.025n

.meas tran vdout1_161ck50 FIND v(dout1_161) AT=30.025n

.meas tran vdout1_162ck50 FIND v(dout1_162) AT=30.025n

.meas tran vdout1_163ck50 FIND v(dout1_163) AT=30.025n

.meas tran vdout1_164ck50 FIND v(dout1_164) AT=30.025n

.meas tran vdout1_165ck50 FIND v(dout1_165) AT=30.025n

.meas tran vdout1_166ck50 FIND v(dout1_166) AT=30.025n

.meas tran vdout1_167ck50 FIND v(dout1_167) AT=30.025n

.meas tran vdout1_168ck50 FIND v(dout1_168) AT=30.025n

.meas tran vdout1_169ck50 FIND v(dout1_169) AT=30.025n

.meas tran vdout1_170ck50 FIND v(dout1_170) AT=30.025n

.meas tran vdout1_171ck50 FIND v(dout1_171) AT=30.025n

.meas tran vdout1_172ck50 FIND v(dout1_172) AT=30.025n

.meas tran vdout1_173ck50 FIND v(dout1_173) AT=30.025n

.meas tran vdout1_174ck50 FIND v(dout1_174) AT=30.025n

.meas tran vdout1_175ck50 FIND v(dout1_175) AT=30.025n

.meas tran vdout1_176ck50 FIND v(dout1_176) AT=30.025n

.meas tran vdout1_177ck50 FIND v(dout1_177) AT=30.025n

.meas tran vdout1_178ck50 FIND v(dout1_178) AT=30.025n

.meas tran vdout1_179ck50 FIND v(dout1_179) AT=30.025n

.meas tran vdout1_180ck50 FIND v(dout1_180) AT=30.025n

.meas tran vdout1_181ck50 FIND v(dout1_181) AT=30.025n

.meas tran vdout1_182ck50 FIND v(dout1_182) AT=30.025n

.meas tran vdout1_183ck50 FIND v(dout1_183) AT=30.025n

.meas tran vdout1_184ck50 FIND v(dout1_184) AT=30.025n

.meas tran vdout1_185ck50 FIND v(dout1_185) AT=30.025n

.meas tran vdout1_186ck50 FIND v(dout1_186) AT=30.025n

.meas tran vdout1_187ck50 FIND v(dout1_187) AT=30.025n

.meas tran vdout1_188ck50 FIND v(dout1_188) AT=30.025n

.meas tran vdout1_189ck50 FIND v(dout1_189) AT=30.025n

.meas tran vdout1_190ck50 FIND v(dout1_190) AT=30.025n

.meas tran vdout1_191ck50 FIND v(dout1_191) AT=30.025n

.meas tran vdout1_192ck50 FIND v(dout1_192) AT=30.025n

.meas tran vdout1_193ck50 FIND v(dout1_193) AT=30.025n

.meas tran vdout1_194ck50 FIND v(dout1_194) AT=30.025n

.meas tran vdout1_195ck50 FIND v(dout1_195) AT=30.025n

.meas tran vdout1_196ck50 FIND v(dout1_196) AT=30.025n

.meas tran vdout1_197ck50 FIND v(dout1_197) AT=30.025n

.meas tran vdout1_198ck50 FIND v(dout1_198) AT=30.025n

.meas tran vdout1_199ck50 FIND v(dout1_199) AT=30.025n

.meas tran vdout1_200ck50 FIND v(dout1_200) AT=30.025n

.meas tran vdout1_201ck50 FIND v(dout1_201) AT=30.025n

.meas tran vdout1_202ck50 FIND v(dout1_202) AT=30.025n

.meas tran vdout1_203ck50 FIND v(dout1_203) AT=30.025n

.meas tran vdout1_204ck50 FIND v(dout1_204) AT=30.025n

.meas tran vdout1_205ck50 FIND v(dout1_205) AT=30.025n

.meas tran vdout1_206ck50 FIND v(dout1_206) AT=30.025n

.meas tran vdout1_207ck50 FIND v(dout1_207) AT=30.025n

.meas tran vdout1_208ck50 FIND v(dout1_208) AT=30.025n

.meas tran vdout1_209ck50 FIND v(dout1_209) AT=30.025n

.meas tran vdout1_210ck50 FIND v(dout1_210) AT=30.025n

.meas tran vdout1_211ck50 FIND v(dout1_211) AT=30.025n

.meas tran vdout1_212ck50 FIND v(dout1_212) AT=30.025n

.meas tran vdout1_213ck50 FIND v(dout1_213) AT=30.025n

.meas tran vdout1_214ck50 FIND v(dout1_214) AT=30.025n

.meas tran vdout1_215ck50 FIND v(dout1_215) AT=30.025n

.meas tran vdout1_216ck50 FIND v(dout1_216) AT=30.025n

.meas tran vdout1_217ck50 FIND v(dout1_217) AT=30.025n

.meas tran vdout1_218ck50 FIND v(dout1_218) AT=30.025n

.meas tran vdout1_219ck50 FIND v(dout1_219) AT=30.025n

.meas tran vdout1_220ck50 FIND v(dout1_220) AT=30.025n

.meas tran vdout1_221ck50 FIND v(dout1_221) AT=30.025n

.meas tran vdout1_222ck50 FIND v(dout1_222) AT=30.025n

.meas tran vdout1_223ck50 FIND v(dout1_223) AT=30.025n

.meas tran vdout1_224ck50 FIND v(dout1_224) AT=30.025n

.meas tran vdout1_225ck50 FIND v(dout1_225) AT=30.025n

.meas tran vdout1_226ck50 FIND v(dout1_226) AT=30.025n

.meas tran vdout1_227ck50 FIND v(dout1_227) AT=30.025n

.meas tran vdout1_228ck50 FIND v(dout1_228) AT=30.025n

.meas tran vdout1_229ck50 FIND v(dout1_229) AT=30.025n

.meas tran vdout1_230ck50 FIND v(dout1_230) AT=30.025n

.meas tran vdout1_231ck50 FIND v(dout1_231) AT=30.025n

.meas tran vdout1_232ck50 FIND v(dout1_232) AT=30.025n

.meas tran vdout1_233ck50 FIND v(dout1_233) AT=30.025n

.meas tran vdout1_234ck50 FIND v(dout1_234) AT=30.025n

.meas tran vdout1_235ck50 FIND v(dout1_235) AT=30.025n

.meas tran vdout1_236ck50 FIND v(dout1_236) AT=30.025n

.meas tran vdout1_237ck50 FIND v(dout1_237) AT=30.025n

.meas tran vdout1_238ck50 FIND v(dout1_238) AT=30.025n

.meas tran vdout1_239ck50 FIND v(dout1_239) AT=30.025n

.meas tran vdout1_240ck50 FIND v(dout1_240) AT=30.025n

.meas tran vdout1_241ck50 FIND v(dout1_241) AT=30.025n

.meas tran vdout1_242ck50 FIND v(dout1_242) AT=30.025n

.meas tran vdout1_243ck50 FIND v(dout1_243) AT=30.025n

.meas tran vdout1_244ck50 FIND v(dout1_244) AT=30.025n

.meas tran vdout1_245ck50 FIND v(dout1_245) AT=30.025n

.meas tran vdout1_246ck50 FIND v(dout1_246) AT=30.025n

.meas tran vdout1_247ck50 FIND v(dout1_247) AT=30.025n

.meas tran vdout1_248ck50 FIND v(dout1_248) AT=30.025n

.meas tran vdout1_249ck50 FIND v(dout1_249) AT=30.025n

.meas tran vdout1_250ck50 FIND v(dout1_250) AT=30.025n

.meas tran vdout1_251ck50 FIND v(dout1_251) AT=30.025n

.meas tran vdout1_252ck50 FIND v(dout1_252) AT=30.025n

.meas tran vdout1_253ck50 FIND v(dout1_253) AT=30.025n

.meas tran vdout1_254ck50 FIND v(dout1_254) AT=30.025n

.meas tran vdout1_255ck50 FIND v(dout1_255) AT=30.025n

.meas tran vdout1_256ck50 FIND v(dout1_256) AT=30.025n

.meas tran vdout1_257ck50 FIND v(dout1_257) AT=30.025n

.meas tran vdout1_258ck50 FIND v(dout1_258) AT=30.025n

.meas tran vdout1_259ck50 FIND v(dout1_259) AT=30.025n

.meas tran vdout1_260ck50 FIND v(dout1_260) AT=30.025n

.meas tran vdout1_261ck50 FIND v(dout1_261) AT=30.025n

.meas tran vdout1_262ck50 FIND v(dout1_262) AT=30.025n

.meas tran vdout1_263ck50 FIND v(dout1_263) AT=30.025n

.meas tran vdout1_264ck50 FIND v(dout1_264) AT=30.025n

.meas tran vdout1_265ck50 FIND v(dout1_265) AT=30.025n

.meas tran vdout1_266ck50 FIND v(dout1_266) AT=30.025n

.meas tran vdout1_267ck50 FIND v(dout1_267) AT=30.025n

.meas tran vdout1_268ck50 FIND v(dout1_268) AT=30.025n

.meas tran vdout1_269ck50 FIND v(dout1_269) AT=30.025n

.meas tran vdout1_270ck50 FIND v(dout1_270) AT=30.025n

.meas tran vdout1_271ck50 FIND v(dout1_271) AT=30.025n

.meas tran vdout1_272ck50 FIND v(dout1_272) AT=30.025n

.meas tran vdout1_273ck50 FIND v(dout1_273) AT=30.025n

.meas tran vdout1_274ck50 FIND v(dout1_274) AT=30.025n

.meas tran vdout1_275ck50 FIND v(dout1_275) AT=30.025n

.meas tran vdout1_276ck50 FIND v(dout1_276) AT=30.025n

.meas tran vdout1_277ck50 FIND v(dout1_277) AT=30.025n

.meas tran vdout1_278ck50 FIND v(dout1_278) AT=30.025n

.meas tran vdout1_279ck50 FIND v(dout1_279) AT=30.025n

.meas tran vdout1_280ck50 FIND v(dout1_280) AT=30.025n

.meas tran vdout1_281ck50 FIND v(dout1_281) AT=30.025n

.meas tran vdout1_282ck50 FIND v(dout1_282) AT=30.025n

.meas tran vdout1_283ck50 FIND v(dout1_283) AT=30.025n

.meas tran vdout1_284ck50 FIND v(dout1_284) AT=30.025n

.meas tran vdout1_285ck50 FIND v(dout1_285) AT=30.025n

.meas tran vdout1_286ck50 FIND v(dout1_286) AT=30.025n

.meas tran vdout1_287ck50 FIND v(dout1_287) AT=30.025n

.meas tran vdout1_288ck50 FIND v(dout1_288) AT=30.025n

.meas tran vdout1_289ck50 FIND v(dout1_289) AT=30.025n

.meas tran vdout1_290ck50 FIND v(dout1_290) AT=30.025n

.meas tran vdout1_291ck50 FIND v(dout1_291) AT=30.025n

.meas tran vdout1_292ck50 FIND v(dout1_292) AT=30.025n

.meas tran vdout1_293ck50 FIND v(dout1_293) AT=30.025n

.meas tran vdout1_294ck50 FIND v(dout1_294) AT=30.025n

.meas tran vdout1_295ck50 FIND v(dout1_295) AT=30.025n

.meas tran vdout1_296ck50 FIND v(dout1_296) AT=30.025n

.meas tran vdout1_297ck50 FIND v(dout1_297) AT=30.025n

.meas tran vdout1_298ck50 FIND v(dout1_298) AT=30.025n

.meas tran vdout1_299ck50 FIND v(dout1_299) AT=30.025n

.meas tran vdout1_300ck50 FIND v(dout1_300) AT=30.025n

.meas tran vdout1_301ck50 FIND v(dout1_301) AT=30.025n

.meas tran vdout1_302ck50 FIND v(dout1_302) AT=30.025n

.meas tran vdout1_303ck50 FIND v(dout1_303) AT=30.025n

.meas tran vdout1_304ck50 FIND v(dout1_304) AT=30.025n

.meas tran vdout1_305ck50 FIND v(dout1_305) AT=30.025n

.meas tran vdout1_306ck50 FIND v(dout1_306) AT=30.025n

.meas tran vdout1_307ck50 FIND v(dout1_307) AT=30.025n

.meas tran vdout1_308ck50 FIND v(dout1_308) AT=30.025n

.meas tran vdout1_309ck50 FIND v(dout1_309) AT=30.025n

.meas tran vdout1_310ck50 FIND v(dout1_310) AT=30.025n

.meas tran vdout1_311ck50 FIND v(dout1_311) AT=30.025n

.meas tran vdout1_312ck50 FIND v(dout1_312) AT=30.025n

.meas tran vdout1_313ck50 FIND v(dout1_313) AT=30.025n

.meas tran vdout1_314ck50 FIND v(dout1_314) AT=30.025n

.meas tran vdout1_315ck50 FIND v(dout1_315) AT=30.025n

.meas tran vdout1_316ck50 FIND v(dout1_316) AT=30.025n

.meas tran vdout1_317ck50 FIND v(dout1_317) AT=30.025n

.meas tran vdout1_318ck50 FIND v(dout1_318) AT=30.025n

.meas tran vdout1_319ck50 FIND v(dout1_319) AT=30.025n

.meas tran vdout1_320ck50 FIND v(dout1_320) AT=30.025n

.meas tran vdout1_321ck50 FIND v(dout1_321) AT=30.025n

.meas tran vdout1_322ck50 FIND v(dout1_322) AT=30.025n

.meas tran vdout1_323ck50 FIND v(dout1_323) AT=30.025n

.meas tran vdout1_324ck50 FIND v(dout1_324) AT=30.025n

.meas tran vdout1_325ck50 FIND v(dout1_325) AT=30.025n

.meas tran vdout1_326ck50 FIND v(dout1_326) AT=30.025n

.meas tran vdout1_327ck50 FIND v(dout1_327) AT=30.025n

.meas tran vdout1_328ck50 FIND v(dout1_328) AT=30.025n

.meas tran vdout1_329ck50 FIND v(dout1_329) AT=30.025n

.meas tran vdout1_330ck50 FIND v(dout1_330) AT=30.025n

.meas tran vdout1_331ck50 FIND v(dout1_331) AT=30.025n

.meas tran vdout1_332ck50 FIND v(dout1_332) AT=30.025n

.meas tran vdout1_333ck50 FIND v(dout1_333) AT=30.025n

.meas tran vdout1_334ck50 FIND v(dout1_334) AT=30.025n

.meas tran vdout1_335ck50 FIND v(dout1_335) AT=30.025n

.meas tran vdout1_336ck50 FIND v(dout1_336) AT=30.025n

.meas tran vdout1_337ck50 FIND v(dout1_337) AT=30.025n

.meas tran vdout1_338ck50 FIND v(dout1_338) AT=30.025n

.meas tran vdout1_339ck50 FIND v(dout1_339) AT=30.025n

.meas tran vdout1_340ck50 FIND v(dout1_340) AT=30.025n

.meas tran vdout1_341ck50 FIND v(dout1_341) AT=30.025n

.meas tran vdout1_342ck50 FIND v(dout1_342) AT=30.025n

.meas tran vdout1_343ck50 FIND v(dout1_343) AT=30.025n

.meas tran vdout1_344ck50 FIND v(dout1_344) AT=30.025n

.meas tran vdout1_345ck50 FIND v(dout1_345) AT=30.025n

.meas tran vdout1_346ck50 FIND v(dout1_346) AT=30.025n

.meas tran vdout1_347ck50 FIND v(dout1_347) AT=30.025n

.meas tran vdout1_348ck50 FIND v(dout1_348) AT=30.025n

.meas tran vdout1_349ck50 FIND v(dout1_349) AT=30.025n

.meas tran vdout1_350ck50 FIND v(dout1_350) AT=30.025n

.meas tran vdout1_351ck50 FIND v(dout1_351) AT=30.025n

.meas tran vdout1_352ck50 FIND v(dout1_352) AT=30.025n

.meas tran vdout1_353ck50 FIND v(dout1_353) AT=30.025n

.meas tran vdout1_354ck50 FIND v(dout1_354) AT=30.025n

.meas tran vdout1_355ck50 FIND v(dout1_355) AT=30.025n

.meas tran vdout1_356ck50 FIND v(dout1_356) AT=30.025n

.meas tran vdout1_357ck50 FIND v(dout1_357) AT=30.025n

.meas tran vdout1_358ck50 FIND v(dout1_358) AT=30.025n

.meas tran vdout1_359ck50 FIND v(dout1_359) AT=30.025n

.meas tran vdout1_360ck50 FIND v(dout1_360) AT=30.025n

.meas tran vdout1_361ck50 FIND v(dout1_361) AT=30.025n

.meas tran vdout1_362ck50 FIND v(dout1_362) AT=30.025n

.meas tran vdout1_363ck50 FIND v(dout1_363) AT=30.025n

.meas tran vdout1_364ck50 FIND v(dout1_364) AT=30.025n

.meas tran vdout1_365ck50 FIND v(dout1_365) AT=30.025n

.meas tran vdout1_366ck50 FIND v(dout1_366) AT=30.025n

.meas tran vdout1_367ck50 FIND v(dout1_367) AT=30.025n

.meas tran vdout1_368ck50 FIND v(dout1_368) AT=30.025n

.meas tran vdout1_369ck50 FIND v(dout1_369) AT=30.025n

.meas tran vdout1_370ck50 FIND v(dout1_370) AT=30.025n

.meas tran vdout1_371ck50 FIND v(dout1_371) AT=30.025n

.meas tran vdout1_372ck50 FIND v(dout1_372) AT=30.025n

.meas tran vdout1_373ck50 FIND v(dout1_373) AT=30.025n

.meas tran vdout1_374ck50 FIND v(dout1_374) AT=30.025n

.meas tran vdout1_375ck50 FIND v(dout1_375) AT=30.025n

.meas tran vdout1_376ck50 FIND v(dout1_376) AT=30.025n

.meas tran vdout1_377ck50 FIND v(dout1_377) AT=30.025n

.meas tran vdout1_378ck50 FIND v(dout1_378) AT=30.025n

.meas tran vdout1_379ck50 FIND v(dout1_379) AT=30.025n

.meas tran vdout1_380ck50 FIND v(dout1_380) AT=30.025n

.meas tran vdout1_381ck50 FIND v(dout1_381) AT=30.025n

.meas tran vdout1_382ck50 FIND v(dout1_382) AT=30.025n

.meas tran vdout1_383ck50 FIND v(dout1_383) AT=30.025n

.meas tran vdout1_384ck50 FIND v(dout1_384) AT=30.025n

.meas tran vdout1_385ck50 FIND v(dout1_385) AT=30.025n

.meas tran vdout1_386ck50 FIND v(dout1_386) AT=30.025n

.meas tran vdout1_387ck50 FIND v(dout1_387) AT=30.025n

.meas tran vdout1_388ck50 FIND v(dout1_388) AT=30.025n

.meas tran vdout1_389ck50 FIND v(dout1_389) AT=30.025n

.meas tran vdout1_390ck50 FIND v(dout1_390) AT=30.025n

.meas tran vdout1_391ck50 FIND v(dout1_391) AT=30.025n

.meas tran vdout1_392ck50 FIND v(dout1_392) AT=30.025n

.meas tran vdout1_393ck50 FIND v(dout1_393) AT=30.025n

.meas tran vdout1_394ck50 FIND v(dout1_394) AT=30.025n

.meas tran vdout1_395ck50 FIND v(dout1_395) AT=30.025n

.meas tran vdout1_396ck50 FIND v(dout1_396) AT=30.025n

.meas tran vdout1_397ck50 FIND v(dout1_397) AT=30.025n

.meas tran vdout1_398ck50 FIND v(dout1_398) AT=30.025n

.meas tran vdout1_399ck50 FIND v(dout1_399) AT=30.025n

.meas tran vdout1_400ck50 FIND v(dout1_400) AT=30.025n

.meas tran vdout1_401ck50 FIND v(dout1_401) AT=30.025n

.meas tran vdout1_402ck50 FIND v(dout1_402) AT=30.025n

.meas tran vdout1_403ck50 FIND v(dout1_403) AT=30.025n

.meas tran vdout1_404ck50 FIND v(dout1_404) AT=30.025n

.meas tran vdout1_405ck50 FIND v(dout1_405) AT=30.025n

.meas tran vdout1_406ck50 FIND v(dout1_406) AT=30.025n

.meas tran vdout1_407ck50 FIND v(dout1_407) AT=30.025n

.meas tran vdout1_408ck50 FIND v(dout1_408) AT=30.025n

.meas tran vdout1_409ck50 FIND v(dout1_409) AT=30.025n

.meas tran vdout1_410ck50 FIND v(dout1_410) AT=30.025n

.meas tran vdout1_411ck50 FIND v(dout1_411) AT=30.025n

.meas tran vdout1_412ck50 FIND v(dout1_412) AT=30.025n

.meas tran vdout1_413ck50 FIND v(dout1_413) AT=30.025n

.meas tran vdout1_414ck50 FIND v(dout1_414) AT=30.025n

.meas tran vdout1_415ck50 FIND v(dout1_415) AT=30.025n

.meas tran vdout1_416ck50 FIND v(dout1_416) AT=30.025n

.meas tran vdout1_417ck50 FIND v(dout1_417) AT=30.025n

.meas tran vdout1_418ck50 FIND v(dout1_418) AT=30.025n

.meas tran vdout1_419ck50 FIND v(dout1_419) AT=30.025n

.meas tran vdout1_420ck50 FIND v(dout1_420) AT=30.025n

.meas tran vdout1_421ck50 FIND v(dout1_421) AT=30.025n

.meas tran vdout1_422ck50 FIND v(dout1_422) AT=30.025n

.meas tran vdout1_423ck50 FIND v(dout1_423) AT=30.025n

.meas tran vdout1_424ck50 FIND v(dout1_424) AT=30.025n

.meas tran vdout1_425ck50 FIND v(dout1_425) AT=30.025n

.meas tran vdout1_426ck50 FIND v(dout1_426) AT=30.025n

.meas tran vdout1_427ck50 FIND v(dout1_427) AT=30.025n

.meas tran vdout1_428ck50 FIND v(dout1_428) AT=30.025n

.meas tran vdout1_429ck50 FIND v(dout1_429) AT=30.025n

.meas tran vdout1_430ck50 FIND v(dout1_430) AT=30.025n

.meas tran vdout1_431ck50 FIND v(dout1_431) AT=30.025n

.meas tran vdout1_432ck50 FIND v(dout1_432) AT=30.025n

.meas tran vdout1_433ck50 FIND v(dout1_433) AT=30.025n

.meas tran vdout1_434ck50 FIND v(dout1_434) AT=30.025n

.meas tran vdout1_435ck50 FIND v(dout1_435) AT=30.025n

.meas tran vdout1_436ck50 FIND v(dout1_436) AT=30.025n

.meas tran vdout1_437ck50 FIND v(dout1_437) AT=30.025n

.meas tran vdout1_438ck50 FIND v(dout1_438) AT=30.025n

.meas tran vdout1_439ck50 FIND v(dout1_439) AT=30.025n

.meas tran vdout1_440ck50 FIND v(dout1_440) AT=30.025n

.meas tran vdout1_441ck50 FIND v(dout1_441) AT=30.025n

.meas tran vdout1_442ck50 FIND v(dout1_442) AT=30.025n

.meas tran vdout1_443ck50 FIND v(dout1_443) AT=30.025n

.meas tran vdout1_444ck50 FIND v(dout1_444) AT=30.025n

.meas tran vdout1_445ck50 FIND v(dout1_445) AT=30.025n

.meas tran vdout1_446ck50 FIND v(dout1_446) AT=30.025n

.meas tran vdout1_447ck50 FIND v(dout1_447) AT=30.025n

.meas tran vdout1_448ck50 FIND v(dout1_448) AT=30.025n

.meas tran vdout1_449ck50 FIND v(dout1_449) AT=30.025n

.meas tran vdout1_450ck50 FIND v(dout1_450) AT=30.025n

.meas tran vdout1_451ck50 FIND v(dout1_451) AT=30.025n

.meas tran vdout1_452ck50 FIND v(dout1_452) AT=30.025n

.meas tran vdout1_453ck50 FIND v(dout1_453) AT=30.025n

.meas tran vdout1_454ck50 FIND v(dout1_454) AT=30.025n

.meas tran vdout1_455ck50 FIND v(dout1_455) AT=30.025n

.meas tran vdout1_456ck50 FIND v(dout1_456) AT=30.025n

.meas tran vdout1_457ck50 FIND v(dout1_457) AT=30.025n

.meas tran vdout1_458ck50 FIND v(dout1_458) AT=30.025n

.meas tran vdout1_459ck50 FIND v(dout1_459) AT=30.025n

.meas tran vdout1_460ck50 FIND v(dout1_460) AT=30.025n

.meas tran vdout1_461ck50 FIND v(dout1_461) AT=30.025n

.meas tran vdout1_462ck50 FIND v(dout1_462) AT=30.025n

.meas tran vdout1_463ck50 FIND v(dout1_463) AT=30.025n

.meas tran vdout1_464ck50 FIND v(dout1_464) AT=30.025n

.meas tran vdout1_465ck50 FIND v(dout1_465) AT=30.025n

.meas tran vdout1_466ck50 FIND v(dout1_466) AT=30.025n

.meas tran vdout1_467ck50 FIND v(dout1_467) AT=30.025n

.meas tran vdout1_468ck50 FIND v(dout1_468) AT=30.025n

.meas tran vdout1_469ck50 FIND v(dout1_469) AT=30.025n

.meas tran vdout1_470ck50 FIND v(dout1_470) AT=30.025n

.meas tran vdout1_471ck50 FIND v(dout1_471) AT=30.025n

.meas tran vdout1_472ck50 FIND v(dout1_472) AT=30.025n

.meas tran vdout1_473ck50 FIND v(dout1_473) AT=30.025n

.meas tran vdout1_474ck50 FIND v(dout1_474) AT=30.025n

.meas tran vdout1_475ck50 FIND v(dout1_475) AT=30.025n

.meas tran vdout1_476ck50 FIND v(dout1_476) AT=30.025n

.meas tran vdout1_477ck50 FIND v(dout1_477) AT=30.025n

.meas tran vdout1_478ck50 FIND v(dout1_478) AT=30.025n

.meas tran vdout1_479ck50 FIND v(dout1_479) AT=30.025n

.meas tran vdout1_480ck50 FIND v(dout1_480) AT=30.025n

.meas tran vdout1_481ck50 FIND v(dout1_481) AT=30.025n

.meas tran vdout1_482ck50 FIND v(dout1_482) AT=30.025n

.meas tran vdout1_483ck50 FIND v(dout1_483) AT=30.025n

.meas tran vdout1_484ck50 FIND v(dout1_484) AT=30.025n

.meas tran vdout1_485ck50 FIND v(dout1_485) AT=30.025n

.meas tran vdout1_486ck50 FIND v(dout1_486) AT=30.025n

.meas tran vdout1_487ck50 FIND v(dout1_487) AT=30.025n

.meas tran vdout1_488ck50 FIND v(dout1_488) AT=30.025n

.meas tran vdout1_489ck50 FIND v(dout1_489) AT=30.025n

.meas tran vdout1_490ck50 FIND v(dout1_490) AT=30.025n

.meas tran vdout1_491ck50 FIND v(dout1_491) AT=30.025n

.meas tran vdout1_492ck50 FIND v(dout1_492) AT=30.025n

.meas tran vdout1_493ck50 FIND v(dout1_493) AT=30.025n

.meas tran vdout1_494ck50 FIND v(dout1_494) AT=30.025n

.meas tran vdout1_495ck50 FIND v(dout1_495) AT=30.025n

.meas tran vdout1_496ck50 FIND v(dout1_496) AT=30.025n

.meas tran vdout1_497ck50 FIND v(dout1_497) AT=30.025n

.meas tran vdout1_498ck50 FIND v(dout1_498) AT=30.025n

.meas tran vdout1_499ck50 FIND v(dout1_499) AT=30.025n

.meas tran vdout1_500ck50 FIND v(dout1_500) AT=30.025n

.meas tran vdout1_501ck50 FIND v(dout1_501) AT=30.025n

.meas tran vdout1_502ck50 FIND v(dout1_502) AT=30.025n

.meas tran vdout1_503ck50 FIND v(dout1_503) AT=30.025n

.meas tran vdout1_504ck50 FIND v(dout1_504) AT=30.025n

.meas tran vdout1_505ck50 FIND v(dout1_505) AT=30.025n

.meas tran vdout1_506ck50 FIND v(dout1_506) AT=30.025n

.meas tran vdout1_507ck50 FIND v(dout1_507) AT=30.025n

.meas tran vdout1_508ck50 FIND v(dout1_508) AT=30.025n

.meas tran vdout1_509ck50 FIND v(dout1_509) AT=30.025n

.meas tran vdout1_510ck50 FIND v(dout1_510) AT=30.025n

.meas tran vdout1_511ck50 FIND v(dout1_511) AT=30.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_17ck80 FIND v(dout1_17) AT=45.025n

.meas tran vdout1_18ck80 FIND v(dout1_18) AT=45.025n

.meas tran vdout1_19ck80 FIND v(dout1_19) AT=45.025n

.meas tran vdout1_20ck80 FIND v(dout1_20) AT=45.025n

.meas tran vdout1_21ck80 FIND v(dout1_21) AT=45.025n

.meas tran vdout1_22ck80 FIND v(dout1_22) AT=45.025n

.meas tran vdout1_23ck80 FIND v(dout1_23) AT=45.025n

.meas tran vdout1_24ck80 FIND v(dout1_24) AT=45.025n

.meas tran vdout1_25ck80 FIND v(dout1_25) AT=45.025n

.meas tran vdout1_26ck80 FIND v(dout1_26) AT=45.025n

.meas tran vdout1_27ck80 FIND v(dout1_27) AT=45.025n

.meas tran vdout1_28ck80 FIND v(dout1_28) AT=45.025n

.meas tran vdout1_29ck80 FIND v(dout1_29) AT=45.025n

.meas tran vdout1_30ck80 FIND v(dout1_30) AT=45.025n

.meas tran vdout1_31ck80 FIND v(dout1_31) AT=45.025n

.meas tran vdout1_32ck80 FIND v(dout1_32) AT=45.025n

.meas tran vdout1_33ck80 FIND v(dout1_33) AT=45.025n

.meas tran vdout1_34ck80 FIND v(dout1_34) AT=45.025n

.meas tran vdout1_35ck80 FIND v(dout1_35) AT=45.025n

.meas tran vdout1_36ck80 FIND v(dout1_36) AT=45.025n

.meas tran vdout1_37ck80 FIND v(dout1_37) AT=45.025n

.meas tran vdout1_38ck80 FIND v(dout1_38) AT=45.025n

.meas tran vdout1_39ck80 FIND v(dout1_39) AT=45.025n

.meas tran vdout1_40ck80 FIND v(dout1_40) AT=45.025n

.meas tran vdout1_41ck80 FIND v(dout1_41) AT=45.025n

.meas tran vdout1_42ck80 FIND v(dout1_42) AT=45.025n

.meas tran vdout1_43ck80 FIND v(dout1_43) AT=45.025n

.meas tran vdout1_44ck80 FIND v(dout1_44) AT=45.025n

.meas tran vdout1_45ck80 FIND v(dout1_45) AT=45.025n

.meas tran vdout1_46ck80 FIND v(dout1_46) AT=45.025n

.meas tran vdout1_47ck80 FIND v(dout1_47) AT=45.025n

.meas tran vdout1_48ck80 FIND v(dout1_48) AT=45.025n

.meas tran vdout1_49ck80 FIND v(dout1_49) AT=45.025n

.meas tran vdout1_50ck80 FIND v(dout1_50) AT=45.025n

.meas tran vdout1_51ck80 FIND v(dout1_51) AT=45.025n

.meas tran vdout1_52ck80 FIND v(dout1_52) AT=45.025n

.meas tran vdout1_53ck80 FIND v(dout1_53) AT=45.025n

.meas tran vdout1_54ck80 FIND v(dout1_54) AT=45.025n

.meas tran vdout1_55ck80 FIND v(dout1_55) AT=45.025n

.meas tran vdout1_56ck80 FIND v(dout1_56) AT=45.025n

.meas tran vdout1_57ck80 FIND v(dout1_57) AT=45.025n

.meas tran vdout1_58ck80 FIND v(dout1_58) AT=45.025n

.meas tran vdout1_59ck80 FIND v(dout1_59) AT=45.025n

.meas tran vdout1_60ck80 FIND v(dout1_60) AT=45.025n

.meas tran vdout1_61ck80 FIND v(dout1_61) AT=45.025n

.meas tran vdout1_62ck80 FIND v(dout1_62) AT=45.025n

.meas tran vdout1_63ck80 FIND v(dout1_63) AT=45.025n

.meas tran vdout1_64ck80 FIND v(dout1_64) AT=45.025n

.meas tran vdout1_65ck80 FIND v(dout1_65) AT=45.025n

.meas tran vdout1_66ck80 FIND v(dout1_66) AT=45.025n

.meas tran vdout1_67ck80 FIND v(dout1_67) AT=45.025n

.meas tran vdout1_68ck80 FIND v(dout1_68) AT=45.025n

.meas tran vdout1_69ck80 FIND v(dout1_69) AT=45.025n

.meas tran vdout1_70ck80 FIND v(dout1_70) AT=45.025n

.meas tran vdout1_71ck80 FIND v(dout1_71) AT=45.025n

.meas tran vdout1_72ck80 FIND v(dout1_72) AT=45.025n

.meas tran vdout1_73ck80 FIND v(dout1_73) AT=45.025n

.meas tran vdout1_74ck80 FIND v(dout1_74) AT=45.025n

.meas tran vdout1_75ck80 FIND v(dout1_75) AT=45.025n

.meas tran vdout1_76ck80 FIND v(dout1_76) AT=45.025n

.meas tran vdout1_77ck80 FIND v(dout1_77) AT=45.025n

.meas tran vdout1_78ck80 FIND v(dout1_78) AT=45.025n

.meas tran vdout1_79ck80 FIND v(dout1_79) AT=45.025n

.meas tran vdout1_80ck80 FIND v(dout1_80) AT=45.025n

.meas tran vdout1_81ck80 FIND v(dout1_81) AT=45.025n

.meas tran vdout1_82ck80 FIND v(dout1_82) AT=45.025n

.meas tran vdout1_83ck80 FIND v(dout1_83) AT=45.025n

.meas tran vdout1_84ck80 FIND v(dout1_84) AT=45.025n

.meas tran vdout1_85ck80 FIND v(dout1_85) AT=45.025n

.meas tran vdout1_86ck80 FIND v(dout1_86) AT=45.025n

.meas tran vdout1_87ck80 FIND v(dout1_87) AT=45.025n

.meas tran vdout1_88ck80 FIND v(dout1_88) AT=45.025n

.meas tran vdout1_89ck80 FIND v(dout1_89) AT=45.025n

.meas tran vdout1_90ck80 FIND v(dout1_90) AT=45.025n

.meas tran vdout1_91ck80 FIND v(dout1_91) AT=45.025n

.meas tran vdout1_92ck80 FIND v(dout1_92) AT=45.025n

.meas tran vdout1_93ck80 FIND v(dout1_93) AT=45.025n

.meas tran vdout1_94ck80 FIND v(dout1_94) AT=45.025n

.meas tran vdout1_95ck80 FIND v(dout1_95) AT=45.025n

.meas tran vdout1_96ck80 FIND v(dout1_96) AT=45.025n

.meas tran vdout1_97ck80 FIND v(dout1_97) AT=45.025n

.meas tran vdout1_98ck80 FIND v(dout1_98) AT=45.025n

.meas tran vdout1_99ck80 FIND v(dout1_99) AT=45.025n

.meas tran vdout1_100ck80 FIND v(dout1_100) AT=45.025n

.meas tran vdout1_101ck80 FIND v(dout1_101) AT=45.025n

.meas tran vdout1_102ck80 FIND v(dout1_102) AT=45.025n

.meas tran vdout1_103ck80 FIND v(dout1_103) AT=45.025n

.meas tran vdout1_104ck80 FIND v(dout1_104) AT=45.025n

.meas tran vdout1_105ck80 FIND v(dout1_105) AT=45.025n

.meas tran vdout1_106ck80 FIND v(dout1_106) AT=45.025n

.meas tran vdout1_107ck80 FIND v(dout1_107) AT=45.025n

.meas tran vdout1_108ck80 FIND v(dout1_108) AT=45.025n

.meas tran vdout1_109ck80 FIND v(dout1_109) AT=45.025n

.meas tran vdout1_110ck80 FIND v(dout1_110) AT=45.025n

.meas tran vdout1_111ck80 FIND v(dout1_111) AT=45.025n

.meas tran vdout1_112ck80 FIND v(dout1_112) AT=45.025n

.meas tran vdout1_113ck80 FIND v(dout1_113) AT=45.025n

.meas tran vdout1_114ck80 FIND v(dout1_114) AT=45.025n

.meas tran vdout1_115ck80 FIND v(dout1_115) AT=45.025n

.meas tran vdout1_116ck80 FIND v(dout1_116) AT=45.025n

.meas tran vdout1_117ck80 FIND v(dout1_117) AT=45.025n

.meas tran vdout1_118ck80 FIND v(dout1_118) AT=45.025n

.meas tran vdout1_119ck80 FIND v(dout1_119) AT=45.025n

.meas tran vdout1_120ck80 FIND v(dout1_120) AT=45.025n

.meas tran vdout1_121ck80 FIND v(dout1_121) AT=45.025n

.meas tran vdout1_122ck80 FIND v(dout1_122) AT=45.025n

.meas tran vdout1_123ck80 FIND v(dout1_123) AT=45.025n

.meas tran vdout1_124ck80 FIND v(dout1_124) AT=45.025n

.meas tran vdout1_125ck80 FIND v(dout1_125) AT=45.025n

.meas tran vdout1_126ck80 FIND v(dout1_126) AT=45.025n

.meas tran vdout1_127ck80 FIND v(dout1_127) AT=45.025n

.meas tran vdout1_128ck80 FIND v(dout1_128) AT=45.025n

.meas tran vdout1_129ck80 FIND v(dout1_129) AT=45.025n

.meas tran vdout1_130ck80 FIND v(dout1_130) AT=45.025n

.meas tran vdout1_131ck80 FIND v(dout1_131) AT=45.025n

.meas tran vdout1_132ck80 FIND v(dout1_132) AT=45.025n

.meas tran vdout1_133ck80 FIND v(dout1_133) AT=45.025n

.meas tran vdout1_134ck80 FIND v(dout1_134) AT=45.025n

.meas tran vdout1_135ck80 FIND v(dout1_135) AT=45.025n

.meas tran vdout1_136ck80 FIND v(dout1_136) AT=45.025n

.meas tran vdout1_137ck80 FIND v(dout1_137) AT=45.025n

.meas tran vdout1_138ck80 FIND v(dout1_138) AT=45.025n

.meas tran vdout1_139ck80 FIND v(dout1_139) AT=45.025n

.meas tran vdout1_140ck80 FIND v(dout1_140) AT=45.025n

.meas tran vdout1_141ck80 FIND v(dout1_141) AT=45.025n

.meas tran vdout1_142ck80 FIND v(dout1_142) AT=45.025n

.meas tran vdout1_143ck80 FIND v(dout1_143) AT=45.025n

.meas tran vdout1_144ck80 FIND v(dout1_144) AT=45.025n

.meas tran vdout1_145ck80 FIND v(dout1_145) AT=45.025n

.meas tran vdout1_146ck80 FIND v(dout1_146) AT=45.025n

.meas tran vdout1_147ck80 FIND v(dout1_147) AT=45.025n

.meas tran vdout1_148ck80 FIND v(dout1_148) AT=45.025n

.meas tran vdout1_149ck80 FIND v(dout1_149) AT=45.025n

.meas tran vdout1_150ck80 FIND v(dout1_150) AT=45.025n

.meas tran vdout1_151ck80 FIND v(dout1_151) AT=45.025n

.meas tran vdout1_152ck80 FIND v(dout1_152) AT=45.025n

.meas tran vdout1_153ck80 FIND v(dout1_153) AT=45.025n

.meas tran vdout1_154ck80 FIND v(dout1_154) AT=45.025n

.meas tran vdout1_155ck80 FIND v(dout1_155) AT=45.025n

.meas tran vdout1_156ck80 FIND v(dout1_156) AT=45.025n

.meas tran vdout1_157ck80 FIND v(dout1_157) AT=45.025n

.meas tran vdout1_158ck80 FIND v(dout1_158) AT=45.025n

.meas tran vdout1_159ck80 FIND v(dout1_159) AT=45.025n

.meas tran vdout1_160ck80 FIND v(dout1_160) AT=45.025n

.meas tran vdout1_161ck80 FIND v(dout1_161) AT=45.025n

.meas tran vdout1_162ck80 FIND v(dout1_162) AT=45.025n

.meas tran vdout1_163ck80 FIND v(dout1_163) AT=45.025n

.meas tran vdout1_164ck80 FIND v(dout1_164) AT=45.025n

.meas tran vdout1_165ck80 FIND v(dout1_165) AT=45.025n

.meas tran vdout1_166ck80 FIND v(dout1_166) AT=45.025n

.meas tran vdout1_167ck80 FIND v(dout1_167) AT=45.025n

.meas tran vdout1_168ck80 FIND v(dout1_168) AT=45.025n

.meas tran vdout1_169ck80 FIND v(dout1_169) AT=45.025n

.meas tran vdout1_170ck80 FIND v(dout1_170) AT=45.025n

.meas tran vdout1_171ck80 FIND v(dout1_171) AT=45.025n

.meas tran vdout1_172ck80 FIND v(dout1_172) AT=45.025n

.meas tran vdout1_173ck80 FIND v(dout1_173) AT=45.025n

.meas tran vdout1_174ck80 FIND v(dout1_174) AT=45.025n

.meas tran vdout1_175ck80 FIND v(dout1_175) AT=45.025n

.meas tran vdout1_176ck80 FIND v(dout1_176) AT=45.025n

.meas tran vdout1_177ck80 FIND v(dout1_177) AT=45.025n

.meas tran vdout1_178ck80 FIND v(dout1_178) AT=45.025n

.meas tran vdout1_179ck80 FIND v(dout1_179) AT=45.025n

.meas tran vdout1_180ck80 FIND v(dout1_180) AT=45.025n

.meas tran vdout1_181ck80 FIND v(dout1_181) AT=45.025n

.meas tran vdout1_182ck80 FIND v(dout1_182) AT=45.025n

.meas tran vdout1_183ck80 FIND v(dout1_183) AT=45.025n

.meas tran vdout1_184ck80 FIND v(dout1_184) AT=45.025n

.meas tran vdout1_185ck80 FIND v(dout1_185) AT=45.025n

.meas tran vdout1_186ck80 FIND v(dout1_186) AT=45.025n

.meas tran vdout1_187ck80 FIND v(dout1_187) AT=45.025n

.meas tran vdout1_188ck80 FIND v(dout1_188) AT=45.025n

.meas tran vdout1_189ck80 FIND v(dout1_189) AT=45.025n

.meas tran vdout1_190ck80 FIND v(dout1_190) AT=45.025n

.meas tran vdout1_191ck80 FIND v(dout1_191) AT=45.025n

.meas tran vdout1_192ck80 FIND v(dout1_192) AT=45.025n

.meas tran vdout1_193ck80 FIND v(dout1_193) AT=45.025n

.meas tran vdout1_194ck80 FIND v(dout1_194) AT=45.025n

.meas tran vdout1_195ck80 FIND v(dout1_195) AT=45.025n

.meas tran vdout1_196ck80 FIND v(dout1_196) AT=45.025n

.meas tran vdout1_197ck80 FIND v(dout1_197) AT=45.025n

.meas tran vdout1_198ck80 FIND v(dout1_198) AT=45.025n

.meas tran vdout1_199ck80 FIND v(dout1_199) AT=45.025n

.meas tran vdout1_200ck80 FIND v(dout1_200) AT=45.025n

.meas tran vdout1_201ck80 FIND v(dout1_201) AT=45.025n

.meas tran vdout1_202ck80 FIND v(dout1_202) AT=45.025n

.meas tran vdout1_203ck80 FIND v(dout1_203) AT=45.025n

.meas tran vdout1_204ck80 FIND v(dout1_204) AT=45.025n

.meas tran vdout1_205ck80 FIND v(dout1_205) AT=45.025n

.meas tran vdout1_206ck80 FIND v(dout1_206) AT=45.025n

.meas tran vdout1_207ck80 FIND v(dout1_207) AT=45.025n

.meas tran vdout1_208ck80 FIND v(dout1_208) AT=45.025n

.meas tran vdout1_209ck80 FIND v(dout1_209) AT=45.025n

.meas tran vdout1_210ck80 FIND v(dout1_210) AT=45.025n

.meas tran vdout1_211ck80 FIND v(dout1_211) AT=45.025n

.meas tran vdout1_212ck80 FIND v(dout1_212) AT=45.025n

.meas tran vdout1_213ck80 FIND v(dout1_213) AT=45.025n

.meas tran vdout1_214ck80 FIND v(dout1_214) AT=45.025n

.meas tran vdout1_215ck80 FIND v(dout1_215) AT=45.025n

.meas tran vdout1_216ck80 FIND v(dout1_216) AT=45.025n

.meas tran vdout1_217ck80 FIND v(dout1_217) AT=45.025n

.meas tran vdout1_218ck80 FIND v(dout1_218) AT=45.025n

.meas tran vdout1_219ck80 FIND v(dout1_219) AT=45.025n

.meas tran vdout1_220ck80 FIND v(dout1_220) AT=45.025n

.meas tran vdout1_221ck80 FIND v(dout1_221) AT=45.025n

.meas tran vdout1_222ck80 FIND v(dout1_222) AT=45.025n

.meas tran vdout1_223ck80 FIND v(dout1_223) AT=45.025n

.meas tran vdout1_224ck80 FIND v(dout1_224) AT=45.025n

.meas tran vdout1_225ck80 FIND v(dout1_225) AT=45.025n

.meas tran vdout1_226ck80 FIND v(dout1_226) AT=45.025n

.meas tran vdout1_227ck80 FIND v(dout1_227) AT=45.025n

.meas tran vdout1_228ck80 FIND v(dout1_228) AT=45.025n

.meas tran vdout1_229ck80 FIND v(dout1_229) AT=45.025n

.meas tran vdout1_230ck80 FIND v(dout1_230) AT=45.025n

.meas tran vdout1_231ck80 FIND v(dout1_231) AT=45.025n

.meas tran vdout1_232ck80 FIND v(dout1_232) AT=45.025n

.meas tran vdout1_233ck80 FIND v(dout1_233) AT=45.025n

.meas tran vdout1_234ck80 FIND v(dout1_234) AT=45.025n

.meas tran vdout1_235ck80 FIND v(dout1_235) AT=45.025n

.meas tran vdout1_236ck80 FIND v(dout1_236) AT=45.025n

.meas tran vdout1_237ck80 FIND v(dout1_237) AT=45.025n

.meas tran vdout1_238ck80 FIND v(dout1_238) AT=45.025n

.meas tran vdout1_239ck80 FIND v(dout1_239) AT=45.025n

.meas tran vdout1_240ck80 FIND v(dout1_240) AT=45.025n

.meas tran vdout1_241ck80 FIND v(dout1_241) AT=45.025n

.meas tran vdout1_242ck80 FIND v(dout1_242) AT=45.025n

.meas tran vdout1_243ck80 FIND v(dout1_243) AT=45.025n

.meas tran vdout1_244ck80 FIND v(dout1_244) AT=45.025n

.meas tran vdout1_245ck80 FIND v(dout1_245) AT=45.025n

.meas tran vdout1_246ck80 FIND v(dout1_246) AT=45.025n

.meas tran vdout1_247ck80 FIND v(dout1_247) AT=45.025n

.meas tran vdout1_248ck80 FIND v(dout1_248) AT=45.025n

.meas tran vdout1_249ck80 FIND v(dout1_249) AT=45.025n

.meas tran vdout1_250ck80 FIND v(dout1_250) AT=45.025n

.meas tran vdout1_251ck80 FIND v(dout1_251) AT=45.025n

.meas tran vdout1_252ck80 FIND v(dout1_252) AT=45.025n

.meas tran vdout1_253ck80 FIND v(dout1_253) AT=45.025n

.meas tran vdout1_254ck80 FIND v(dout1_254) AT=45.025n

.meas tran vdout1_255ck80 FIND v(dout1_255) AT=45.025n

.meas tran vdout1_256ck80 FIND v(dout1_256) AT=45.025n

.meas tran vdout1_257ck80 FIND v(dout1_257) AT=45.025n

.meas tran vdout1_258ck80 FIND v(dout1_258) AT=45.025n

.meas tran vdout1_259ck80 FIND v(dout1_259) AT=45.025n

.meas tran vdout1_260ck80 FIND v(dout1_260) AT=45.025n

.meas tran vdout1_261ck80 FIND v(dout1_261) AT=45.025n

.meas tran vdout1_262ck80 FIND v(dout1_262) AT=45.025n

.meas tran vdout1_263ck80 FIND v(dout1_263) AT=45.025n

.meas tran vdout1_264ck80 FIND v(dout1_264) AT=45.025n

.meas tran vdout1_265ck80 FIND v(dout1_265) AT=45.025n

.meas tran vdout1_266ck80 FIND v(dout1_266) AT=45.025n

.meas tran vdout1_267ck80 FIND v(dout1_267) AT=45.025n

.meas tran vdout1_268ck80 FIND v(dout1_268) AT=45.025n

.meas tran vdout1_269ck80 FIND v(dout1_269) AT=45.025n

.meas tran vdout1_270ck80 FIND v(dout1_270) AT=45.025n

.meas tran vdout1_271ck80 FIND v(dout1_271) AT=45.025n

.meas tran vdout1_272ck80 FIND v(dout1_272) AT=45.025n

.meas tran vdout1_273ck80 FIND v(dout1_273) AT=45.025n

.meas tran vdout1_274ck80 FIND v(dout1_274) AT=45.025n

.meas tran vdout1_275ck80 FIND v(dout1_275) AT=45.025n

.meas tran vdout1_276ck80 FIND v(dout1_276) AT=45.025n

.meas tran vdout1_277ck80 FIND v(dout1_277) AT=45.025n

.meas tran vdout1_278ck80 FIND v(dout1_278) AT=45.025n

.meas tran vdout1_279ck80 FIND v(dout1_279) AT=45.025n

.meas tran vdout1_280ck80 FIND v(dout1_280) AT=45.025n

.meas tran vdout1_281ck80 FIND v(dout1_281) AT=45.025n

.meas tran vdout1_282ck80 FIND v(dout1_282) AT=45.025n

.meas tran vdout1_283ck80 FIND v(dout1_283) AT=45.025n

.meas tran vdout1_284ck80 FIND v(dout1_284) AT=45.025n

.meas tran vdout1_285ck80 FIND v(dout1_285) AT=45.025n

.meas tran vdout1_286ck80 FIND v(dout1_286) AT=45.025n

.meas tran vdout1_287ck80 FIND v(dout1_287) AT=45.025n

.meas tran vdout1_288ck80 FIND v(dout1_288) AT=45.025n

.meas tran vdout1_289ck80 FIND v(dout1_289) AT=45.025n

.meas tran vdout1_290ck80 FIND v(dout1_290) AT=45.025n

.meas tran vdout1_291ck80 FIND v(dout1_291) AT=45.025n

.meas tran vdout1_292ck80 FIND v(dout1_292) AT=45.025n

.meas tran vdout1_293ck80 FIND v(dout1_293) AT=45.025n

.meas tran vdout1_294ck80 FIND v(dout1_294) AT=45.025n

.meas tran vdout1_295ck80 FIND v(dout1_295) AT=45.025n

.meas tran vdout1_296ck80 FIND v(dout1_296) AT=45.025n

.meas tran vdout1_297ck80 FIND v(dout1_297) AT=45.025n

.meas tran vdout1_298ck80 FIND v(dout1_298) AT=45.025n

.meas tran vdout1_299ck80 FIND v(dout1_299) AT=45.025n

.meas tran vdout1_300ck80 FIND v(dout1_300) AT=45.025n

.meas tran vdout1_301ck80 FIND v(dout1_301) AT=45.025n

.meas tran vdout1_302ck80 FIND v(dout1_302) AT=45.025n

.meas tran vdout1_303ck80 FIND v(dout1_303) AT=45.025n

.meas tran vdout1_304ck80 FIND v(dout1_304) AT=45.025n

.meas tran vdout1_305ck80 FIND v(dout1_305) AT=45.025n

.meas tran vdout1_306ck80 FIND v(dout1_306) AT=45.025n

.meas tran vdout1_307ck80 FIND v(dout1_307) AT=45.025n

.meas tran vdout1_308ck80 FIND v(dout1_308) AT=45.025n

.meas tran vdout1_309ck80 FIND v(dout1_309) AT=45.025n

.meas tran vdout1_310ck80 FIND v(dout1_310) AT=45.025n

.meas tran vdout1_311ck80 FIND v(dout1_311) AT=45.025n

.meas tran vdout1_312ck80 FIND v(dout1_312) AT=45.025n

.meas tran vdout1_313ck80 FIND v(dout1_313) AT=45.025n

.meas tran vdout1_314ck80 FIND v(dout1_314) AT=45.025n

.meas tran vdout1_315ck80 FIND v(dout1_315) AT=45.025n

.meas tran vdout1_316ck80 FIND v(dout1_316) AT=45.025n

.meas tran vdout1_317ck80 FIND v(dout1_317) AT=45.025n

.meas tran vdout1_318ck80 FIND v(dout1_318) AT=45.025n

.meas tran vdout1_319ck80 FIND v(dout1_319) AT=45.025n

.meas tran vdout1_320ck80 FIND v(dout1_320) AT=45.025n

.meas tran vdout1_321ck80 FIND v(dout1_321) AT=45.025n

.meas tran vdout1_322ck80 FIND v(dout1_322) AT=45.025n

.meas tran vdout1_323ck80 FIND v(dout1_323) AT=45.025n

.meas tran vdout1_324ck80 FIND v(dout1_324) AT=45.025n

.meas tran vdout1_325ck80 FIND v(dout1_325) AT=45.025n

.meas tran vdout1_326ck80 FIND v(dout1_326) AT=45.025n

.meas tran vdout1_327ck80 FIND v(dout1_327) AT=45.025n

.meas tran vdout1_328ck80 FIND v(dout1_328) AT=45.025n

.meas tran vdout1_329ck80 FIND v(dout1_329) AT=45.025n

.meas tran vdout1_330ck80 FIND v(dout1_330) AT=45.025n

.meas tran vdout1_331ck80 FIND v(dout1_331) AT=45.025n

.meas tran vdout1_332ck80 FIND v(dout1_332) AT=45.025n

.meas tran vdout1_333ck80 FIND v(dout1_333) AT=45.025n

.meas tran vdout1_334ck80 FIND v(dout1_334) AT=45.025n

.meas tran vdout1_335ck80 FIND v(dout1_335) AT=45.025n

.meas tran vdout1_336ck80 FIND v(dout1_336) AT=45.025n

.meas tran vdout1_337ck80 FIND v(dout1_337) AT=45.025n

.meas tran vdout1_338ck80 FIND v(dout1_338) AT=45.025n

.meas tran vdout1_339ck80 FIND v(dout1_339) AT=45.025n

.meas tran vdout1_340ck80 FIND v(dout1_340) AT=45.025n

.meas tran vdout1_341ck80 FIND v(dout1_341) AT=45.025n

.meas tran vdout1_342ck80 FIND v(dout1_342) AT=45.025n

.meas tran vdout1_343ck80 FIND v(dout1_343) AT=45.025n

.meas tran vdout1_344ck80 FIND v(dout1_344) AT=45.025n

.meas tran vdout1_345ck80 FIND v(dout1_345) AT=45.025n

.meas tran vdout1_346ck80 FIND v(dout1_346) AT=45.025n

.meas tran vdout1_347ck80 FIND v(dout1_347) AT=45.025n

.meas tran vdout1_348ck80 FIND v(dout1_348) AT=45.025n

.meas tran vdout1_349ck80 FIND v(dout1_349) AT=45.025n

.meas tran vdout1_350ck80 FIND v(dout1_350) AT=45.025n

.meas tran vdout1_351ck80 FIND v(dout1_351) AT=45.025n

.meas tran vdout1_352ck80 FIND v(dout1_352) AT=45.025n

.meas tran vdout1_353ck80 FIND v(dout1_353) AT=45.025n

.meas tran vdout1_354ck80 FIND v(dout1_354) AT=45.025n

.meas tran vdout1_355ck80 FIND v(dout1_355) AT=45.025n

.meas tran vdout1_356ck80 FIND v(dout1_356) AT=45.025n

.meas tran vdout1_357ck80 FIND v(dout1_357) AT=45.025n

.meas tran vdout1_358ck80 FIND v(dout1_358) AT=45.025n

.meas tran vdout1_359ck80 FIND v(dout1_359) AT=45.025n

.meas tran vdout1_360ck80 FIND v(dout1_360) AT=45.025n

.meas tran vdout1_361ck80 FIND v(dout1_361) AT=45.025n

.meas tran vdout1_362ck80 FIND v(dout1_362) AT=45.025n

.meas tran vdout1_363ck80 FIND v(dout1_363) AT=45.025n

.meas tran vdout1_364ck80 FIND v(dout1_364) AT=45.025n

.meas tran vdout1_365ck80 FIND v(dout1_365) AT=45.025n

.meas tran vdout1_366ck80 FIND v(dout1_366) AT=45.025n

.meas tran vdout1_367ck80 FIND v(dout1_367) AT=45.025n

.meas tran vdout1_368ck80 FIND v(dout1_368) AT=45.025n

.meas tran vdout1_369ck80 FIND v(dout1_369) AT=45.025n

.meas tran vdout1_370ck80 FIND v(dout1_370) AT=45.025n

.meas tran vdout1_371ck80 FIND v(dout1_371) AT=45.025n

.meas tran vdout1_372ck80 FIND v(dout1_372) AT=45.025n

.meas tran vdout1_373ck80 FIND v(dout1_373) AT=45.025n

.meas tran vdout1_374ck80 FIND v(dout1_374) AT=45.025n

.meas tran vdout1_375ck80 FIND v(dout1_375) AT=45.025n

.meas tran vdout1_376ck80 FIND v(dout1_376) AT=45.025n

.meas tran vdout1_377ck80 FIND v(dout1_377) AT=45.025n

.meas tran vdout1_378ck80 FIND v(dout1_378) AT=45.025n

.meas tran vdout1_379ck80 FIND v(dout1_379) AT=45.025n

.meas tran vdout1_380ck80 FIND v(dout1_380) AT=45.025n

.meas tran vdout1_381ck80 FIND v(dout1_381) AT=45.025n

.meas tran vdout1_382ck80 FIND v(dout1_382) AT=45.025n

.meas tran vdout1_383ck80 FIND v(dout1_383) AT=45.025n

.meas tran vdout1_384ck80 FIND v(dout1_384) AT=45.025n

.meas tran vdout1_385ck80 FIND v(dout1_385) AT=45.025n

.meas tran vdout1_386ck80 FIND v(dout1_386) AT=45.025n

.meas tran vdout1_387ck80 FIND v(dout1_387) AT=45.025n

.meas tran vdout1_388ck80 FIND v(dout1_388) AT=45.025n

.meas tran vdout1_389ck80 FIND v(dout1_389) AT=45.025n

.meas tran vdout1_390ck80 FIND v(dout1_390) AT=45.025n

.meas tran vdout1_391ck80 FIND v(dout1_391) AT=45.025n

.meas tran vdout1_392ck80 FIND v(dout1_392) AT=45.025n

.meas tran vdout1_393ck80 FIND v(dout1_393) AT=45.025n

.meas tran vdout1_394ck80 FIND v(dout1_394) AT=45.025n

.meas tran vdout1_395ck80 FIND v(dout1_395) AT=45.025n

.meas tran vdout1_396ck80 FIND v(dout1_396) AT=45.025n

.meas tran vdout1_397ck80 FIND v(dout1_397) AT=45.025n

.meas tran vdout1_398ck80 FIND v(dout1_398) AT=45.025n

.meas tran vdout1_399ck80 FIND v(dout1_399) AT=45.025n

.meas tran vdout1_400ck80 FIND v(dout1_400) AT=45.025n

.meas tran vdout1_401ck80 FIND v(dout1_401) AT=45.025n

.meas tran vdout1_402ck80 FIND v(dout1_402) AT=45.025n

.meas tran vdout1_403ck80 FIND v(dout1_403) AT=45.025n

.meas tran vdout1_404ck80 FIND v(dout1_404) AT=45.025n

.meas tran vdout1_405ck80 FIND v(dout1_405) AT=45.025n

.meas tran vdout1_406ck80 FIND v(dout1_406) AT=45.025n

.meas tran vdout1_407ck80 FIND v(dout1_407) AT=45.025n

.meas tran vdout1_408ck80 FIND v(dout1_408) AT=45.025n

.meas tran vdout1_409ck80 FIND v(dout1_409) AT=45.025n

.meas tran vdout1_410ck80 FIND v(dout1_410) AT=45.025n

.meas tran vdout1_411ck80 FIND v(dout1_411) AT=45.025n

.meas tran vdout1_412ck80 FIND v(dout1_412) AT=45.025n

.meas tran vdout1_413ck80 FIND v(dout1_413) AT=45.025n

.meas tran vdout1_414ck80 FIND v(dout1_414) AT=45.025n

.meas tran vdout1_415ck80 FIND v(dout1_415) AT=45.025n

.meas tran vdout1_416ck80 FIND v(dout1_416) AT=45.025n

.meas tran vdout1_417ck80 FIND v(dout1_417) AT=45.025n

.meas tran vdout1_418ck80 FIND v(dout1_418) AT=45.025n

.meas tran vdout1_419ck80 FIND v(dout1_419) AT=45.025n

.meas tran vdout1_420ck80 FIND v(dout1_420) AT=45.025n

.meas tran vdout1_421ck80 FIND v(dout1_421) AT=45.025n

.meas tran vdout1_422ck80 FIND v(dout1_422) AT=45.025n

.meas tran vdout1_423ck80 FIND v(dout1_423) AT=45.025n

.meas tran vdout1_424ck80 FIND v(dout1_424) AT=45.025n

.meas tran vdout1_425ck80 FIND v(dout1_425) AT=45.025n

.meas tran vdout1_426ck80 FIND v(dout1_426) AT=45.025n

.meas tran vdout1_427ck80 FIND v(dout1_427) AT=45.025n

.meas tran vdout1_428ck80 FIND v(dout1_428) AT=45.025n

.meas tran vdout1_429ck80 FIND v(dout1_429) AT=45.025n

.meas tran vdout1_430ck80 FIND v(dout1_430) AT=45.025n

.meas tran vdout1_431ck80 FIND v(dout1_431) AT=45.025n

.meas tran vdout1_432ck80 FIND v(dout1_432) AT=45.025n

.meas tran vdout1_433ck80 FIND v(dout1_433) AT=45.025n

.meas tran vdout1_434ck80 FIND v(dout1_434) AT=45.025n

.meas tran vdout1_435ck80 FIND v(dout1_435) AT=45.025n

.meas tran vdout1_436ck80 FIND v(dout1_436) AT=45.025n

.meas tran vdout1_437ck80 FIND v(dout1_437) AT=45.025n

.meas tran vdout1_438ck80 FIND v(dout1_438) AT=45.025n

.meas tran vdout1_439ck80 FIND v(dout1_439) AT=45.025n

.meas tran vdout1_440ck80 FIND v(dout1_440) AT=45.025n

.meas tran vdout1_441ck80 FIND v(dout1_441) AT=45.025n

.meas tran vdout1_442ck80 FIND v(dout1_442) AT=45.025n

.meas tran vdout1_443ck80 FIND v(dout1_443) AT=45.025n

.meas tran vdout1_444ck80 FIND v(dout1_444) AT=45.025n

.meas tran vdout1_445ck80 FIND v(dout1_445) AT=45.025n

.meas tran vdout1_446ck80 FIND v(dout1_446) AT=45.025n

.meas tran vdout1_447ck80 FIND v(dout1_447) AT=45.025n

.meas tran vdout1_448ck80 FIND v(dout1_448) AT=45.025n

.meas tran vdout1_449ck80 FIND v(dout1_449) AT=45.025n

.meas tran vdout1_450ck80 FIND v(dout1_450) AT=45.025n

.meas tran vdout1_451ck80 FIND v(dout1_451) AT=45.025n

.meas tran vdout1_452ck80 FIND v(dout1_452) AT=45.025n

.meas tran vdout1_453ck80 FIND v(dout1_453) AT=45.025n

.meas tran vdout1_454ck80 FIND v(dout1_454) AT=45.025n

.meas tran vdout1_455ck80 FIND v(dout1_455) AT=45.025n

.meas tran vdout1_456ck80 FIND v(dout1_456) AT=45.025n

.meas tran vdout1_457ck80 FIND v(dout1_457) AT=45.025n

.meas tran vdout1_458ck80 FIND v(dout1_458) AT=45.025n

.meas tran vdout1_459ck80 FIND v(dout1_459) AT=45.025n

.meas tran vdout1_460ck80 FIND v(dout1_460) AT=45.025n

.meas tran vdout1_461ck80 FIND v(dout1_461) AT=45.025n

.meas tran vdout1_462ck80 FIND v(dout1_462) AT=45.025n

.meas tran vdout1_463ck80 FIND v(dout1_463) AT=45.025n

.meas tran vdout1_464ck80 FIND v(dout1_464) AT=45.025n

.meas tran vdout1_465ck80 FIND v(dout1_465) AT=45.025n

.meas tran vdout1_466ck80 FIND v(dout1_466) AT=45.025n

.meas tran vdout1_467ck80 FIND v(dout1_467) AT=45.025n

.meas tran vdout1_468ck80 FIND v(dout1_468) AT=45.025n

.meas tran vdout1_469ck80 FIND v(dout1_469) AT=45.025n

.meas tran vdout1_470ck80 FIND v(dout1_470) AT=45.025n

.meas tran vdout1_471ck80 FIND v(dout1_471) AT=45.025n

.meas tran vdout1_472ck80 FIND v(dout1_472) AT=45.025n

.meas tran vdout1_473ck80 FIND v(dout1_473) AT=45.025n

.meas tran vdout1_474ck80 FIND v(dout1_474) AT=45.025n

.meas tran vdout1_475ck80 FIND v(dout1_475) AT=45.025n

.meas tran vdout1_476ck80 FIND v(dout1_476) AT=45.025n

.meas tran vdout1_477ck80 FIND v(dout1_477) AT=45.025n

.meas tran vdout1_478ck80 FIND v(dout1_478) AT=45.025n

.meas tran vdout1_479ck80 FIND v(dout1_479) AT=45.025n

.meas tran vdout1_480ck80 FIND v(dout1_480) AT=45.025n

.meas tran vdout1_481ck80 FIND v(dout1_481) AT=45.025n

.meas tran vdout1_482ck80 FIND v(dout1_482) AT=45.025n

.meas tran vdout1_483ck80 FIND v(dout1_483) AT=45.025n

.meas tran vdout1_484ck80 FIND v(dout1_484) AT=45.025n

.meas tran vdout1_485ck80 FIND v(dout1_485) AT=45.025n

.meas tran vdout1_486ck80 FIND v(dout1_486) AT=45.025n

.meas tran vdout1_487ck80 FIND v(dout1_487) AT=45.025n

.meas tran vdout1_488ck80 FIND v(dout1_488) AT=45.025n

.meas tran vdout1_489ck80 FIND v(dout1_489) AT=45.025n

.meas tran vdout1_490ck80 FIND v(dout1_490) AT=45.025n

.meas tran vdout1_491ck80 FIND v(dout1_491) AT=45.025n

.meas tran vdout1_492ck80 FIND v(dout1_492) AT=45.025n

.meas tran vdout1_493ck80 FIND v(dout1_493) AT=45.025n

.meas tran vdout1_494ck80 FIND v(dout1_494) AT=45.025n

.meas tran vdout1_495ck80 FIND v(dout1_495) AT=45.025n

.meas tran vdout1_496ck80 FIND v(dout1_496) AT=45.025n

.meas tran vdout1_497ck80 FIND v(dout1_497) AT=45.025n

.meas tran vdout1_498ck80 FIND v(dout1_498) AT=45.025n

.meas tran vdout1_499ck80 FIND v(dout1_499) AT=45.025n

.meas tran vdout1_500ck80 FIND v(dout1_500) AT=45.025n

.meas tran vdout1_501ck80 FIND v(dout1_501) AT=45.025n

.meas tran vdout1_502ck80 FIND v(dout1_502) AT=45.025n

.meas tran vdout1_503ck80 FIND v(dout1_503) AT=45.025n

.meas tran vdout1_504ck80 FIND v(dout1_504) AT=45.025n

.meas tran vdout1_505ck80 FIND v(dout1_505) AT=45.025n

.meas tran vdout1_506ck80 FIND v(dout1_506) AT=45.025n

.meas tran vdout1_507ck80 FIND v(dout1_507) AT=45.025n

.meas tran vdout1_508ck80 FIND v(dout1_508) AT=45.025n

.meas tran vdout1_509ck80 FIND v(dout1_509) AT=45.025n

.meas tran vdout1_510ck80 FIND v(dout1_510) AT=45.025n

.meas tran vdout1_511ck80 FIND v(dout1_511) AT=45.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_17ck100 FIND v(dout1_17) AT=55.025n

.meas tran vdout1_18ck100 FIND v(dout1_18) AT=55.025n

.meas tran vdout1_19ck100 FIND v(dout1_19) AT=55.025n

.meas tran vdout1_20ck100 FIND v(dout1_20) AT=55.025n

.meas tran vdout1_21ck100 FIND v(dout1_21) AT=55.025n

.meas tran vdout1_22ck100 FIND v(dout1_22) AT=55.025n

.meas tran vdout1_23ck100 FIND v(dout1_23) AT=55.025n

.meas tran vdout1_24ck100 FIND v(dout1_24) AT=55.025n

.meas tran vdout1_25ck100 FIND v(dout1_25) AT=55.025n

.meas tran vdout1_26ck100 FIND v(dout1_26) AT=55.025n

.meas tran vdout1_27ck100 FIND v(dout1_27) AT=55.025n

.meas tran vdout1_28ck100 FIND v(dout1_28) AT=55.025n

.meas tran vdout1_29ck100 FIND v(dout1_29) AT=55.025n

.meas tran vdout1_30ck100 FIND v(dout1_30) AT=55.025n

.meas tran vdout1_31ck100 FIND v(dout1_31) AT=55.025n

.meas tran vdout1_32ck100 FIND v(dout1_32) AT=55.025n

.meas tran vdout1_33ck100 FIND v(dout1_33) AT=55.025n

.meas tran vdout1_34ck100 FIND v(dout1_34) AT=55.025n

.meas tran vdout1_35ck100 FIND v(dout1_35) AT=55.025n

.meas tran vdout1_36ck100 FIND v(dout1_36) AT=55.025n

.meas tran vdout1_37ck100 FIND v(dout1_37) AT=55.025n

.meas tran vdout1_38ck100 FIND v(dout1_38) AT=55.025n

.meas tran vdout1_39ck100 FIND v(dout1_39) AT=55.025n

.meas tran vdout1_40ck100 FIND v(dout1_40) AT=55.025n

.meas tran vdout1_41ck100 FIND v(dout1_41) AT=55.025n

.meas tran vdout1_42ck100 FIND v(dout1_42) AT=55.025n

.meas tran vdout1_43ck100 FIND v(dout1_43) AT=55.025n

.meas tran vdout1_44ck100 FIND v(dout1_44) AT=55.025n

.meas tran vdout1_45ck100 FIND v(dout1_45) AT=55.025n

.meas tran vdout1_46ck100 FIND v(dout1_46) AT=55.025n

.meas tran vdout1_47ck100 FIND v(dout1_47) AT=55.025n

.meas tran vdout1_48ck100 FIND v(dout1_48) AT=55.025n

.meas tran vdout1_49ck100 FIND v(dout1_49) AT=55.025n

.meas tran vdout1_50ck100 FIND v(dout1_50) AT=55.025n

.meas tran vdout1_51ck100 FIND v(dout1_51) AT=55.025n

.meas tran vdout1_52ck100 FIND v(dout1_52) AT=55.025n

.meas tran vdout1_53ck100 FIND v(dout1_53) AT=55.025n

.meas tran vdout1_54ck100 FIND v(dout1_54) AT=55.025n

.meas tran vdout1_55ck100 FIND v(dout1_55) AT=55.025n

.meas tran vdout1_56ck100 FIND v(dout1_56) AT=55.025n

.meas tran vdout1_57ck100 FIND v(dout1_57) AT=55.025n

.meas tran vdout1_58ck100 FIND v(dout1_58) AT=55.025n

.meas tran vdout1_59ck100 FIND v(dout1_59) AT=55.025n

.meas tran vdout1_60ck100 FIND v(dout1_60) AT=55.025n

.meas tran vdout1_61ck100 FIND v(dout1_61) AT=55.025n

.meas tran vdout1_62ck100 FIND v(dout1_62) AT=55.025n

.meas tran vdout1_63ck100 FIND v(dout1_63) AT=55.025n

.meas tran vdout1_64ck100 FIND v(dout1_64) AT=55.025n

.meas tran vdout1_65ck100 FIND v(dout1_65) AT=55.025n

.meas tran vdout1_66ck100 FIND v(dout1_66) AT=55.025n

.meas tran vdout1_67ck100 FIND v(dout1_67) AT=55.025n

.meas tran vdout1_68ck100 FIND v(dout1_68) AT=55.025n

.meas tran vdout1_69ck100 FIND v(dout1_69) AT=55.025n

.meas tran vdout1_70ck100 FIND v(dout1_70) AT=55.025n

.meas tran vdout1_71ck100 FIND v(dout1_71) AT=55.025n

.meas tran vdout1_72ck100 FIND v(dout1_72) AT=55.025n

.meas tran vdout1_73ck100 FIND v(dout1_73) AT=55.025n

.meas tran vdout1_74ck100 FIND v(dout1_74) AT=55.025n

.meas tran vdout1_75ck100 FIND v(dout1_75) AT=55.025n

.meas tran vdout1_76ck100 FIND v(dout1_76) AT=55.025n

.meas tran vdout1_77ck100 FIND v(dout1_77) AT=55.025n

.meas tran vdout1_78ck100 FIND v(dout1_78) AT=55.025n

.meas tran vdout1_79ck100 FIND v(dout1_79) AT=55.025n

.meas tran vdout1_80ck100 FIND v(dout1_80) AT=55.025n

.meas tran vdout1_81ck100 FIND v(dout1_81) AT=55.025n

.meas tran vdout1_82ck100 FIND v(dout1_82) AT=55.025n

.meas tran vdout1_83ck100 FIND v(dout1_83) AT=55.025n

.meas tran vdout1_84ck100 FIND v(dout1_84) AT=55.025n

.meas tran vdout1_85ck100 FIND v(dout1_85) AT=55.025n

.meas tran vdout1_86ck100 FIND v(dout1_86) AT=55.025n

.meas tran vdout1_87ck100 FIND v(dout1_87) AT=55.025n

.meas tran vdout1_88ck100 FIND v(dout1_88) AT=55.025n

.meas tran vdout1_89ck100 FIND v(dout1_89) AT=55.025n

.meas tran vdout1_90ck100 FIND v(dout1_90) AT=55.025n

.meas tran vdout1_91ck100 FIND v(dout1_91) AT=55.025n

.meas tran vdout1_92ck100 FIND v(dout1_92) AT=55.025n

.meas tran vdout1_93ck100 FIND v(dout1_93) AT=55.025n

.meas tran vdout1_94ck100 FIND v(dout1_94) AT=55.025n

.meas tran vdout1_95ck100 FIND v(dout1_95) AT=55.025n

.meas tran vdout1_96ck100 FIND v(dout1_96) AT=55.025n

.meas tran vdout1_97ck100 FIND v(dout1_97) AT=55.025n

.meas tran vdout1_98ck100 FIND v(dout1_98) AT=55.025n

.meas tran vdout1_99ck100 FIND v(dout1_99) AT=55.025n

.meas tran vdout1_100ck100 FIND v(dout1_100) AT=55.025n

.meas tran vdout1_101ck100 FIND v(dout1_101) AT=55.025n

.meas tran vdout1_102ck100 FIND v(dout1_102) AT=55.025n

.meas tran vdout1_103ck100 FIND v(dout1_103) AT=55.025n

.meas tran vdout1_104ck100 FIND v(dout1_104) AT=55.025n

.meas tran vdout1_105ck100 FIND v(dout1_105) AT=55.025n

.meas tran vdout1_106ck100 FIND v(dout1_106) AT=55.025n

.meas tran vdout1_107ck100 FIND v(dout1_107) AT=55.025n

.meas tran vdout1_108ck100 FIND v(dout1_108) AT=55.025n

.meas tran vdout1_109ck100 FIND v(dout1_109) AT=55.025n

.meas tran vdout1_110ck100 FIND v(dout1_110) AT=55.025n

.meas tran vdout1_111ck100 FIND v(dout1_111) AT=55.025n

.meas tran vdout1_112ck100 FIND v(dout1_112) AT=55.025n

.meas tran vdout1_113ck100 FIND v(dout1_113) AT=55.025n

.meas tran vdout1_114ck100 FIND v(dout1_114) AT=55.025n

.meas tran vdout1_115ck100 FIND v(dout1_115) AT=55.025n

.meas tran vdout1_116ck100 FIND v(dout1_116) AT=55.025n

.meas tran vdout1_117ck100 FIND v(dout1_117) AT=55.025n

.meas tran vdout1_118ck100 FIND v(dout1_118) AT=55.025n

.meas tran vdout1_119ck100 FIND v(dout1_119) AT=55.025n

.meas tran vdout1_120ck100 FIND v(dout1_120) AT=55.025n

.meas tran vdout1_121ck100 FIND v(dout1_121) AT=55.025n

.meas tran vdout1_122ck100 FIND v(dout1_122) AT=55.025n

.meas tran vdout1_123ck100 FIND v(dout1_123) AT=55.025n

.meas tran vdout1_124ck100 FIND v(dout1_124) AT=55.025n

.meas tran vdout1_125ck100 FIND v(dout1_125) AT=55.025n

.meas tran vdout1_126ck100 FIND v(dout1_126) AT=55.025n

.meas tran vdout1_127ck100 FIND v(dout1_127) AT=55.025n

.meas tran vdout1_128ck100 FIND v(dout1_128) AT=55.025n

.meas tran vdout1_129ck100 FIND v(dout1_129) AT=55.025n

.meas tran vdout1_130ck100 FIND v(dout1_130) AT=55.025n

.meas tran vdout1_131ck100 FIND v(dout1_131) AT=55.025n

.meas tran vdout1_132ck100 FIND v(dout1_132) AT=55.025n

.meas tran vdout1_133ck100 FIND v(dout1_133) AT=55.025n

.meas tran vdout1_134ck100 FIND v(dout1_134) AT=55.025n

.meas tran vdout1_135ck100 FIND v(dout1_135) AT=55.025n

.meas tran vdout1_136ck100 FIND v(dout1_136) AT=55.025n

.meas tran vdout1_137ck100 FIND v(dout1_137) AT=55.025n

.meas tran vdout1_138ck100 FIND v(dout1_138) AT=55.025n

.meas tran vdout1_139ck100 FIND v(dout1_139) AT=55.025n

.meas tran vdout1_140ck100 FIND v(dout1_140) AT=55.025n

.meas tran vdout1_141ck100 FIND v(dout1_141) AT=55.025n

.meas tran vdout1_142ck100 FIND v(dout1_142) AT=55.025n

.meas tran vdout1_143ck100 FIND v(dout1_143) AT=55.025n

.meas tran vdout1_144ck100 FIND v(dout1_144) AT=55.025n

.meas tran vdout1_145ck100 FIND v(dout1_145) AT=55.025n

.meas tran vdout1_146ck100 FIND v(dout1_146) AT=55.025n

.meas tran vdout1_147ck100 FIND v(dout1_147) AT=55.025n

.meas tran vdout1_148ck100 FIND v(dout1_148) AT=55.025n

.meas tran vdout1_149ck100 FIND v(dout1_149) AT=55.025n

.meas tran vdout1_150ck100 FIND v(dout1_150) AT=55.025n

.meas tran vdout1_151ck100 FIND v(dout1_151) AT=55.025n

.meas tran vdout1_152ck100 FIND v(dout1_152) AT=55.025n

.meas tran vdout1_153ck100 FIND v(dout1_153) AT=55.025n

.meas tran vdout1_154ck100 FIND v(dout1_154) AT=55.025n

.meas tran vdout1_155ck100 FIND v(dout1_155) AT=55.025n

.meas tran vdout1_156ck100 FIND v(dout1_156) AT=55.025n

.meas tran vdout1_157ck100 FIND v(dout1_157) AT=55.025n

.meas tran vdout1_158ck100 FIND v(dout1_158) AT=55.025n

.meas tran vdout1_159ck100 FIND v(dout1_159) AT=55.025n

.meas tran vdout1_160ck100 FIND v(dout1_160) AT=55.025n

.meas tran vdout1_161ck100 FIND v(dout1_161) AT=55.025n

.meas tran vdout1_162ck100 FIND v(dout1_162) AT=55.025n

.meas tran vdout1_163ck100 FIND v(dout1_163) AT=55.025n

.meas tran vdout1_164ck100 FIND v(dout1_164) AT=55.025n

.meas tran vdout1_165ck100 FIND v(dout1_165) AT=55.025n

.meas tran vdout1_166ck100 FIND v(dout1_166) AT=55.025n

.meas tran vdout1_167ck100 FIND v(dout1_167) AT=55.025n

.meas tran vdout1_168ck100 FIND v(dout1_168) AT=55.025n

.meas tran vdout1_169ck100 FIND v(dout1_169) AT=55.025n

.meas tran vdout1_170ck100 FIND v(dout1_170) AT=55.025n

.meas tran vdout1_171ck100 FIND v(dout1_171) AT=55.025n

.meas tran vdout1_172ck100 FIND v(dout1_172) AT=55.025n

.meas tran vdout1_173ck100 FIND v(dout1_173) AT=55.025n

.meas tran vdout1_174ck100 FIND v(dout1_174) AT=55.025n

.meas tran vdout1_175ck100 FIND v(dout1_175) AT=55.025n

.meas tran vdout1_176ck100 FIND v(dout1_176) AT=55.025n

.meas tran vdout1_177ck100 FIND v(dout1_177) AT=55.025n

.meas tran vdout1_178ck100 FIND v(dout1_178) AT=55.025n

.meas tran vdout1_179ck100 FIND v(dout1_179) AT=55.025n

.meas tran vdout1_180ck100 FIND v(dout1_180) AT=55.025n

.meas tran vdout1_181ck100 FIND v(dout1_181) AT=55.025n

.meas tran vdout1_182ck100 FIND v(dout1_182) AT=55.025n

.meas tran vdout1_183ck100 FIND v(dout1_183) AT=55.025n

.meas tran vdout1_184ck100 FIND v(dout1_184) AT=55.025n

.meas tran vdout1_185ck100 FIND v(dout1_185) AT=55.025n

.meas tran vdout1_186ck100 FIND v(dout1_186) AT=55.025n

.meas tran vdout1_187ck100 FIND v(dout1_187) AT=55.025n

.meas tran vdout1_188ck100 FIND v(dout1_188) AT=55.025n

.meas tran vdout1_189ck100 FIND v(dout1_189) AT=55.025n

.meas tran vdout1_190ck100 FIND v(dout1_190) AT=55.025n

.meas tran vdout1_191ck100 FIND v(dout1_191) AT=55.025n

.meas tran vdout1_192ck100 FIND v(dout1_192) AT=55.025n

.meas tran vdout1_193ck100 FIND v(dout1_193) AT=55.025n

.meas tran vdout1_194ck100 FIND v(dout1_194) AT=55.025n

.meas tran vdout1_195ck100 FIND v(dout1_195) AT=55.025n

.meas tran vdout1_196ck100 FIND v(dout1_196) AT=55.025n

.meas tran vdout1_197ck100 FIND v(dout1_197) AT=55.025n

.meas tran vdout1_198ck100 FIND v(dout1_198) AT=55.025n

.meas tran vdout1_199ck100 FIND v(dout1_199) AT=55.025n

.meas tran vdout1_200ck100 FIND v(dout1_200) AT=55.025n

.meas tran vdout1_201ck100 FIND v(dout1_201) AT=55.025n

.meas tran vdout1_202ck100 FIND v(dout1_202) AT=55.025n

.meas tran vdout1_203ck100 FIND v(dout1_203) AT=55.025n

.meas tran vdout1_204ck100 FIND v(dout1_204) AT=55.025n

.meas tran vdout1_205ck100 FIND v(dout1_205) AT=55.025n

.meas tran vdout1_206ck100 FIND v(dout1_206) AT=55.025n

.meas tran vdout1_207ck100 FIND v(dout1_207) AT=55.025n

.meas tran vdout1_208ck100 FIND v(dout1_208) AT=55.025n

.meas tran vdout1_209ck100 FIND v(dout1_209) AT=55.025n

.meas tran vdout1_210ck100 FIND v(dout1_210) AT=55.025n

.meas tran vdout1_211ck100 FIND v(dout1_211) AT=55.025n

.meas tran vdout1_212ck100 FIND v(dout1_212) AT=55.025n

.meas tran vdout1_213ck100 FIND v(dout1_213) AT=55.025n

.meas tran vdout1_214ck100 FIND v(dout1_214) AT=55.025n

.meas tran vdout1_215ck100 FIND v(dout1_215) AT=55.025n

.meas tran vdout1_216ck100 FIND v(dout1_216) AT=55.025n

.meas tran vdout1_217ck100 FIND v(dout1_217) AT=55.025n

.meas tran vdout1_218ck100 FIND v(dout1_218) AT=55.025n

.meas tran vdout1_219ck100 FIND v(dout1_219) AT=55.025n

.meas tran vdout1_220ck100 FIND v(dout1_220) AT=55.025n

.meas tran vdout1_221ck100 FIND v(dout1_221) AT=55.025n

.meas tran vdout1_222ck100 FIND v(dout1_222) AT=55.025n

.meas tran vdout1_223ck100 FIND v(dout1_223) AT=55.025n

.meas tran vdout1_224ck100 FIND v(dout1_224) AT=55.025n

.meas tran vdout1_225ck100 FIND v(dout1_225) AT=55.025n

.meas tran vdout1_226ck100 FIND v(dout1_226) AT=55.025n

.meas tran vdout1_227ck100 FIND v(dout1_227) AT=55.025n

.meas tran vdout1_228ck100 FIND v(dout1_228) AT=55.025n

.meas tran vdout1_229ck100 FIND v(dout1_229) AT=55.025n

.meas tran vdout1_230ck100 FIND v(dout1_230) AT=55.025n

.meas tran vdout1_231ck100 FIND v(dout1_231) AT=55.025n

.meas tran vdout1_232ck100 FIND v(dout1_232) AT=55.025n

.meas tran vdout1_233ck100 FIND v(dout1_233) AT=55.025n

.meas tran vdout1_234ck100 FIND v(dout1_234) AT=55.025n

.meas tran vdout1_235ck100 FIND v(dout1_235) AT=55.025n

.meas tran vdout1_236ck100 FIND v(dout1_236) AT=55.025n

.meas tran vdout1_237ck100 FIND v(dout1_237) AT=55.025n

.meas tran vdout1_238ck100 FIND v(dout1_238) AT=55.025n

.meas tran vdout1_239ck100 FIND v(dout1_239) AT=55.025n

.meas tran vdout1_240ck100 FIND v(dout1_240) AT=55.025n

.meas tran vdout1_241ck100 FIND v(dout1_241) AT=55.025n

.meas tran vdout1_242ck100 FIND v(dout1_242) AT=55.025n

.meas tran vdout1_243ck100 FIND v(dout1_243) AT=55.025n

.meas tran vdout1_244ck100 FIND v(dout1_244) AT=55.025n

.meas tran vdout1_245ck100 FIND v(dout1_245) AT=55.025n

.meas tran vdout1_246ck100 FIND v(dout1_246) AT=55.025n

.meas tran vdout1_247ck100 FIND v(dout1_247) AT=55.025n

.meas tran vdout1_248ck100 FIND v(dout1_248) AT=55.025n

.meas tran vdout1_249ck100 FIND v(dout1_249) AT=55.025n

.meas tran vdout1_250ck100 FIND v(dout1_250) AT=55.025n

.meas tran vdout1_251ck100 FIND v(dout1_251) AT=55.025n

.meas tran vdout1_252ck100 FIND v(dout1_252) AT=55.025n

.meas tran vdout1_253ck100 FIND v(dout1_253) AT=55.025n

.meas tran vdout1_254ck100 FIND v(dout1_254) AT=55.025n

.meas tran vdout1_255ck100 FIND v(dout1_255) AT=55.025n

.meas tran vdout1_256ck100 FIND v(dout1_256) AT=55.025n

.meas tran vdout1_257ck100 FIND v(dout1_257) AT=55.025n

.meas tran vdout1_258ck100 FIND v(dout1_258) AT=55.025n

.meas tran vdout1_259ck100 FIND v(dout1_259) AT=55.025n

.meas tran vdout1_260ck100 FIND v(dout1_260) AT=55.025n

.meas tran vdout1_261ck100 FIND v(dout1_261) AT=55.025n

.meas tran vdout1_262ck100 FIND v(dout1_262) AT=55.025n

.meas tran vdout1_263ck100 FIND v(dout1_263) AT=55.025n

.meas tran vdout1_264ck100 FIND v(dout1_264) AT=55.025n

.meas tran vdout1_265ck100 FIND v(dout1_265) AT=55.025n

.meas tran vdout1_266ck100 FIND v(dout1_266) AT=55.025n

.meas tran vdout1_267ck100 FIND v(dout1_267) AT=55.025n

.meas tran vdout1_268ck100 FIND v(dout1_268) AT=55.025n

.meas tran vdout1_269ck100 FIND v(dout1_269) AT=55.025n

.meas tran vdout1_270ck100 FIND v(dout1_270) AT=55.025n

.meas tran vdout1_271ck100 FIND v(dout1_271) AT=55.025n

.meas tran vdout1_272ck100 FIND v(dout1_272) AT=55.025n

.meas tran vdout1_273ck100 FIND v(dout1_273) AT=55.025n

.meas tran vdout1_274ck100 FIND v(dout1_274) AT=55.025n

.meas tran vdout1_275ck100 FIND v(dout1_275) AT=55.025n

.meas tran vdout1_276ck100 FIND v(dout1_276) AT=55.025n

.meas tran vdout1_277ck100 FIND v(dout1_277) AT=55.025n

.meas tran vdout1_278ck100 FIND v(dout1_278) AT=55.025n

.meas tran vdout1_279ck100 FIND v(dout1_279) AT=55.025n

.meas tran vdout1_280ck100 FIND v(dout1_280) AT=55.025n

.meas tran vdout1_281ck100 FIND v(dout1_281) AT=55.025n

.meas tran vdout1_282ck100 FIND v(dout1_282) AT=55.025n

.meas tran vdout1_283ck100 FIND v(dout1_283) AT=55.025n

.meas tran vdout1_284ck100 FIND v(dout1_284) AT=55.025n

.meas tran vdout1_285ck100 FIND v(dout1_285) AT=55.025n

.meas tran vdout1_286ck100 FIND v(dout1_286) AT=55.025n

.meas tran vdout1_287ck100 FIND v(dout1_287) AT=55.025n

.meas tran vdout1_288ck100 FIND v(dout1_288) AT=55.025n

.meas tran vdout1_289ck100 FIND v(dout1_289) AT=55.025n

.meas tran vdout1_290ck100 FIND v(dout1_290) AT=55.025n

.meas tran vdout1_291ck100 FIND v(dout1_291) AT=55.025n

.meas tran vdout1_292ck100 FIND v(dout1_292) AT=55.025n

.meas tran vdout1_293ck100 FIND v(dout1_293) AT=55.025n

.meas tran vdout1_294ck100 FIND v(dout1_294) AT=55.025n

.meas tran vdout1_295ck100 FIND v(dout1_295) AT=55.025n

.meas tran vdout1_296ck100 FIND v(dout1_296) AT=55.025n

.meas tran vdout1_297ck100 FIND v(dout1_297) AT=55.025n

.meas tran vdout1_298ck100 FIND v(dout1_298) AT=55.025n

.meas tran vdout1_299ck100 FIND v(dout1_299) AT=55.025n

.meas tran vdout1_300ck100 FIND v(dout1_300) AT=55.025n

.meas tran vdout1_301ck100 FIND v(dout1_301) AT=55.025n

.meas tran vdout1_302ck100 FIND v(dout1_302) AT=55.025n

.meas tran vdout1_303ck100 FIND v(dout1_303) AT=55.025n

.meas tran vdout1_304ck100 FIND v(dout1_304) AT=55.025n

.meas tran vdout1_305ck100 FIND v(dout1_305) AT=55.025n

.meas tran vdout1_306ck100 FIND v(dout1_306) AT=55.025n

.meas tran vdout1_307ck100 FIND v(dout1_307) AT=55.025n

.meas tran vdout1_308ck100 FIND v(dout1_308) AT=55.025n

.meas tran vdout1_309ck100 FIND v(dout1_309) AT=55.025n

.meas tran vdout1_310ck100 FIND v(dout1_310) AT=55.025n

.meas tran vdout1_311ck100 FIND v(dout1_311) AT=55.025n

.meas tran vdout1_312ck100 FIND v(dout1_312) AT=55.025n

.meas tran vdout1_313ck100 FIND v(dout1_313) AT=55.025n

.meas tran vdout1_314ck100 FIND v(dout1_314) AT=55.025n

.meas tran vdout1_315ck100 FIND v(dout1_315) AT=55.025n

.meas tran vdout1_316ck100 FIND v(dout1_316) AT=55.025n

.meas tran vdout1_317ck100 FIND v(dout1_317) AT=55.025n

.meas tran vdout1_318ck100 FIND v(dout1_318) AT=55.025n

.meas tran vdout1_319ck100 FIND v(dout1_319) AT=55.025n

.meas tran vdout1_320ck100 FIND v(dout1_320) AT=55.025n

.meas tran vdout1_321ck100 FIND v(dout1_321) AT=55.025n

.meas tran vdout1_322ck100 FIND v(dout1_322) AT=55.025n

.meas tran vdout1_323ck100 FIND v(dout1_323) AT=55.025n

.meas tran vdout1_324ck100 FIND v(dout1_324) AT=55.025n

.meas tran vdout1_325ck100 FIND v(dout1_325) AT=55.025n

.meas tran vdout1_326ck100 FIND v(dout1_326) AT=55.025n

.meas tran vdout1_327ck100 FIND v(dout1_327) AT=55.025n

.meas tran vdout1_328ck100 FIND v(dout1_328) AT=55.025n

.meas tran vdout1_329ck100 FIND v(dout1_329) AT=55.025n

.meas tran vdout1_330ck100 FIND v(dout1_330) AT=55.025n

.meas tran vdout1_331ck100 FIND v(dout1_331) AT=55.025n

.meas tran vdout1_332ck100 FIND v(dout1_332) AT=55.025n

.meas tran vdout1_333ck100 FIND v(dout1_333) AT=55.025n

.meas tran vdout1_334ck100 FIND v(dout1_334) AT=55.025n

.meas tran vdout1_335ck100 FIND v(dout1_335) AT=55.025n

.meas tran vdout1_336ck100 FIND v(dout1_336) AT=55.025n

.meas tran vdout1_337ck100 FIND v(dout1_337) AT=55.025n

.meas tran vdout1_338ck100 FIND v(dout1_338) AT=55.025n

.meas tran vdout1_339ck100 FIND v(dout1_339) AT=55.025n

.meas tran vdout1_340ck100 FIND v(dout1_340) AT=55.025n

.meas tran vdout1_341ck100 FIND v(dout1_341) AT=55.025n

.meas tran vdout1_342ck100 FIND v(dout1_342) AT=55.025n

.meas tran vdout1_343ck100 FIND v(dout1_343) AT=55.025n

.meas tran vdout1_344ck100 FIND v(dout1_344) AT=55.025n

.meas tran vdout1_345ck100 FIND v(dout1_345) AT=55.025n

.meas tran vdout1_346ck100 FIND v(dout1_346) AT=55.025n

.meas tran vdout1_347ck100 FIND v(dout1_347) AT=55.025n

.meas tran vdout1_348ck100 FIND v(dout1_348) AT=55.025n

.meas tran vdout1_349ck100 FIND v(dout1_349) AT=55.025n

.meas tran vdout1_350ck100 FIND v(dout1_350) AT=55.025n

.meas tran vdout1_351ck100 FIND v(dout1_351) AT=55.025n

.meas tran vdout1_352ck100 FIND v(dout1_352) AT=55.025n

.meas tran vdout1_353ck100 FIND v(dout1_353) AT=55.025n

.meas tran vdout1_354ck100 FIND v(dout1_354) AT=55.025n

.meas tran vdout1_355ck100 FIND v(dout1_355) AT=55.025n

.meas tran vdout1_356ck100 FIND v(dout1_356) AT=55.025n

.meas tran vdout1_357ck100 FIND v(dout1_357) AT=55.025n

.meas tran vdout1_358ck100 FIND v(dout1_358) AT=55.025n

.meas tran vdout1_359ck100 FIND v(dout1_359) AT=55.025n

.meas tran vdout1_360ck100 FIND v(dout1_360) AT=55.025n

.meas tran vdout1_361ck100 FIND v(dout1_361) AT=55.025n

.meas tran vdout1_362ck100 FIND v(dout1_362) AT=55.025n

.meas tran vdout1_363ck100 FIND v(dout1_363) AT=55.025n

.meas tran vdout1_364ck100 FIND v(dout1_364) AT=55.025n

.meas tran vdout1_365ck100 FIND v(dout1_365) AT=55.025n

.meas tran vdout1_366ck100 FIND v(dout1_366) AT=55.025n

.meas tran vdout1_367ck100 FIND v(dout1_367) AT=55.025n

.meas tran vdout1_368ck100 FIND v(dout1_368) AT=55.025n

.meas tran vdout1_369ck100 FIND v(dout1_369) AT=55.025n

.meas tran vdout1_370ck100 FIND v(dout1_370) AT=55.025n

.meas tran vdout1_371ck100 FIND v(dout1_371) AT=55.025n

.meas tran vdout1_372ck100 FIND v(dout1_372) AT=55.025n

.meas tran vdout1_373ck100 FIND v(dout1_373) AT=55.025n

.meas tran vdout1_374ck100 FIND v(dout1_374) AT=55.025n

.meas tran vdout1_375ck100 FIND v(dout1_375) AT=55.025n

.meas tran vdout1_376ck100 FIND v(dout1_376) AT=55.025n

.meas tran vdout1_377ck100 FIND v(dout1_377) AT=55.025n

.meas tran vdout1_378ck100 FIND v(dout1_378) AT=55.025n

.meas tran vdout1_379ck100 FIND v(dout1_379) AT=55.025n

.meas tran vdout1_380ck100 FIND v(dout1_380) AT=55.025n

.meas tran vdout1_381ck100 FIND v(dout1_381) AT=55.025n

.meas tran vdout1_382ck100 FIND v(dout1_382) AT=55.025n

.meas tran vdout1_383ck100 FIND v(dout1_383) AT=55.025n

.meas tran vdout1_384ck100 FIND v(dout1_384) AT=55.025n

.meas tran vdout1_385ck100 FIND v(dout1_385) AT=55.025n

.meas tran vdout1_386ck100 FIND v(dout1_386) AT=55.025n

.meas tran vdout1_387ck100 FIND v(dout1_387) AT=55.025n

.meas tran vdout1_388ck100 FIND v(dout1_388) AT=55.025n

.meas tran vdout1_389ck100 FIND v(dout1_389) AT=55.025n

.meas tran vdout1_390ck100 FIND v(dout1_390) AT=55.025n

.meas tran vdout1_391ck100 FIND v(dout1_391) AT=55.025n

.meas tran vdout1_392ck100 FIND v(dout1_392) AT=55.025n

.meas tran vdout1_393ck100 FIND v(dout1_393) AT=55.025n

.meas tran vdout1_394ck100 FIND v(dout1_394) AT=55.025n

.meas tran vdout1_395ck100 FIND v(dout1_395) AT=55.025n

.meas tran vdout1_396ck100 FIND v(dout1_396) AT=55.025n

.meas tran vdout1_397ck100 FIND v(dout1_397) AT=55.025n

.meas tran vdout1_398ck100 FIND v(dout1_398) AT=55.025n

.meas tran vdout1_399ck100 FIND v(dout1_399) AT=55.025n

.meas tran vdout1_400ck100 FIND v(dout1_400) AT=55.025n

.meas tran vdout1_401ck100 FIND v(dout1_401) AT=55.025n

.meas tran vdout1_402ck100 FIND v(dout1_402) AT=55.025n

.meas tran vdout1_403ck100 FIND v(dout1_403) AT=55.025n

.meas tran vdout1_404ck100 FIND v(dout1_404) AT=55.025n

.meas tran vdout1_405ck100 FIND v(dout1_405) AT=55.025n

.meas tran vdout1_406ck100 FIND v(dout1_406) AT=55.025n

.meas tran vdout1_407ck100 FIND v(dout1_407) AT=55.025n

.meas tran vdout1_408ck100 FIND v(dout1_408) AT=55.025n

.meas tran vdout1_409ck100 FIND v(dout1_409) AT=55.025n

.meas tran vdout1_410ck100 FIND v(dout1_410) AT=55.025n

.meas tran vdout1_411ck100 FIND v(dout1_411) AT=55.025n

.meas tran vdout1_412ck100 FIND v(dout1_412) AT=55.025n

.meas tran vdout1_413ck100 FIND v(dout1_413) AT=55.025n

.meas tran vdout1_414ck100 FIND v(dout1_414) AT=55.025n

.meas tran vdout1_415ck100 FIND v(dout1_415) AT=55.025n

.meas tran vdout1_416ck100 FIND v(dout1_416) AT=55.025n

.meas tran vdout1_417ck100 FIND v(dout1_417) AT=55.025n

.meas tran vdout1_418ck100 FIND v(dout1_418) AT=55.025n

.meas tran vdout1_419ck100 FIND v(dout1_419) AT=55.025n

.meas tran vdout1_420ck100 FIND v(dout1_420) AT=55.025n

.meas tran vdout1_421ck100 FIND v(dout1_421) AT=55.025n

.meas tran vdout1_422ck100 FIND v(dout1_422) AT=55.025n

.meas tran vdout1_423ck100 FIND v(dout1_423) AT=55.025n

.meas tran vdout1_424ck100 FIND v(dout1_424) AT=55.025n

.meas tran vdout1_425ck100 FIND v(dout1_425) AT=55.025n

.meas tran vdout1_426ck100 FIND v(dout1_426) AT=55.025n

.meas tran vdout1_427ck100 FIND v(dout1_427) AT=55.025n

.meas tran vdout1_428ck100 FIND v(dout1_428) AT=55.025n

.meas tran vdout1_429ck100 FIND v(dout1_429) AT=55.025n

.meas tran vdout1_430ck100 FIND v(dout1_430) AT=55.025n

.meas tran vdout1_431ck100 FIND v(dout1_431) AT=55.025n

.meas tran vdout1_432ck100 FIND v(dout1_432) AT=55.025n

.meas tran vdout1_433ck100 FIND v(dout1_433) AT=55.025n

.meas tran vdout1_434ck100 FIND v(dout1_434) AT=55.025n

.meas tran vdout1_435ck100 FIND v(dout1_435) AT=55.025n

.meas tran vdout1_436ck100 FIND v(dout1_436) AT=55.025n

.meas tran vdout1_437ck100 FIND v(dout1_437) AT=55.025n

.meas tran vdout1_438ck100 FIND v(dout1_438) AT=55.025n

.meas tran vdout1_439ck100 FIND v(dout1_439) AT=55.025n

.meas tran vdout1_440ck100 FIND v(dout1_440) AT=55.025n

.meas tran vdout1_441ck100 FIND v(dout1_441) AT=55.025n

.meas tran vdout1_442ck100 FIND v(dout1_442) AT=55.025n

.meas tran vdout1_443ck100 FIND v(dout1_443) AT=55.025n

.meas tran vdout1_444ck100 FIND v(dout1_444) AT=55.025n

.meas tran vdout1_445ck100 FIND v(dout1_445) AT=55.025n

.meas tran vdout1_446ck100 FIND v(dout1_446) AT=55.025n

.meas tran vdout1_447ck100 FIND v(dout1_447) AT=55.025n

.meas tran vdout1_448ck100 FIND v(dout1_448) AT=55.025n

.meas tran vdout1_449ck100 FIND v(dout1_449) AT=55.025n

.meas tran vdout1_450ck100 FIND v(dout1_450) AT=55.025n

.meas tran vdout1_451ck100 FIND v(dout1_451) AT=55.025n

.meas tran vdout1_452ck100 FIND v(dout1_452) AT=55.025n

.meas tran vdout1_453ck100 FIND v(dout1_453) AT=55.025n

.meas tran vdout1_454ck100 FIND v(dout1_454) AT=55.025n

.meas tran vdout1_455ck100 FIND v(dout1_455) AT=55.025n

.meas tran vdout1_456ck100 FIND v(dout1_456) AT=55.025n

.meas tran vdout1_457ck100 FIND v(dout1_457) AT=55.025n

.meas tran vdout1_458ck100 FIND v(dout1_458) AT=55.025n

.meas tran vdout1_459ck100 FIND v(dout1_459) AT=55.025n

.meas tran vdout1_460ck100 FIND v(dout1_460) AT=55.025n

.meas tran vdout1_461ck100 FIND v(dout1_461) AT=55.025n

.meas tran vdout1_462ck100 FIND v(dout1_462) AT=55.025n

.meas tran vdout1_463ck100 FIND v(dout1_463) AT=55.025n

.meas tran vdout1_464ck100 FIND v(dout1_464) AT=55.025n

.meas tran vdout1_465ck100 FIND v(dout1_465) AT=55.025n

.meas tran vdout1_466ck100 FIND v(dout1_466) AT=55.025n

.meas tran vdout1_467ck100 FIND v(dout1_467) AT=55.025n

.meas tran vdout1_468ck100 FIND v(dout1_468) AT=55.025n

.meas tran vdout1_469ck100 FIND v(dout1_469) AT=55.025n

.meas tran vdout1_470ck100 FIND v(dout1_470) AT=55.025n

.meas tran vdout1_471ck100 FIND v(dout1_471) AT=55.025n

.meas tran vdout1_472ck100 FIND v(dout1_472) AT=55.025n

.meas tran vdout1_473ck100 FIND v(dout1_473) AT=55.025n

.meas tran vdout1_474ck100 FIND v(dout1_474) AT=55.025n

.meas tran vdout1_475ck100 FIND v(dout1_475) AT=55.025n

.meas tran vdout1_476ck100 FIND v(dout1_476) AT=55.025n

.meas tran vdout1_477ck100 FIND v(dout1_477) AT=55.025n

.meas tran vdout1_478ck100 FIND v(dout1_478) AT=55.025n

.meas tran vdout1_479ck100 FIND v(dout1_479) AT=55.025n

.meas tran vdout1_480ck100 FIND v(dout1_480) AT=55.025n

.meas tran vdout1_481ck100 FIND v(dout1_481) AT=55.025n

.meas tran vdout1_482ck100 FIND v(dout1_482) AT=55.025n

.meas tran vdout1_483ck100 FIND v(dout1_483) AT=55.025n

.meas tran vdout1_484ck100 FIND v(dout1_484) AT=55.025n

.meas tran vdout1_485ck100 FIND v(dout1_485) AT=55.025n

.meas tran vdout1_486ck100 FIND v(dout1_486) AT=55.025n

.meas tran vdout1_487ck100 FIND v(dout1_487) AT=55.025n

.meas tran vdout1_488ck100 FIND v(dout1_488) AT=55.025n

.meas tran vdout1_489ck100 FIND v(dout1_489) AT=55.025n

.meas tran vdout1_490ck100 FIND v(dout1_490) AT=55.025n

.meas tran vdout1_491ck100 FIND v(dout1_491) AT=55.025n

.meas tran vdout1_492ck100 FIND v(dout1_492) AT=55.025n

.meas tran vdout1_493ck100 FIND v(dout1_493) AT=55.025n

.meas tran vdout1_494ck100 FIND v(dout1_494) AT=55.025n

.meas tran vdout1_495ck100 FIND v(dout1_495) AT=55.025n

.meas tran vdout1_496ck100 FIND v(dout1_496) AT=55.025n

.meas tran vdout1_497ck100 FIND v(dout1_497) AT=55.025n

.meas tran vdout1_498ck100 FIND v(dout1_498) AT=55.025n

.meas tran vdout1_499ck100 FIND v(dout1_499) AT=55.025n

.meas tran vdout1_500ck100 FIND v(dout1_500) AT=55.025n

.meas tran vdout1_501ck100 FIND v(dout1_501) AT=55.025n

.meas tran vdout1_502ck100 FIND v(dout1_502) AT=55.025n

.meas tran vdout1_503ck100 FIND v(dout1_503) AT=55.025n

.meas tran vdout1_504ck100 FIND v(dout1_504) AT=55.025n

.meas tran vdout1_505ck100 FIND v(dout1_505) AT=55.025n

.meas tran vdout1_506ck100 FIND v(dout1_506) AT=55.025n

.meas tran vdout1_507ck100 FIND v(dout1_507) AT=55.025n

.meas tran vdout1_508ck100 FIND v(dout1_508) AT=55.025n

.meas tran vdout1_509ck100 FIND v(dout1_509) AT=55.025n

.meas tran vdout1_510ck100 FIND v(dout1_510) AT=55.025n

.meas tran vdout1_511ck100 FIND v(dout1_511) AT=55.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_32ck130 FIND v(dout1_32) AT=70.025n

.meas tran vdout1_33ck130 FIND v(dout1_33) AT=70.025n

.meas tran vdout1_34ck130 FIND v(dout1_34) AT=70.025n

.meas tran vdout1_35ck130 FIND v(dout1_35) AT=70.025n

.meas tran vdout1_36ck130 FIND v(dout1_36) AT=70.025n

.meas tran vdout1_37ck130 FIND v(dout1_37) AT=70.025n

.meas tran vdout1_38ck130 FIND v(dout1_38) AT=70.025n

.meas tran vdout1_39ck130 FIND v(dout1_39) AT=70.025n

.meas tran vdout1_40ck130 FIND v(dout1_40) AT=70.025n

.meas tran vdout1_41ck130 FIND v(dout1_41) AT=70.025n

.meas tran vdout1_42ck130 FIND v(dout1_42) AT=70.025n

.meas tran vdout1_43ck130 FIND v(dout1_43) AT=70.025n

.meas tran vdout1_44ck130 FIND v(dout1_44) AT=70.025n

.meas tran vdout1_45ck130 FIND v(dout1_45) AT=70.025n

.meas tran vdout1_46ck130 FIND v(dout1_46) AT=70.025n

.meas tran vdout1_47ck130 FIND v(dout1_47) AT=70.025n

.meas tran vdout1_48ck130 FIND v(dout1_48) AT=70.025n

.meas tran vdout1_49ck130 FIND v(dout1_49) AT=70.025n

.meas tran vdout1_50ck130 FIND v(dout1_50) AT=70.025n

.meas tran vdout1_51ck130 FIND v(dout1_51) AT=70.025n

.meas tran vdout1_52ck130 FIND v(dout1_52) AT=70.025n

.meas tran vdout1_53ck130 FIND v(dout1_53) AT=70.025n

.meas tran vdout1_54ck130 FIND v(dout1_54) AT=70.025n

.meas tran vdout1_55ck130 FIND v(dout1_55) AT=70.025n

.meas tran vdout1_56ck130 FIND v(dout1_56) AT=70.025n

.meas tran vdout1_57ck130 FIND v(dout1_57) AT=70.025n

.meas tran vdout1_58ck130 FIND v(dout1_58) AT=70.025n

.meas tran vdout1_59ck130 FIND v(dout1_59) AT=70.025n

.meas tran vdout1_60ck130 FIND v(dout1_60) AT=70.025n

.meas tran vdout1_61ck130 FIND v(dout1_61) AT=70.025n

.meas tran vdout1_62ck130 FIND v(dout1_62) AT=70.025n

.meas tran vdout1_63ck130 FIND v(dout1_63) AT=70.025n

.meas tran vdout1_64ck130 FIND v(dout1_64) AT=70.025n

.meas tran vdout1_65ck130 FIND v(dout1_65) AT=70.025n

.meas tran vdout1_66ck130 FIND v(dout1_66) AT=70.025n

.meas tran vdout1_67ck130 FIND v(dout1_67) AT=70.025n

.meas tran vdout1_68ck130 FIND v(dout1_68) AT=70.025n

.meas tran vdout1_69ck130 FIND v(dout1_69) AT=70.025n

.meas tran vdout1_70ck130 FIND v(dout1_70) AT=70.025n

.meas tran vdout1_71ck130 FIND v(dout1_71) AT=70.025n

.meas tran vdout1_72ck130 FIND v(dout1_72) AT=70.025n

.meas tran vdout1_73ck130 FIND v(dout1_73) AT=70.025n

.meas tran vdout1_74ck130 FIND v(dout1_74) AT=70.025n

.meas tran vdout1_75ck130 FIND v(dout1_75) AT=70.025n

.meas tran vdout1_76ck130 FIND v(dout1_76) AT=70.025n

.meas tran vdout1_77ck130 FIND v(dout1_77) AT=70.025n

.meas tran vdout1_78ck130 FIND v(dout1_78) AT=70.025n

.meas tran vdout1_79ck130 FIND v(dout1_79) AT=70.025n

.meas tran vdout1_80ck130 FIND v(dout1_80) AT=70.025n

.meas tran vdout1_81ck130 FIND v(dout1_81) AT=70.025n

.meas tran vdout1_82ck130 FIND v(dout1_82) AT=70.025n

.meas tran vdout1_83ck130 FIND v(dout1_83) AT=70.025n

.meas tran vdout1_84ck130 FIND v(dout1_84) AT=70.025n

.meas tran vdout1_85ck130 FIND v(dout1_85) AT=70.025n

.meas tran vdout1_86ck130 FIND v(dout1_86) AT=70.025n

.meas tran vdout1_87ck130 FIND v(dout1_87) AT=70.025n

.meas tran vdout1_88ck130 FIND v(dout1_88) AT=70.025n

.meas tran vdout1_89ck130 FIND v(dout1_89) AT=70.025n

.meas tran vdout1_90ck130 FIND v(dout1_90) AT=70.025n

.meas tran vdout1_91ck130 FIND v(dout1_91) AT=70.025n

.meas tran vdout1_92ck130 FIND v(dout1_92) AT=70.025n

.meas tran vdout1_93ck130 FIND v(dout1_93) AT=70.025n

.meas tran vdout1_94ck130 FIND v(dout1_94) AT=70.025n

.meas tran vdout1_95ck130 FIND v(dout1_95) AT=70.025n

.meas tran vdout1_96ck130 FIND v(dout1_96) AT=70.025n

.meas tran vdout1_97ck130 FIND v(dout1_97) AT=70.025n

.meas tran vdout1_98ck130 FIND v(dout1_98) AT=70.025n

.meas tran vdout1_99ck130 FIND v(dout1_99) AT=70.025n

.meas tran vdout1_100ck130 FIND v(dout1_100) AT=70.025n

.meas tran vdout1_101ck130 FIND v(dout1_101) AT=70.025n

.meas tran vdout1_102ck130 FIND v(dout1_102) AT=70.025n

.meas tran vdout1_103ck130 FIND v(dout1_103) AT=70.025n

.meas tran vdout1_104ck130 FIND v(dout1_104) AT=70.025n

.meas tran vdout1_105ck130 FIND v(dout1_105) AT=70.025n

.meas tran vdout1_106ck130 FIND v(dout1_106) AT=70.025n

.meas tran vdout1_107ck130 FIND v(dout1_107) AT=70.025n

.meas tran vdout1_108ck130 FIND v(dout1_108) AT=70.025n

.meas tran vdout1_109ck130 FIND v(dout1_109) AT=70.025n

.meas tran vdout1_110ck130 FIND v(dout1_110) AT=70.025n

.meas tran vdout1_111ck130 FIND v(dout1_111) AT=70.025n

.meas tran vdout1_112ck130 FIND v(dout1_112) AT=70.025n

.meas tran vdout1_113ck130 FIND v(dout1_113) AT=70.025n

.meas tran vdout1_114ck130 FIND v(dout1_114) AT=70.025n

.meas tran vdout1_115ck130 FIND v(dout1_115) AT=70.025n

.meas tran vdout1_116ck130 FIND v(dout1_116) AT=70.025n

.meas tran vdout1_117ck130 FIND v(dout1_117) AT=70.025n

.meas tran vdout1_118ck130 FIND v(dout1_118) AT=70.025n

.meas tran vdout1_119ck130 FIND v(dout1_119) AT=70.025n

.meas tran vdout1_120ck130 FIND v(dout1_120) AT=70.025n

.meas tran vdout1_121ck130 FIND v(dout1_121) AT=70.025n

.meas tran vdout1_122ck130 FIND v(dout1_122) AT=70.025n

.meas tran vdout1_123ck130 FIND v(dout1_123) AT=70.025n

.meas tran vdout1_124ck130 FIND v(dout1_124) AT=70.025n

.meas tran vdout1_125ck130 FIND v(dout1_125) AT=70.025n

.meas tran vdout1_126ck130 FIND v(dout1_126) AT=70.025n

.meas tran vdout1_127ck130 FIND v(dout1_127) AT=70.025n

.meas tran vdout1_128ck130 FIND v(dout1_128) AT=70.025n

.meas tran vdout1_129ck130 FIND v(dout1_129) AT=70.025n

.meas tran vdout1_130ck130 FIND v(dout1_130) AT=70.025n

.meas tran vdout1_131ck130 FIND v(dout1_131) AT=70.025n

.meas tran vdout1_132ck130 FIND v(dout1_132) AT=70.025n

.meas tran vdout1_133ck130 FIND v(dout1_133) AT=70.025n

.meas tran vdout1_134ck130 FIND v(dout1_134) AT=70.025n

.meas tran vdout1_135ck130 FIND v(dout1_135) AT=70.025n

.meas tran vdout1_136ck130 FIND v(dout1_136) AT=70.025n

.meas tran vdout1_137ck130 FIND v(dout1_137) AT=70.025n

.meas tran vdout1_138ck130 FIND v(dout1_138) AT=70.025n

.meas tran vdout1_139ck130 FIND v(dout1_139) AT=70.025n

.meas tran vdout1_140ck130 FIND v(dout1_140) AT=70.025n

.meas tran vdout1_141ck130 FIND v(dout1_141) AT=70.025n

.meas tran vdout1_142ck130 FIND v(dout1_142) AT=70.025n

.meas tran vdout1_143ck130 FIND v(dout1_143) AT=70.025n

.meas tran vdout1_144ck130 FIND v(dout1_144) AT=70.025n

.meas tran vdout1_145ck130 FIND v(dout1_145) AT=70.025n

.meas tran vdout1_146ck130 FIND v(dout1_146) AT=70.025n

.meas tran vdout1_147ck130 FIND v(dout1_147) AT=70.025n

.meas tran vdout1_148ck130 FIND v(dout1_148) AT=70.025n

.meas tran vdout1_149ck130 FIND v(dout1_149) AT=70.025n

.meas tran vdout1_150ck130 FIND v(dout1_150) AT=70.025n

.meas tran vdout1_151ck130 FIND v(dout1_151) AT=70.025n

.meas tran vdout1_152ck130 FIND v(dout1_152) AT=70.025n

.meas tran vdout1_153ck130 FIND v(dout1_153) AT=70.025n

.meas tran vdout1_154ck130 FIND v(dout1_154) AT=70.025n

.meas tran vdout1_155ck130 FIND v(dout1_155) AT=70.025n

.meas tran vdout1_156ck130 FIND v(dout1_156) AT=70.025n

.meas tran vdout1_157ck130 FIND v(dout1_157) AT=70.025n

.meas tran vdout1_158ck130 FIND v(dout1_158) AT=70.025n

.meas tran vdout1_159ck130 FIND v(dout1_159) AT=70.025n

.meas tran vdout1_160ck130 FIND v(dout1_160) AT=70.025n

.meas tran vdout1_161ck130 FIND v(dout1_161) AT=70.025n

.meas tran vdout1_162ck130 FIND v(dout1_162) AT=70.025n

.meas tran vdout1_163ck130 FIND v(dout1_163) AT=70.025n

.meas tran vdout1_164ck130 FIND v(dout1_164) AT=70.025n

.meas tran vdout1_165ck130 FIND v(dout1_165) AT=70.025n

.meas tran vdout1_166ck130 FIND v(dout1_166) AT=70.025n

.meas tran vdout1_167ck130 FIND v(dout1_167) AT=70.025n

.meas tran vdout1_168ck130 FIND v(dout1_168) AT=70.025n

.meas tran vdout1_169ck130 FIND v(dout1_169) AT=70.025n

.meas tran vdout1_170ck130 FIND v(dout1_170) AT=70.025n

.meas tran vdout1_171ck130 FIND v(dout1_171) AT=70.025n

.meas tran vdout1_172ck130 FIND v(dout1_172) AT=70.025n

.meas tran vdout1_173ck130 FIND v(dout1_173) AT=70.025n

.meas tran vdout1_174ck130 FIND v(dout1_174) AT=70.025n

.meas tran vdout1_175ck130 FIND v(dout1_175) AT=70.025n

.meas tran vdout1_176ck130 FIND v(dout1_176) AT=70.025n

.meas tran vdout1_177ck130 FIND v(dout1_177) AT=70.025n

.meas tran vdout1_178ck130 FIND v(dout1_178) AT=70.025n

.meas tran vdout1_179ck130 FIND v(dout1_179) AT=70.025n

.meas tran vdout1_180ck130 FIND v(dout1_180) AT=70.025n

.meas tran vdout1_181ck130 FIND v(dout1_181) AT=70.025n

.meas tran vdout1_182ck130 FIND v(dout1_182) AT=70.025n

.meas tran vdout1_183ck130 FIND v(dout1_183) AT=70.025n

.meas tran vdout1_184ck130 FIND v(dout1_184) AT=70.025n

.meas tran vdout1_185ck130 FIND v(dout1_185) AT=70.025n

.meas tran vdout1_186ck130 FIND v(dout1_186) AT=70.025n

.meas tran vdout1_187ck130 FIND v(dout1_187) AT=70.025n

.meas tran vdout1_188ck130 FIND v(dout1_188) AT=70.025n

.meas tran vdout1_189ck130 FIND v(dout1_189) AT=70.025n

.meas tran vdout1_190ck130 FIND v(dout1_190) AT=70.025n

.meas tran vdout1_191ck130 FIND v(dout1_191) AT=70.025n

.meas tran vdout1_192ck130 FIND v(dout1_192) AT=70.025n

.meas tran vdout1_193ck130 FIND v(dout1_193) AT=70.025n

.meas tran vdout1_194ck130 FIND v(dout1_194) AT=70.025n

.meas tran vdout1_195ck130 FIND v(dout1_195) AT=70.025n

.meas tran vdout1_196ck130 FIND v(dout1_196) AT=70.025n

.meas tran vdout1_197ck130 FIND v(dout1_197) AT=70.025n

.meas tran vdout1_198ck130 FIND v(dout1_198) AT=70.025n

.meas tran vdout1_199ck130 FIND v(dout1_199) AT=70.025n

.meas tran vdout1_200ck130 FIND v(dout1_200) AT=70.025n

.meas tran vdout1_201ck130 FIND v(dout1_201) AT=70.025n

.meas tran vdout1_202ck130 FIND v(dout1_202) AT=70.025n

.meas tran vdout1_203ck130 FIND v(dout1_203) AT=70.025n

.meas tran vdout1_204ck130 FIND v(dout1_204) AT=70.025n

.meas tran vdout1_205ck130 FIND v(dout1_205) AT=70.025n

.meas tran vdout1_206ck130 FIND v(dout1_206) AT=70.025n

.meas tran vdout1_207ck130 FIND v(dout1_207) AT=70.025n

.meas tran vdout1_208ck130 FIND v(dout1_208) AT=70.025n

.meas tran vdout1_209ck130 FIND v(dout1_209) AT=70.025n

.meas tran vdout1_210ck130 FIND v(dout1_210) AT=70.025n

.meas tran vdout1_211ck130 FIND v(dout1_211) AT=70.025n

.meas tran vdout1_212ck130 FIND v(dout1_212) AT=70.025n

.meas tran vdout1_213ck130 FIND v(dout1_213) AT=70.025n

.meas tran vdout1_214ck130 FIND v(dout1_214) AT=70.025n

.meas tran vdout1_215ck130 FIND v(dout1_215) AT=70.025n

.meas tran vdout1_216ck130 FIND v(dout1_216) AT=70.025n

.meas tran vdout1_217ck130 FIND v(dout1_217) AT=70.025n

.meas tran vdout1_218ck130 FIND v(dout1_218) AT=70.025n

.meas tran vdout1_219ck130 FIND v(dout1_219) AT=70.025n

.meas tran vdout1_220ck130 FIND v(dout1_220) AT=70.025n

.meas tran vdout1_221ck130 FIND v(dout1_221) AT=70.025n

.meas tran vdout1_222ck130 FIND v(dout1_222) AT=70.025n

.meas tran vdout1_223ck130 FIND v(dout1_223) AT=70.025n

.meas tran vdout1_224ck130 FIND v(dout1_224) AT=70.025n

.meas tran vdout1_225ck130 FIND v(dout1_225) AT=70.025n

.meas tran vdout1_226ck130 FIND v(dout1_226) AT=70.025n

.meas tran vdout1_227ck130 FIND v(dout1_227) AT=70.025n

.meas tran vdout1_228ck130 FIND v(dout1_228) AT=70.025n

.meas tran vdout1_229ck130 FIND v(dout1_229) AT=70.025n

.meas tran vdout1_230ck130 FIND v(dout1_230) AT=70.025n

.meas tran vdout1_231ck130 FIND v(dout1_231) AT=70.025n

.meas tran vdout1_232ck130 FIND v(dout1_232) AT=70.025n

.meas tran vdout1_233ck130 FIND v(dout1_233) AT=70.025n

.meas tran vdout1_234ck130 FIND v(dout1_234) AT=70.025n

.meas tran vdout1_235ck130 FIND v(dout1_235) AT=70.025n

.meas tran vdout1_236ck130 FIND v(dout1_236) AT=70.025n

.meas tran vdout1_237ck130 FIND v(dout1_237) AT=70.025n

.meas tran vdout1_238ck130 FIND v(dout1_238) AT=70.025n

.meas tran vdout1_239ck130 FIND v(dout1_239) AT=70.025n

.meas tran vdout1_240ck130 FIND v(dout1_240) AT=70.025n

.meas tran vdout1_241ck130 FIND v(dout1_241) AT=70.025n

.meas tran vdout1_242ck130 FIND v(dout1_242) AT=70.025n

.meas tran vdout1_243ck130 FIND v(dout1_243) AT=70.025n

.meas tran vdout1_244ck130 FIND v(dout1_244) AT=70.025n

.meas tran vdout1_245ck130 FIND v(dout1_245) AT=70.025n

.meas tran vdout1_246ck130 FIND v(dout1_246) AT=70.025n

.meas tran vdout1_247ck130 FIND v(dout1_247) AT=70.025n

.meas tran vdout1_248ck130 FIND v(dout1_248) AT=70.025n

.meas tran vdout1_249ck130 FIND v(dout1_249) AT=70.025n

.meas tran vdout1_250ck130 FIND v(dout1_250) AT=70.025n

.meas tran vdout1_251ck130 FIND v(dout1_251) AT=70.025n

.meas tran vdout1_252ck130 FIND v(dout1_252) AT=70.025n

.meas tran vdout1_253ck130 FIND v(dout1_253) AT=70.025n

.meas tran vdout1_254ck130 FIND v(dout1_254) AT=70.025n

.meas tran vdout1_255ck130 FIND v(dout1_255) AT=70.025n

.meas tran vdout1_256ck130 FIND v(dout1_256) AT=70.025n

.meas tran vdout1_257ck130 FIND v(dout1_257) AT=70.025n

.meas tran vdout1_258ck130 FIND v(dout1_258) AT=70.025n

.meas tran vdout1_259ck130 FIND v(dout1_259) AT=70.025n

.meas tran vdout1_260ck130 FIND v(dout1_260) AT=70.025n

.meas tran vdout1_261ck130 FIND v(dout1_261) AT=70.025n

.meas tran vdout1_262ck130 FIND v(dout1_262) AT=70.025n

.meas tran vdout1_263ck130 FIND v(dout1_263) AT=70.025n

.meas tran vdout1_264ck130 FIND v(dout1_264) AT=70.025n

.meas tran vdout1_265ck130 FIND v(dout1_265) AT=70.025n

.meas tran vdout1_266ck130 FIND v(dout1_266) AT=70.025n

.meas tran vdout1_267ck130 FIND v(dout1_267) AT=70.025n

.meas tran vdout1_268ck130 FIND v(dout1_268) AT=70.025n

.meas tran vdout1_269ck130 FIND v(dout1_269) AT=70.025n

.meas tran vdout1_270ck130 FIND v(dout1_270) AT=70.025n

.meas tran vdout1_271ck130 FIND v(dout1_271) AT=70.025n

.meas tran vdout1_272ck130 FIND v(dout1_272) AT=70.025n

.meas tran vdout1_273ck130 FIND v(dout1_273) AT=70.025n

.meas tran vdout1_274ck130 FIND v(dout1_274) AT=70.025n

.meas tran vdout1_275ck130 FIND v(dout1_275) AT=70.025n

.meas tran vdout1_276ck130 FIND v(dout1_276) AT=70.025n

.meas tran vdout1_277ck130 FIND v(dout1_277) AT=70.025n

.meas tran vdout1_278ck130 FIND v(dout1_278) AT=70.025n

.meas tran vdout1_279ck130 FIND v(dout1_279) AT=70.025n

.meas tran vdout1_280ck130 FIND v(dout1_280) AT=70.025n

.meas tran vdout1_281ck130 FIND v(dout1_281) AT=70.025n

.meas tran vdout1_282ck130 FIND v(dout1_282) AT=70.025n

.meas tran vdout1_283ck130 FIND v(dout1_283) AT=70.025n

.meas tran vdout1_284ck130 FIND v(dout1_284) AT=70.025n

.meas tran vdout1_285ck130 FIND v(dout1_285) AT=70.025n

.meas tran vdout1_286ck130 FIND v(dout1_286) AT=70.025n

.meas tran vdout1_287ck130 FIND v(dout1_287) AT=70.025n

.meas tran vdout1_288ck130 FIND v(dout1_288) AT=70.025n

.meas tran vdout1_289ck130 FIND v(dout1_289) AT=70.025n

.meas tran vdout1_290ck130 FIND v(dout1_290) AT=70.025n

.meas tran vdout1_291ck130 FIND v(dout1_291) AT=70.025n

.meas tran vdout1_292ck130 FIND v(dout1_292) AT=70.025n

.meas tran vdout1_293ck130 FIND v(dout1_293) AT=70.025n

.meas tran vdout1_294ck130 FIND v(dout1_294) AT=70.025n

.meas tran vdout1_295ck130 FIND v(dout1_295) AT=70.025n

.meas tran vdout1_296ck130 FIND v(dout1_296) AT=70.025n

.meas tran vdout1_297ck130 FIND v(dout1_297) AT=70.025n

.meas tran vdout1_298ck130 FIND v(dout1_298) AT=70.025n

.meas tran vdout1_299ck130 FIND v(dout1_299) AT=70.025n

.meas tran vdout1_300ck130 FIND v(dout1_300) AT=70.025n

.meas tran vdout1_301ck130 FIND v(dout1_301) AT=70.025n

.meas tran vdout1_302ck130 FIND v(dout1_302) AT=70.025n

.meas tran vdout1_303ck130 FIND v(dout1_303) AT=70.025n

.meas tran vdout1_304ck130 FIND v(dout1_304) AT=70.025n

.meas tran vdout1_305ck130 FIND v(dout1_305) AT=70.025n

.meas tran vdout1_306ck130 FIND v(dout1_306) AT=70.025n

.meas tran vdout1_307ck130 FIND v(dout1_307) AT=70.025n

.meas tran vdout1_308ck130 FIND v(dout1_308) AT=70.025n

.meas tran vdout1_309ck130 FIND v(dout1_309) AT=70.025n

.meas tran vdout1_310ck130 FIND v(dout1_310) AT=70.025n

.meas tran vdout1_311ck130 FIND v(dout1_311) AT=70.025n

.meas tran vdout1_312ck130 FIND v(dout1_312) AT=70.025n

.meas tran vdout1_313ck130 FIND v(dout1_313) AT=70.025n

.meas tran vdout1_314ck130 FIND v(dout1_314) AT=70.025n

.meas tran vdout1_315ck130 FIND v(dout1_315) AT=70.025n

.meas tran vdout1_316ck130 FIND v(dout1_316) AT=70.025n

.meas tran vdout1_317ck130 FIND v(dout1_317) AT=70.025n

.meas tran vdout1_318ck130 FIND v(dout1_318) AT=70.025n

.meas tran vdout1_319ck130 FIND v(dout1_319) AT=70.025n

.meas tran vdout1_320ck130 FIND v(dout1_320) AT=70.025n

.meas tran vdout1_321ck130 FIND v(dout1_321) AT=70.025n

.meas tran vdout1_322ck130 FIND v(dout1_322) AT=70.025n

.meas tran vdout1_323ck130 FIND v(dout1_323) AT=70.025n

.meas tran vdout1_324ck130 FIND v(dout1_324) AT=70.025n

.meas tran vdout1_325ck130 FIND v(dout1_325) AT=70.025n

.meas tran vdout1_326ck130 FIND v(dout1_326) AT=70.025n

.meas tran vdout1_327ck130 FIND v(dout1_327) AT=70.025n

.meas tran vdout1_328ck130 FIND v(dout1_328) AT=70.025n

.meas tran vdout1_329ck130 FIND v(dout1_329) AT=70.025n

.meas tran vdout1_330ck130 FIND v(dout1_330) AT=70.025n

.meas tran vdout1_331ck130 FIND v(dout1_331) AT=70.025n

.meas tran vdout1_332ck130 FIND v(dout1_332) AT=70.025n

.meas tran vdout1_333ck130 FIND v(dout1_333) AT=70.025n

.meas tran vdout1_334ck130 FIND v(dout1_334) AT=70.025n

.meas tran vdout1_335ck130 FIND v(dout1_335) AT=70.025n

.meas tran vdout1_336ck130 FIND v(dout1_336) AT=70.025n

.meas tran vdout1_337ck130 FIND v(dout1_337) AT=70.025n

.meas tran vdout1_338ck130 FIND v(dout1_338) AT=70.025n

.meas tran vdout1_339ck130 FIND v(dout1_339) AT=70.025n

.meas tran vdout1_340ck130 FIND v(dout1_340) AT=70.025n

.meas tran vdout1_341ck130 FIND v(dout1_341) AT=70.025n

.meas tran vdout1_342ck130 FIND v(dout1_342) AT=70.025n

.meas tran vdout1_343ck130 FIND v(dout1_343) AT=70.025n

.meas tran vdout1_344ck130 FIND v(dout1_344) AT=70.025n

.meas tran vdout1_345ck130 FIND v(dout1_345) AT=70.025n

.meas tran vdout1_346ck130 FIND v(dout1_346) AT=70.025n

.meas tran vdout1_347ck130 FIND v(dout1_347) AT=70.025n

.meas tran vdout1_348ck130 FIND v(dout1_348) AT=70.025n

.meas tran vdout1_349ck130 FIND v(dout1_349) AT=70.025n

.meas tran vdout1_350ck130 FIND v(dout1_350) AT=70.025n

.meas tran vdout1_351ck130 FIND v(dout1_351) AT=70.025n

.meas tran vdout1_352ck130 FIND v(dout1_352) AT=70.025n

.meas tran vdout1_353ck130 FIND v(dout1_353) AT=70.025n

.meas tran vdout1_354ck130 FIND v(dout1_354) AT=70.025n

.meas tran vdout1_355ck130 FIND v(dout1_355) AT=70.025n

.meas tran vdout1_356ck130 FIND v(dout1_356) AT=70.025n

.meas tran vdout1_357ck130 FIND v(dout1_357) AT=70.025n

.meas tran vdout1_358ck130 FIND v(dout1_358) AT=70.025n

.meas tran vdout1_359ck130 FIND v(dout1_359) AT=70.025n

.meas tran vdout1_360ck130 FIND v(dout1_360) AT=70.025n

.meas tran vdout1_361ck130 FIND v(dout1_361) AT=70.025n

.meas tran vdout1_362ck130 FIND v(dout1_362) AT=70.025n

.meas tran vdout1_363ck130 FIND v(dout1_363) AT=70.025n

.meas tran vdout1_364ck130 FIND v(dout1_364) AT=70.025n

.meas tran vdout1_365ck130 FIND v(dout1_365) AT=70.025n

.meas tran vdout1_366ck130 FIND v(dout1_366) AT=70.025n

.meas tran vdout1_367ck130 FIND v(dout1_367) AT=70.025n

.meas tran vdout1_368ck130 FIND v(dout1_368) AT=70.025n

.meas tran vdout1_369ck130 FIND v(dout1_369) AT=70.025n

.meas tran vdout1_370ck130 FIND v(dout1_370) AT=70.025n

.meas tran vdout1_371ck130 FIND v(dout1_371) AT=70.025n

.meas tran vdout1_372ck130 FIND v(dout1_372) AT=70.025n

.meas tran vdout1_373ck130 FIND v(dout1_373) AT=70.025n

.meas tran vdout1_374ck130 FIND v(dout1_374) AT=70.025n

.meas tran vdout1_375ck130 FIND v(dout1_375) AT=70.025n

.meas tran vdout1_376ck130 FIND v(dout1_376) AT=70.025n

.meas tran vdout1_377ck130 FIND v(dout1_377) AT=70.025n

.meas tran vdout1_378ck130 FIND v(dout1_378) AT=70.025n

.meas tran vdout1_379ck130 FIND v(dout1_379) AT=70.025n

.meas tran vdout1_380ck130 FIND v(dout1_380) AT=70.025n

.meas tran vdout1_381ck130 FIND v(dout1_381) AT=70.025n

.meas tran vdout1_382ck130 FIND v(dout1_382) AT=70.025n

.meas tran vdout1_383ck130 FIND v(dout1_383) AT=70.025n

.meas tran vdout1_384ck130 FIND v(dout1_384) AT=70.025n

.meas tran vdout1_385ck130 FIND v(dout1_385) AT=70.025n

.meas tran vdout1_386ck130 FIND v(dout1_386) AT=70.025n

.meas tran vdout1_387ck130 FIND v(dout1_387) AT=70.025n

.meas tran vdout1_388ck130 FIND v(dout1_388) AT=70.025n

.meas tran vdout1_389ck130 FIND v(dout1_389) AT=70.025n

.meas tran vdout1_390ck130 FIND v(dout1_390) AT=70.025n

.meas tran vdout1_391ck130 FIND v(dout1_391) AT=70.025n

.meas tran vdout1_392ck130 FIND v(dout1_392) AT=70.025n

.meas tran vdout1_393ck130 FIND v(dout1_393) AT=70.025n

.meas tran vdout1_394ck130 FIND v(dout1_394) AT=70.025n

.meas tran vdout1_395ck130 FIND v(dout1_395) AT=70.025n

.meas tran vdout1_396ck130 FIND v(dout1_396) AT=70.025n

.meas tran vdout1_397ck130 FIND v(dout1_397) AT=70.025n

.meas tran vdout1_398ck130 FIND v(dout1_398) AT=70.025n

.meas tran vdout1_399ck130 FIND v(dout1_399) AT=70.025n

.meas tran vdout1_400ck130 FIND v(dout1_400) AT=70.025n

.meas tran vdout1_401ck130 FIND v(dout1_401) AT=70.025n

.meas tran vdout1_402ck130 FIND v(dout1_402) AT=70.025n

.meas tran vdout1_403ck130 FIND v(dout1_403) AT=70.025n

.meas tran vdout1_404ck130 FIND v(dout1_404) AT=70.025n

.meas tran vdout1_405ck130 FIND v(dout1_405) AT=70.025n

.meas tran vdout1_406ck130 FIND v(dout1_406) AT=70.025n

.meas tran vdout1_407ck130 FIND v(dout1_407) AT=70.025n

.meas tran vdout1_408ck130 FIND v(dout1_408) AT=70.025n

.meas tran vdout1_409ck130 FIND v(dout1_409) AT=70.025n

.meas tran vdout1_410ck130 FIND v(dout1_410) AT=70.025n

.meas tran vdout1_411ck130 FIND v(dout1_411) AT=70.025n

.meas tran vdout1_412ck130 FIND v(dout1_412) AT=70.025n

.meas tran vdout1_413ck130 FIND v(dout1_413) AT=70.025n

.meas tran vdout1_414ck130 FIND v(dout1_414) AT=70.025n

.meas tran vdout1_415ck130 FIND v(dout1_415) AT=70.025n

.meas tran vdout1_416ck130 FIND v(dout1_416) AT=70.025n

.meas tran vdout1_417ck130 FIND v(dout1_417) AT=70.025n

.meas tran vdout1_418ck130 FIND v(dout1_418) AT=70.025n

.meas tran vdout1_419ck130 FIND v(dout1_419) AT=70.025n

.meas tran vdout1_420ck130 FIND v(dout1_420) AT=70.025n

.meas tran vdout1_421ck130 FIND v(dout1_421) AT=70.025n

.meas tran vdout1_422ck130 FIND v(dout1_422) AT=70.025n

.meas tran vdout1_423ck130 FIND v(dout1_423) AT=70.025n

.meas tran vdout1_424ck130 FIND v(dout1_424) AT=70.025n

.meas tran vdout1_425ck130 FIND v(dout1_425) AT=70.025n

.meas tran vdout1_426ck130 FIND v(dout1_426) AT=70.025n

.meas tran vdout1_427ck130 FIND v(dout1_427) AT=70.025n

.meas tran vdout1_428ck130 FIND v(dout1_428) AT=70.025n

.meas tran vdout1_429ck130 FIND v(dout1_429) AT=70.025n

.meas tran vdout1_430ck130 FIND v(dout1_430) AT=70.025n

.meas tran vdout1_431ck130 FIND v(dout1_431) AT=70.025n

.meas tran vdout1_432ck130 FIND v(dout1_432) AT=70.025n

.meas tran vdout1_433ck130 FIND v(dout1_433) AT=70.025n

.meas tran vdout1_434ck130 FIND v(dout1_434) AT=70.025n

.meas tran vdout1_435ck130 FIND v(dout1_435) AT=70.025n

.meas tran vdout1_436ck130 FIND v(dout1_436) AT=70.025n

.meas tran vdout1_437ck130 FIND v(dout1_437) AT=70.025n

.meas tran vdout1_438ck130 FIND v(dout1_438) AT=70.025n

.meas tran vdout1_439ck130 FIND v(dout1_439) AT=70.025n

.meas tran vdout1_440ck130 FIND v(dout1_440) AT=70.025n

.meas tran vdout1_441ck130 FIND v(dout1_441) AT=70.025n

.meas tran vdout1_442ck130 FIND v(dout1_442) AT=70.025n

.meas tran vdout1_443ck130 FIND v(dout1_443) AT=70.025n

.meas tran vdout1_444ck130 FIND v(dout1_444) AT=70.025n

.meas tran vdout1_445ck130 FIND v(dout1_445) AT=70.025n

.meas tran vdout1_446ck130 FIND v(dout1_446) AT=70.025n

.meas tran vdout1_447ck130 FIND v(dout1_447) AT=70.025n

.meas tran vdout1_448ck130 FIND v(dout1_448) AT=70.025n

.meas tran vdout1_449ck130 FIND v(dout1_449) AT=70.025n

.meas tran vdout1_450ck130 FIND v(dout1_450) AT=70.025n

.meas tran vdout1_451ck130 FIND v(dout1_451) AT=70.025n

.meas tran vdout1_452ck130 FIND v(dout1_452) AT=70.025n

.meas tran vdout1_453ck130 FIND v(dout1_453) AT=70.025n

.meas tran vdout1_454ck130 FIND v(dout1_454) AT=70.025n

.meas tran vdout1_455ck130 FIND v(dout1_455) AT=70.025n

.meas tran vdout1_456ck130 FIND v(dout1_456) AT=70.025n

.meas tran vdout1_457ck130 FIND v(dout1_457) AT=70.025n

.meas tran vdout1_458ck130 FIND v(dout1_458) AT=70.025n

.meas tran vdout1_459ck130 FIND v(dout1_459) AT=70.025n

.meas tran vdout1_460ck130 FIND v(dout1_460) AT=70.025n

.meas tran vdout1_461ck130 FIND v(dout1_461) AT=70.025n

.meas tran vdout1_462ck130 FIND v(dout1_462) AT=70.025n

.meas tran vdout1_463ck130 FIND v(dout1_463) AT=70.025n

.meas tran vdout1_464ck130 FIND v(dout1_464) AT=70.025n

.meas tran vdout1_465ck130 FIND v(dout1_465) AT=70.025n

.meas tran vdout1_466ck130 FIND v(dout1_466) AT=70.025n

.meas tran vdout1_467ck130 FIND v(dout1_467) AT=70.025n

.meas tran vdout1_468ck130 FIND v(dout1_468) AT=70.025n

.meas tran vdout1_469ck130 FIND v(dout1_469) AT=70.025n

.meas tran vdout1_470ck130 FIND v(dout1_470) AT=70.025n

.meas tran vdout1_471ck130 FIND v(dout1_471) AT=70.025n

.meas tran vdout1_472ck130 FIND v(dout1_472) AT=70.025n

.meas tran vdout1_473ck130 FIND v(dout1_473) AT=70.025n

.meas tran vdout1_474ck130 FIND v(dout1_474) AT=70.025n

.meas tran vdout1_475ck130 FIND v(dout1_475) AT=70.025n

.meas tran vdout1_476ck130 FIND v(dout1_476) AT=70.025n

.meas tran vdout1_477ck130 FIND v(dout1_477) AT=70.025n

.meas tran vdout1_478ck130 FIND v(dout1_478) AT=70.025n

.meas tran vdout1_479ck130 FIND v(dout1_479) AT=70.025n

.meas tran vdout1_480ck130 FIND v(dout1_480) AT=70.025n

.meas tran vdout1_481ck130 FIND v(dout1_481) AT=70.025n

.meas tran vdout1_482ck130 FIND v(dout1_482) AT=70.025n

.meas tran vdout1_483ck130 FIND v(dout1_483) AT=70.025n

.meas tran vdout1_484ck130 FIND v(dout1_484) AT=70.025n

.meas tran vdout1_485ck130 FIND v(dout1_485) AT=70.025n

.meas tran vdout1_486ck130 FIND v(dout1_486) AT=70.025n

.meas tran vdout1_487ck130 FIND v(dout1_487) AT=70.025n

.meas tran vdout1_488ck130 FIND v(dout1_488) AT=70.025n

.meas tran vdout1_489ck130 FIND v(dout1_489) AT=70.025n

.meas tran vdout1_490ck130 FIND v(dout1_490) AT=70.025n

.meas tran vdout1_491ck130 FIND v(dout1_491) AT=70.025n

.meas tran vdout1_492ck130 FIND v(dout1_492) AT=70.025n

.meas tran vdout1_493ck130 FIND v(dout1_493) AT=70.025n

.meas tran vdout1_494ck130 FIND v(dout1_494) AT=70.025n

.meas tran vdout1_495ck130 FIND v(dout1_495) AT=70.025n

.meas tran vdout1_496ck130 FIND v(dout1_496) AT=70.025n

.meas tran vdout1_497ck130 FIND v(dout1_497) AT=70.025n

.meas tran vdout1_498ck130 FIND v(dout1_498) AT=70.025n

.meas tran vdout1_499ck130 FIND v(dout1_499) AT=70.025n

.meas tran vdout1_500ck130 FIND v(dout1_500) AT=70.025n

.meas tran vdout1_501ck130 FIND v(dout1_501) AT=70.025n

.meas tran vdout1_502ck130 FIND v(dout1_502) AT=70.025n

.meas tran vdout1_503ck130 FIND v(dout1_503) AT=70.025n

.meas tran vdout1_504ck130 FIND v(dout1_504) AT=70.025n

.meas tran vdout1_505ck130 FIND v(dout1_505) AT=70.025n

.meas tran vdout1_506ck130 FIND v(dout1_506) AT=70.025n

.meas tran vdout1_507ck130 FIND v(dout1_507) AT=70.025n

.meas tran vdout1_508ck130 FIND v(dout1_508) AT=70.025n

.meas tran vdout1_509ck130 FIND v(dout1_509) AT=70.025n

.meas tran vdout1_510ck130 FIND v(dout1_510) AT=70.025n

.meas tran vdout1_511ck130 FIND v(dout1_511) AT=70.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_17ck140 FIND v(dout1_17) AT=75.025n

.meas tran vdout1_18ck140 FIND v(dout1_18) AT=75.025n

.meas tran vdout1_19ck140 FIND v(dout1_19) AT=75.025n

.meas tran vdout1_20ck140 FIND v(dout1_20) AT=75.025n

.meas tran vdout1_21ck140 FIND v(dout1_21) AT=75.025n

.meas tran vdout1_22ck140 FIND v(dout1_22) AT=75.025n

.meas tran vdout1_23ck140 FIND v(dout1_23) AT=75.025n

.meas tran vdout1_24ck140 FIND v(dout1_24) AT=75.025n

.meas tran vdout1_25ck140 FIND v(dout1_25) AT=75.025n

.meas tran vdout1_26ck140 FIND v(dout1_26) AT=75.025n

.meas tran vdout1_27ck140 FIND v(dout1_27) AT=75.025n

.meas tran vdout1_28ck140 FIND v(dout1_28) AT=75.025n

.meas tran vdout1_29ck140 FIND v(dout1_29) AT=75.025n

.meas tran vdout1_30ck140 FIND v(dout1_30) AT=75.025n

.meas tran vdout1_31ck140 FIND v(dout1_31) AT=75.025n

.meas tran vdout1_32ck140 FIND v(dout1_32) AT=75.025n

.meas tran vdout1_33ck140 FIND v(dout1_33) AT=75.025n

.meas tran vdout1_34ck140 FIND v(dout1_34) AT=75.025n

.meas tran vdout1_35ck140 FIND v(dout1_35) AT=75.025n

.meas tran vdout1_36ck140 FIND v(dout1_36) AT=75.025n

.meas tran vdout1_37ck140 FIND v(dout1_37) AT=75.025n

.meas tran vdout1_38ck140 FIND v(dout1_38) AT=75.025n

.meas tran vdout1_39ck140 FIND v(dout1_39) AT=75.025n

.meas tran vdout1_40ck140 FIND v(dout1_40) AT=75.025n

.meas tran vdout1_41ck140 FIND v(dout1_41) AT=75.025n

.meas tran vdout1_42ck140 FIND v(dout1_42) AT=75.025n

.meas tran vdout1_43ck140 FIND v(dout1_43) AT=75.025n

.meas tran vdout1_44ck140 FIND v(dout1_44) AT=75.025n

.meas tran vdout1_45ck140 FIND v(dout1_45) AT=75.025n

.meas tran vdout1_46ck140 FIND v(dout1_46) AT=75.025n

.meas tran vdout1_47ck140 FIND v(dout1_47) AT=75.025n

.meas tran vdout1_48ck140 FIND v(dout1_48) AT=75.025n

.meas tran vdout1_49ck140 FIND v(dout1_49) AT=75.025n

.meas tran vdout1_50ck140 FIND v(dout1_50) AT=75.025n

.meas tran vdout1_51ck140 FIND v(dout1_51) AT=75.025n

.meas tran vdout1_52ck140 FIND v(dout1_52) AT=75.025n

.meas tran vdout1_53ck140 FIND v(dout1_53) AT=75.025n

.meas tran vdout1_54ck140 FIND v(dout1_54) AT=75.025n

.meas tran vdout1_55ck140 FIND v(dout1_55) AT=75.025n

.meas tran vdout1_56ck140 FIND v(dout1_56) AT=75.025n

.meas tran vdout1_57ck140 FIND v(dout1_57) AT=75.025n

.meas tran vdout1_58ck140 FIND v(dout1_58) AT=75.025n

.meas tran vdout1_59ck140 FIND v(dout1_59) AT=75.025n

.meas tran vdout1_60ck140 FIND v(dout1_60) AT=75.025n

.meas tran vdout1_61ck140 FIND v(dout1_61) AT=75.025n

.meas tran vdout1_62ck140 FIND v(dout1_62) AT=75.025n

.meas tran vdout1_63ck140 FIND v(dout1_63) AT=75.025n

.meas tran vdout1_64ck140 FIND v(dout1_64) AT=75.025n

.meas tran vdout1_65ck140 FIND v(dout1_65) AT=75.025n

.meas tran vdout1_66ck140 FIND v(dout1_66) AT=75.025n

.meas tran vdout1_67ck140 FIND v(dout1_67) AT=75.025n

.meas tran vdout1_68ck140 FIND v(dout1_68) AT=75.025n

.meas tran vdout1_69ck140 FIND v(dout1_69) AT=75.025n

.meas tran vdout1_70ck140 FIND v(dout1_70) AT=75.025n

.meas tran vdout1_71ck140 FIND v(dout1_71) AT=75.025n

.meas tran vdout1_72ck140 FIND v(dout1_72) AT=75.025n

.meas tran vdout1_73ck140 FIND v(dout1_73) AT=75.025n

.meas tran vdout1_74ck140 FIND v(dout1_74) AT=75.025n

.meas tran vdout1_75ck140 FIND v(dout1_75) AT=75.025n

.meas tran vdout1_76ck140 FIND v(dout1_76) AT=75.025n

.meas tran vdout1_77ck140 FIND v(dout1_77) AT=75.025n

.meas tran vdout1_78ck140 FIND v(dout1_78) AT=75.025n

.meas tran vdout1_79ck140 FIND v(dout1_79) AT=75.025n

.meas tran vdout1_80ck140 FIND v(dout1_80) AT=75.025n

.meas tran vdout1_81ck140 FIND v(dout1_81) AT=75.025n

.meas tran vdout1_82ck140 FIND v(dout1_82) AT=75.025n

.meas tran vdout1_83ck140 FIND v(dout1_83) AT=75.025n

.meas tran vdout1_84ck140 FIND v(dout1_84) AT=75.025n

.meas tran vdout1_85ck140 FIND v(dout1_85) AT=75.025n

.meas tran vdout1_86ck140 FIND v(dout1_86) AT=75.025n

.meas tran vdout1_87ck140 FIND v(dout1_87) AT=75.025n

.meas tran vdout1_88ck140 FIND v(dout1_88) AT=75.025n

.meas tran vdout1_89ck140 FIND v(dout1_89) AT=75.025n

.meas tran vdout1_90ck140 FIND v(dout1_90) AT=75.025n

.meas tran vdout1_91ck140 FIND v(dout1_91) AT=75.025n

.meas tran vdout1_92ck140 FIND v(dout1_92) AT=75.025n

.meas tran vdout1_93ck140 FIND v(dout1_93) AT=75.025n

.meas tran vdout1_94ck140 FIND v(dout1_94) AT=75.025n

.meas tran vdout1_95ck140 FIND v(dout1_95) AT=75.025n

.meas tran vdout1_96ck140 FIND v(dout1_96) AT=75.025n

.meas tran vdout1_97ck140 FIND v(dout1_97) AT=75.025n

.meas tran vdout1_98ck140 FIND v(dout1_98) AT=75.025n

.meas tran vdout1_99ck140 FIND v(dout1_99) AT=75.025n

.meas tran vdout1_100ck140 FIND v(dout1_100) AT=75.025n

.meas tran vdout1_101ck140 FIND v(dout1_101) AT=75.025n

.meas tran vdout1_102ck140 FIND v(dout1_102) AT=75.025n

.meas tran vdout1_103ck140 FIND v(dout1_103) AT=75.025n

.meas tran vdout1_104ck140 FIND v(dout1_104) AT=75.025n

.meas tran vdout1_105ck140 FIND v(dout1_105) AT=75.025n

.meas tran vdout1_106ck140 FIND v(dout1_106) AT=75.025n

.meas tran vdout1_107ck140 FIND v(dout1_107) AT=75.025n

.meas tran vdout1_108ck140 FIND v(dout1_108) AT=75.025n

.meas tran vdout1_109ck140 FIND v(dout1_109) AT=75.025n

.meas tran vdout1_110ck140 FIND v(dout1_110) AT=75.025n

.meas tran vdout1_111ck140 FIND v(dout1_111) AT=75.025n

.meas tran vdout1_112ck140 FIND v(dout1_112) AT=75.025n

.meas tran vdout1_113ck140 FIND v(dout1_113) AT=75.025n

.meas tran vdout1_114ck140 FIND v(dout1_114) AT=75.025n

.meas tran vdout1_115ck140 FIND v(dout1_115) AT=75.025n

.meas tran vdout1_116ck140 FIND v(dout1_116) AT=75.025n

.meas tran vdout1_117ck140 FIND v(dout1_117) AT=75.025n

.meas tran vdout1_118ck140 FIND v(dout1_118) AT=75.025n

.meas tran vdout1_119ck140 FIND v(dout1_119) AT=75.025n

.meas tran vdout1_120ck140 FIND v(dout1_120) AT=75.025n

.meas tran vdout1_121ck140 FIND v(dout1_121) AT=75.025n

.meas tran vdout1_122ck140 FIND v(dout1_122) AT=75.025n

.meas tran vdout1_123ck140 FIND v(dout1_123) AT=75.025n

.meas tran vdout1_124ck140 FIND v(dout1_124) AT=75.025n

.meas tran vdout1_125ck140 FIND v(dout1_125) AT=75.025n

.meas tran vdout1_126ck140 FIND v(dout1_126) AT=75.025n

.meas tran vdout1_127ck140 FIND v(dout1_127) AT=75.025n

.meas tran vdout1_128ck140 FIND v(dout1_128) AT=75.025n

.meas tran vdout1_129ck140 FIND v(dout1_129) AT=75.025n

.meas tran vdout1_130ck140 FIND v(dout1_130) AT=75.025n

.meas tran vdout1_131ck140 FIND v(dout1_131) AT=75.025n

.meas tran vdout1_132ck140 FIND v(dout1_132) AT=75.025n

.meas tran vdout1_133ck140 FIND v(dout1_133) AT=75.025n

.meas tran vdout1_134ck140 FIND v(dout1_134) AT=75.025n

.meas tran vdout1_135ck140 FIND v(dout1_135) AT=75.025n

.meas tran vdout1_136ck140 FIND v(dout1_136) AT=75.025n

.meas tran vdout1_137ck140 FIND v(dout1_137) AT=75.025n

.meas tran vdout1_138ck140 FIND v(dout1_138) AT=75.025n

.meas tran vdout1_139ck140 FIND v(dout1_139) AT=75.025n

.meas tran vdout1_140ck140 FIND v(dout1_140) AT=75.025n

.meas tran vdout1_141ck140 FIND v(dout1_141) AT=75.025n

.meas tran vdout1_142ck140 FIND v(dout1_142) AT=75.025n

.meas tran vdout1_143ck140 FIND v(dout1_143) AT=75.025n

.meas tran vdout1_144ck140 FIND v(dout1_144) AT=75.025n

.meas tran vdout1_145ck140 FIND v(dout1_145) AT=75.025n

.meas tran vdout1_146ck140 FIND v(dout1_146) AT=75.025n

.meas tran vdout1_147ck140 FIND v(dout1_147) AT=75.025n

.meas tran vdout1_148ck140 FIND v(dout1_148) AT=75.025n

.meas tran vdout1_149ck140 FIND v(dout1_149) AT=75.025n

.meas tran vdout1_150ck140 FIND v(dout1_150) AT=75.025n

.meas tran vdout1_151ck140 FIND v(dout1_151) AT=75.025n

.meas tran vdout1_152ck140 FIND v(dout1_152) AT=75.025n

.meas tran vdout1_153ck140 FIND v(dout1_153) AT=75.025n

.meas tran vdout1_154ck140 FIND v(dout1_154) AT=75.025n

.meas tran vdout1_155ck140 FIND v(dout1_155) AT=75.025n

.meas tran vdout1_156ck140 FIND v(dout1_156) AT=75.025n

.meas tran vdout1_157ck140 FIND v(dout1_157) AT=75.025n

.meas tran vdout1_158ck140 FIND v(dout1_158) AT=75.025n

.meas tran vdout1_159ck140 FIND v(dout1_159) AT=75.025n

.meas tran vdout1_160ck140 FIND v(dout1_160) AT=75.025n

.meas tran vdout1_161ck140 FIND v(dout1_161) AT=75.025n

.meas tran vdout1_162ck140 FIND v(dout1_162) AT=75.025n

.meas tran vdout1_163ck140 FIND v(dout1_163) AT=75.025n

.meas tran vdout1_164ck140 FIND v(dout1_164) AT=75.025n

.meas tran vdout1_165ck140 FIND v(dout1_165) AT=75.025n

.meas tran vdout1_166ck140 FIND v(dout1_166) AT=75.025n

.meas tran vdout1_167ck140 FIND v(dout1_167) AT=75.025n

.meas tran vdout1_168ck140 FIND v(dout1_168) AT=75.025n

.meas tran vdout1_169ck140 FIND v(dout1_169) AT=75.025n

.meas tran vdout1_170ck140 FIND v(dout1_170) AT=75.025n

.meas tran vdout1_171ck140 FIND v(dout1_171) AT=75.025n

.meas tran vdout1_172ck140 FIND v(dout1_172) AT=75.025n

.meas tran vdout1_173ck140 FIND v(dout1_173) AT=75.025n

.meas tran vdout1_174ck140 FIND v(dout1_174) AT=75.025n

.meas tran vdout1_175ck140 FIND v(dout1_175) AT=75.025n

.meas tran vdout1_176ck140 FIND v(dout1_176) AT=75.025n

.meas tran vdout1_177ck140 FIND v(dout1_177) AT=75.025n

.meas tran vdout1_178ck140 FIND v(dout1_178) AT=75.025n

.meas tran vdout1_179ck140 FIND v(dout1_179) AT=75.025n

.meas tran vdout1_180ck140 FIND v(dout1_180) AT=75.025n

.meas tran vdout1_181ck140 FIND v(dout1_181) AT=75.025n

.meas tran vdout1_182ck140 FIND v(dout1_182) AT=75.025n

.meas tran vdout1_183ck140 FIND v(dout1_183) AT=75.025n

.meas tran vdout1_184ck140 FIND v(dout1_184) AT=75.025n

.meas tran vdout1_185ck140 FIND v(dout1_185) AT=75.025n

.meas tran vdout1_186ck140 FIND v(dout1_186) AT=75.025n

.meas tran vdout1_187ck140 FIND v(dout1_187) AT=75.025n

.meas tran vdout1_188ck140 FIND v(dout1_188) AT=75.025n

.meas tran vdout1_189ck140 FIND v(dout1_189) AT=75.025n

.meas tran vdout1_190ck140 FIND v(dout1_190) AT=75.025n

.meas tran vdout1_191ck140 FIND v(dout1_191) AT=75.025n

.meas tran vdout1_192ck140 FIND v(dout1_192) AT=75.025n

.meas tran vdout1_193ck140 FIND v(dout1_193) AT=75.025n

.meas tran vdout1_194ck140 FIND v(dout1_194) AT=75.025n

.meas tran vdout1_195ck140 FIND v(dout1_195) AT=75.025n

.meas tran vdout1_196ck140 FIND v(dout1_196) AT=75.025n

.meas tran vdout1_197ck140 FIND v(dout1_197) AT=75.025n

.meas tran vdout1_198ck140 FIND v(dout1_198) AT=75.025n

.meas tran vdout1_199ck140 FIND v(dout1_199) AT=75.025n

.meas tran vdout1_200ck140 FIND v(dout1_200) AT=75.025n

.meas tran vdout1_201ck140 FIND v(dout1_201) AT=75.025n

.meas tran vdout1_202ck140 FIND v(dout1_202) AT=75.025n

.meas tran vdout1_203ck140 FIND v(dout1_203) AT=75.025n

.meas tran vdout1_204ck140 FIND v(dout1_204) AT=75.025n

.meas tran vdout1_205ck140 FIND v(dout1_205) AT=75.025n

.meas tran vdout1_206ck140 FIND v(dout1_206) AT=75.025n

.meas tran vdout1_207ck140 FIND v(dout1_207) AT=75.025n

.meas tran vdout1_208ck140 FIND v(dout1_208) AT=75.025n

.meas tran vdout1_209ck140 FIND v(dout1_209) AT=75.025n

.meas tran vdout1_210ck140 FIND v(dout1_210) AT=75.025n

.meas tran vdout1_211ck140 FIND v(dout1_211) AT=75.025n

.meas tran vdout1_212ck140 FIND v(dout1_212) AT=75.025n

.meas tran vdout1_213ck140 FIND v(dout1_213) AT=75.025n

.meas tran vdout1_214ck140 FIND v(dout1_214) AT=75.025n

.meas tran vdout1_215ck140 FIND v(dout1_215) AT=75.025n

.meas tran vdout1_216ck140 FIND v(dout1_216) AT=75.025n

.meas tran vdout1_217ck140 FIND v(dout1_217) AT=75.025n

.meas tran vdout1_218ck140 FIND v(dout1_218) AT=75.025n

.meas tran vdout1_219ck140 FIND v(dout1_219) AT=75.025n

.meas tran vdout1_220ck140 FIND v(dout1_220) AT=75.025n

.meas tran vdout1_221ck140 FIND v(dout1_221) AT=75.025n

.meas tran vdout1_222ck140 FIND v(dout1_222) AT=75.025n

.meas tran vdout1_223ck140 FIND v(dout1_223) AT=75.025n

.meas tran vdout1_224ck140 FIND v(dout1_224) AT=75.025n

.meas tran vdout1_225ck140 FIND v(dout1_225) AT=75.025n

.meas tran vdout1_226ck140 FIND v(dout1_226) AT=75.025n

.meas tran vdout1_227ck140 FIND v(dout1_227) AT=75.025n

.meas tran vdout1_228ck140 FIND v(dout1_228) AT=75.025n

.meas tran vdout1_229ck140 FIND v(dout1_229) AT=75.025n

.meas tran vdout1_230ck140 FIND v(dout1_230) AT=75.025n

.meas tran vdout1_231ck140 FIND v(dout1_231) AT=75.025n

.meas tran vdout1_232ck140 FIND v(dout1_232) AT=75.025n

.meas tran vdout1_233ck140 FIND v(dout1_233) AT=75.025n

.meas tran vdout1_234ck140 FIND v(dout1_234) AT=75.025n

.meas tran vdout1_235ck140 FIND v(dout1_235) AT=75.025n

.meas tran vdout1_236ck140 FIND v(dout1_236) AT=75.025n

.meas tran vdout1_237ck140 FIND v(dout1_237) AT=75.025n

.meas tran vdout1_238ck140 FIND v(dout1_238) AT=75.025n

.meas tran vdout1_239ck140 FIND v(dout1_239) AT=75.025n

.meas tran vdout1_240ck140 FIND v(dout1_240) AT=75.025n

.meas tran vdout1_241ck140 FIND v(dout1_241) AT=75.025n

.meas tran vdout1_242ck140 FIND v(dout1_242) AT=75.025n

.meas tran vdout1_243ck140 FIND v(dout1_243) AT=75.025n

.meas tran vdout1_244ck140 FIND v(dout1_244) AT=75.025n

.meas tran vdout1_245ck140 FIND v(dout1_245) AT=75.025n

.meas tran vdout1_246ck140 FIND v(dout1_246) AT=75.025n

.meas tran vdout1_247ck140 FIND v(dout1_247) AT=75.025n

.meas tran vdout1_248ck140 FIND v(dout1_248) AT=75.025n

.meas tran vdout1_249ck140 FIND v(dout1_249) AT=75.025n

.meas tran vdout1_250ck140 FIND v(dout1_250) AT=75.025n

.meas tran vdout1_251ck140 FIND v(dout1_251) AT=75.025n

.meas tran vdout1_252ck140 FIND v(dout1_252) AT=75.025n

.meas tran vdout1_253ck140 FIND v(dout1_253) AT=75.025n

.meas tran vdout1_254ck140 FIND v(dout1_254) AT=75.025n

.meas tran vdout1_255ck140 FIND v(dout1_255) AT=75.025n

.meas tran vdout1_256ck140 FIND v(dout1_256) AT=75.025n

.meas tran vdout1_257ck140 FIND v(dout1_257) AT=75.025n

.meas tran vdout1_258ck140 FIND v(dout1_258) AT=75.025n

.meas tran vdout1_259ck140 FIND v(dout1_259) AT=75.025n

.meas tran vdout1_260ck140 FIND v(dout1_260) AT=75.025n

.meas tran vdout1_261ck140 FIND v(dout1_261) AT=75.025n

.meas tran vdout1_262ck140 FIND v(dout1_262) AT=75.025n

.meas tran vdout1_263ck140 FIND v(dout1_263) AT=75.025n

.meas tran vdout1_264ck140 FIND v(dout1_264) AT=75.025n

.meas tran vdout1_265ck140 FIND v(dout1_265) AT=75.025n

.meas tran vdout1_266ck140 FIND v(dout1_266) AT=75.025n

.meas tran vdout1_267ck140 FIND v(dout1_267) AT=75.025n

.meas tran vdout1_268ck140 FIND v(dout1_268) AT=75.025n

.meas tran vdout1_269ck140 FIND v(dout1_269) AT=75.025n

.meas tran vdout1_270ck140 FIND v(dout1_270) AT=75.025n

.meas tran vdout1_271ck140 FIND v(dout1_271) AT=75.025n

.meas tran vdout1_272ck140 FIND v(dout1_272) AT=75.025n

.meas tran vdout1_273ck140 FIND v(dout1_273) AT=75.025n

.meas tran vdout1_274ck140 FIND v(dout1_274) AT=75.025n

.meas tran vdout1_275ck140 FIND v(dout1_275) AT=75.025n

.meas tran vdout1_276ck140 FIND v(dout1_276) AT=75.025n

.meas tran vdout1_277ck140 FIND v(dout1_277) AT=75.025n

.meas tran vdout1_278ck140 FIND v(dout1_278) AT=75.025n

.meas tran vdout1_279ck140 FIND v(dout1_279) AT=75.025n

.meas tran vdout1_280ck140 FIND v(dout1_280) AT=75.025n

.meas tran vdout1_281ck140 FIND v(dout1_281) AT=75.025n

.meas tran vdout1_282ck140 FIND v(dout1_282) AT=75.025n

.meas tran vdout1_283ck140 FIND v(dout1_283) AT=75.025n

.meas tran vdout1_284ck140 FIND v(dout1_284) AT=75.025n

.meas tran vdout1_285ck140 FIND v(dout1_285) AT=75.025n

.meas tran vdout1_286ck140 FIND v(dout1_286) AT=75.025n

.meas tran vdout1_287ck140 FIND v(dout1_287) AT=75.025n

.meas tran vdout1_288ck140 FIND v(dout1_288) AT=75.025n

.meas tran vdout1_289ck140 FIND v(dout1_289) AT=75.025n

.meas tran vdout1_290ck140 FIND v(dout1_290) AT=75.025n

.meas tran vdout1_291ck140 FIND v(dout1_291) AT=75.025n

.meas tran vdout1_292ck140 FIND v(dout1_292) AT=75.025n

.meas tran vdout1_293ck140 FIND v(dout1_293) AT=75.025n

.meas tran vdout1_294ck140 FIND v(dout1_294) AT=75.025n

.meas tran vdout1_295ck140 FIND v(dout1_295) AT=75.025n

.meas tran vdout1_296ck140 FIND v(dout1_296) AT=75.025n

.meas tran vdout1_297ck140 FIND v(dout1_297) AT=75.025n

.meas tran vdout1_298ck140 FIND v(dout1_298) AT=75.025n

.meas tran vdout1_299ck140 FIND v(dout1_299) AT=75.025n

.meas tran vdout1_300ck140 FIND v(dout1_300) AT=75.025n

.meas tran vdout1_301ck140 FIND v(dout1_301) AT=75.025n

.meas tran vdout1_302ck140 FIND v(dout1_302) AT=75.025n

.meas tran vdout1_303ck140 FIND v(dout1_303) AT=75.025n

.meas tran vdout1_304ck140 FIND v(dout1_304) AT=75.025n

.meas tran vdout1_305ck140 FIND v(dout1_305) AT=75.025n

.meas tran vdout1_306ck140 FIND v(dout1_306) AT=75.025n

.meas tran vdout1_307ck140 FIND v(dout1_307) AT=75.025n

.meas tran vdout1_308ck140 FIND v(dout1_308) AT=75.025n

.meas tran vdout1_309ck140 FIND v(dout1_309) AT=75.025n

.meas tran vdout1_310ck140 FIND v(dout1_310) AT=75.025n

.meas tran vdout1_311ck140 FIND v(dout1_311) AT=75.025n

.meas tran vdout1_312ck140 FIND v(dout1_312) AT=75.025n

.meas tran vdout1_313ck140 FIND v(dout1_313) AT=75.025n

.meas tran vdout1_314ck140 FIND v(dout1_314) AT=75.025n

.meas tran vdout1_315ck140 FIND v(dout1_315) AT=75.025n

.meas tran vdout1_316ck140 FIND v(dout1_316) AT=75.025n

.meas tran vdout1_317ck140 FIND v(dout1_317) AT=75.025n

.meas tran vdout1_318ck140 FIND v(dout1_318) AT=75.025n

.meas tran vdout1_319ck140 FIND v(dout1_319) AT=75.025n

.meas tran vdout1_320ck140 FIND v(dout1_320) AT=75.025n

.meas tran vdout1_321ck140 FIND v(dout1_321) AT=75.025n

.meas tran vdout1_322ck140 FIND v(dout1_322) AT=75.025n

.meas tran vdout1_323ck140 FIND v(dout1_323) AT=75.025n

.meas tran vdout1_324ck140 FIND v(dout1_324) AT=75.025n

.meas tran vdout1_325ck140 FIND v(dout1_325) AT=75.025n

.meas tran vdout1_326ck140 FIND v(dout1_326) AT=75.025n

.meas tran vdout1_327ck140 FIND v(dout1_327) AT=75.025n

.meas tran vdout1_328ck140 FIND v(dout1_328) AT=75.025n

.meas tran vdout1_329ck140 FIND v(dout1_329) AT=75.025n

.meas tran vdout1_330ck140 FIND v(dout1_330) AT=75.025n

.meas tran vdout1_331ck140 FIND v(dout1_331) AT=75.025n

.meas tran vdout1_332ck140 FIND v(dout1_332) AT=75.025n

.meas tran vdout1_333ck140 FIND v(dout1_333) AT=75.025n

.meas tran vdout1_334ck140 FIND v(dout1_334) AT=75.025n

.meas tran vdout1_335ck140 FIND v(dout1_335) AT=75.025n

.meas tran vdout1_336ck140 FIND v(dout1_336) AT=75.025n

.meas tran vdout1_337ck140 FIND v(dout1_337) AT=75.025n

.meas tran vdout1_338ck140 FIND v(dout1_338) AT=75.025n

.meas tran vdout1_339ck140 FIND v(dout1_339) AT=75.025n

.meas tran vdout1_340ck140 FIND v(dout1_340) AT=75.025n

.meas tran vdout1_341ck140 FIND v(dout1_341) AT=75.025n

.meas tran vdout1_342ck140 FIND v(dout1_342) AT=75.025n

.meas tran vdout1_343ck140 FIND v(dout1_343) AT=75.025n

.meas tran vdout1_344ck140 FIND v(dout1_344) AT=75.025n

.meas tran vdout1_345ck140 FIND v(dout1_345) AT=75.025n

.meas tran vdout1_346ck140 FIND v(dout1_346) AT=75.025n

.meas tran vdout1_347ck140 FIND v(dout1_347) AT=75.025n

.meas tran vdout1_348ck140 FIND v(dout1_348) AT=75.025n

.meas tran vdout1_349ck140 FIND v(dout1_349) AT=75.025n

.meas tran vdout1_350ck140 FIND v(dout1_350) AT=75.025n

.meas tran vdout1_351ck140 FIND v(dout1_351) AT=75.025n

.meas tran vdout1_352ck140 FIND v(dout1_352) AT=75.025n

.meas tran vdout1_353ck140 FIND v(dout1_353) AT=75.025n

.meas tran vdout1_354ck140 FIND v(dout1_354) AT=75.025n

.meas tran vdout1_355ck140 FIND v(dout1_355) AT=75.025n

.meas tran vdout1_356ck140 FIND v(dout1_356) AT=75.025n

.meas tran vdout1_357ck140 FIND v(dout1_357) AT=75.025n

.meas tran vdout1_358ck140 FIND v(dout1_358) AT=75.025n

.meas tran vdout1_359ck140 FIND v(dout1_359) AT=75.025n

.meas tran vdout1_360ck140 FIND v(dout1_360) AT=75.025n

.meas tran vdout1_361ck140 FIND v(dout1_361) AT=75.025n

.meas tran vdout1_362ck140 FIND v(dout1_362) AT=75.025n

.meas tran vdout1_363ck140 FIND v(dout1_363) AT=75.025n

.meas tran vdout1_364ck140 FIND v(dout1_364) AT=75.025n

.meas tran vdout1_365ck140 FIND v(dout1_365) AT=75.025n

.meas tran vdout1_366ck140 FIND v(dout1_366) AT=75.025n

.meas tran vdout1_367ck140 FIND v(dout1_367) AT=75.025n

.meas tran vdout1_368ck140 FIND v(dout1_368) AT=75.025n

.meas tran vdout1_369ck140 FIND v(dout1_369) AT=75.025n

.meas tran vdout1_370ck140 FIND v(dout1_370) AT=75.025n

.meas tran vdout1_371ck140 FIND v(dout1_371) AT=75.025n

.meas tran vdout1_372ck140 FIND v(dout1_372) AT=75.025n

.meas tran vdout1_373ck140 FIND v(dout1_373) AT=75.025n

.meas tran vdout1_374ck140 FIND v(dout1_374) AT=75.025n

.meas tran vdout1_375ck140 FIND v(dout1_375) AT=75.025n

.meas tran vdout1_376ck140 FIND v(dout1_376) AT=75.025n

.meas tran vdout1_377ck140 FIND v(dout1_377) AT=75.025n

.meas tran vdout1_378ck140 FIND v(dout1_378) AT=75.025n

.meas tran vdout1_379ck140 FIND v(dout1_379) AT=75.025n

.meas tran vdout1_380ck140 FIND v(dout1_380) AT=75.025n

.meas tran vdout1_381ck140 FIND v(dout1_381) AT=75.025n

.meas tran vdout1_382ck140 FIND v(dout1_382) AT=75.025n

.meas tran vdout1_383ck140 FIND v(dout1_383) AT=75.025n

.meas tran vdout1_384ck140 FIND v(dout1_384) AT=75.025n

.meas tran vdout1_385ck140 FIND v(dout1_385) AT=75.025n

.meas tran vdout1_386ck140 FIND v(dout1_386) AT=75.025n

.meas tran vdout1_387ck140 FIND v(dout1_387) AT=75.025n

.meas tran vdout1_388ck140 FIND v(dout1_388) AT=75.025n

.meas tran vdout1_389ck140 FIND v(dout1_389) AT=75.025n

.meas tran vdout1_390ck140 FIND v(dout1_390) AT=75.025n

.meas tran vdout1_391ck140 FIND v(dout1_391) AT=75.025n

.meas tran vdout1_392ck140 FIND v(dout1_392) AT=75.025n

.meas tran vdout1_393ck140 FIND v(dout1_393) AT=75.025n

.meas tran vdout1_394ck140 FIND v(dout1_394) AT=75.025n

.meas tran vdout1_395ck140 FIND v(dout1_395) AT=75.025n

.meas tran vdout1_396ck140 FIND v(dout1_396) AT=75.025n

.meas tran vdout1_397ck140 FIND v(dout1_397) AT=75.025n

.meas tran vdout1_398ck140 FIND v(dout1_398) AT=75.025n

.meas tran vdout1_399ck140 FIND v(dout1_399) AT=75.025n

.meas tran vdout1_400ck140 FIND v(dout1_400) AT=75.025n

.meas tran vdout1_401ck140 FIND v(dout1_401) AT=75.025n

.meas tran vdout1_402ck140 FIND v(dout1_402) AT=75.025n

.meas tran vdout1_403ck140 FIND v(dout1_403) AT=75.025n

.meas tran vdout1_404ck140 FIND v(dout1_404) AT=75.025n

.meas tran vdout1_405ck140 FIND v(dout1_405) AT=75.025n

.meas tran vdout1_406ck140 FIND v(dout1_406) AT=75.025n

.meas tran vdout1_407ck140 FIND v(dout1_407) AT=75.025n

.meas tran vdout1_408ck140 FIND v(dout1_408) AT=75.025n

.meas tran vdout1_409ck140 FIND v(dout1_409) AT=75.025n

.meas tran vdout1_410ck140 FIND v(dout1_410) AT=75.025n

.meas tran vdout1_411ck140 FIND v(dout1_411) AT=75.025n

.meas tran vdout1_412ck140 FIND v(dout1_412) AT=75.025n

.meas tran vdout1_413ck140 FIND v(dout1_413) AT=75.025n

.meas tran vdout1_414ck140 FIND v(dout1_414) AT=75.025n

.meas tran vdout1_415ck140 FIND v(dout1_415) AT=75.025n

.meas tran vdout1_416ck140 FIND v(dout1_416) AT=75.025n

.meas tran vdout1_417ck140 FIND v(dout1_417) AT=75.025n

.meas tran vdout1_418ck140 FIND v(dout1_418) AT=75.025n

.meas tran vdout1_419ck140 FIND v(dout1_419) AT=75.025n

.meas tran vdout1_420ck140 FIND v(dout1_420) AT=75.025n

.meas tran vdout1_421ck140 FIND v(dout1_421) AT=75.025n

.meas tran vdout1_422ck140 FIND v(dout1_422) AT=75.025n

.meas tran vdout1_423ck140 FIND v(dout1_423) AT=75.025n

.meas tran vdout1_424ck140 FIND v(dout1_424) AT=75.025n

.meas tran vdout1_425ck140 FIND v(dout1_425) AT=75.025n

.meas tran vdout1_426ck140 FIND v(dout1_426) AT=75.025n

.meas tran vdout1_427ck140 FIND v(dout1_427) AT=75.025n

.meas tran vdout1_428ck140 FIND v(dout1_428) AT=75.025n

.meas tran vdout1_429ck140 FIND v(dout1_429) AT=75.025n

.meas tran vdout1_430ck140 FIND v(dout1_430) AT=75.025n

.meas tran vdout1_431ck140 FIND v(dout1_431) AT=75.025n

.meas tran vdout1_432ck140 FIND v(dout1_432) AT=75.025n

.meas tran vdout1_433ck140 FIND v(dout1_433) AT=75.025n

.meas tran vdout1_434ck140 FIND v(dout1_434) AT=75.025n

.meas tran vdout1_435ck140 FIND v(dout1_435) AT=75.025n

.meas tran vdout1_436ck140 FIND v(dout1_436) AT=75.025n

.meas tran vdout1_437ck140 FIND v(dout1_437) AT=75.025n

.meas tran vdout1_438ck140 FIND v(dout1_438) AT=75.025n

.meas tran vdout1_439ck140 FIND v(dout1_439) AT=75.025n

.meas tran vdout1_440ck140 FIND v(dout1_440) AT=75.025n

.meas tran vdout1_441ck140 FIND v(dout1_441) AT=75.025n

.meas tran vdout1_442ck140 FIND v(dout1_442) AT=75.025n

.meas tran vdout1_443ck140 FIND v(dout1_443) AT=75.025n

.meas tran vdout1_444ck140 FIND v(dout1_444) AT=75.025n

.meas tran vdout1_445ck140 FIND v(dout1_445) AT=75.025n

.meas tran vdout1_446ck140 FIND v(dout1_446) AT=75.025n

.meas tran vdout1_447ck140 FIND v(dout1_447) AT=75.025n

.meas tran vdout1_448ck140 FIND v(dout1_448) AT=75.025n

.meas tran vdout1_449ck140 FIND v(dout1_449) AT=75.025n

.meas tran vdout1_450ck140 FIND v(dout1_450) AT=75.025n

.meas tran vdout1_451ck140 FIND v(dout1_451) AT=75.025n

.meas tran vdout1_452ck140 FIND v(dout1_452) AT=75.025n

.meas tran vdout1_453ck140 FIND v(dout1_453) AT=75.025n

.meas tran vdout1_454ck140 FIND v(dout1_454) AT=75.025n

.meas tran vdout1_455ck140 FIND v(dout1_455) AT=75.025n

.meas tran vdout1_456ck140 FIND v(dout1_456) AT=75.025n

.meas tran vdout1_457ck140 FIND v(dout1_457) AT=75.025n

.meas tran vdout1_458ck140 FIND v(dout1_458) AT=75.025n

.meas tran vdout1_459ck140 FIND v(dout1_459) AT=75.025n

.meas tran vdout1_460ck140 FIND v(dout1_460) AT=75.025n

.meas tran vdout1_461ck140 FIND v(dout1_461) AT=75.025n

.meas tran vdout1_462ck140 FIND v(dout1_462) AT=75.025n

.meas tran vdout1_463ck140 FIND v(dout1_463) AT=75.025n

.meas tran vdout1_464ck140 FIND v(dout1_464) AT=75.025n

.meas tran vdout1_465ck140 FIND v(dout1_465) AT=75.025n

.meas tran vdout1_466ck140 FIND v(dout1_466) AT=75.025n

.meas tran vdout1_467ck140 FIND v(dout1_467) AT=75.025n

.meas tran vdout1_468ck140 FIND v(dout1_468) AT=75.025n

.meas tran vdout1_469ck140 FIND v(dout1_469) AT=75.025n

.meas tran vdout1_470ck140 FIND v(dout1_470) AT=75.025n

.meas tran vdout1_471ck140 FIND v(dout1_471) AT=75.025n

.meas tran vdout1_472ck140 FIND v(dout1_472) AT=75.025n

.meas tran vdout1_473ck140 FIND v(dout1_473) AT=75.025n

.meas tran vdout1_474ck140 FIND v(dout1_474) AT=75.025n

.meas tran vdout1_475ck140 FIND v(dout1_475) AT=75.025n

.meas tran vdout1_476ck140 FIND v(dout1_476) AT=75.025n

.meas tran vdout1_477ck140 FIND v(dout1_477) AT=75.025n

.meas tran vdout1_478ck140 FIND v(dout1_478) AT=75.025n

.meas tran vdout1_479ck140 FIND v(dout1_479) AT=75.025n

.meas tran vdout1_480ck140 FIND v(dout1_480) AT=75.025n

.meas tran vdout1_481ck140 FIND v(dout1_481) AT=75.025n

.meas tran vdout1_482ck140 FIND v(dout1_482) AT=75.025n

.meas tran vdout1_483ck140 FIND v(dout1_483) AT=75.025n

.meas tran vdout1_484ck140 FIND v(dout1_484) AT=75.025n

.meas tran vdout1_485ck140 FIND v(dout1_485) AT=75.025n

.meas tran vdout1_486ck140 FIND v(dout1_486) AT=75.025n

.meas tran vdout1_487ck140 FIND v(dout1_487) AT=75.025n

.meas tran vdout1_488ck140 FIND v(dout1_488) AT=75.025n

.meas tran vdout1_489ck140 FIND v(dout1_489) AT=75.025n

.meas tran vdout1_490ck140 FIND v(dout1_490) AT=75.025n

.meas tran vdout1_491ck140 FIND v(dout1_491) AT=75.025n

.meas tran vdout1_492ck140 FIND v(dout1_492) AT=75.025n

.meas tran vdout1_493ck140 FIND v(dout1_493) AT=75.025n

.meas tran vdout1_494ck140 FIND v(dout1_494) AT=75.025n

.meas tran vdout1_495ck140 FIND v(dout1_495) AT=75.025n

.meas tran vdout1_496ck140 FIND v(dout1_496) AT=75.025n

.meas tran vdout1_497ck140 FIND v(dout1_497) AT=75.025n

.meas tran vdout1_498ck140 FIND v(dout1_498) AT=75.025n

.meas tran vdout1_499ck140 FIND v(dout1_499) AT=75.025n

.meas tran vdout1_500ck140 FIND v(dout1_500) AT=75.025n

.meas tran vdout1_501ck140 FIND v(dout1_501) AT=75.025n

.meas tran vdout1_502ck140 FIND v(dout1_502) AT=75.025n

.meas tran vdout1_503ck140 FIND v(dout1_503) AT=75.025n

.meas tran vdout1_504ck140 FIND v(dout1_504) AT=75.025n

.meas tran vdout1_505ck140 FIND v(dout1_505) AT=75.025n

.meas tran vdout1_506ck140 FIND v(dout1_506) AT=75.025n

.meas tran vdout1_507ck140 FIND v(dout1_507) AT=75.025n

.meas tran vdout1_508ck140 FIND v(dout1_508) AT=75.025n

.meas tran vdout1_509ck140 FIND v(dout1_509) AT=75.025n

.meas tran vdout1_510ck140 FIND v(dout1_510) AT=75.025n

.meas tran vdout1_511ck140 FIND v(dout1_511) AT=75.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_22ck180 FIND v(dout1_22) AT=95.025n

.meas tran vdout1_23ck180 FIND v(dout1_23) AT=95.025n

.meas tran vdout1_24ck180 FIND v(dout1_24) AT=95.025n

.meas tran vdout1_25ck180 FIND v(dout1_25) AT=95.025n

.meas tran vdout1_26ck180 FIND v(dout1_26) AT=95.025n

.meas tran vdout1_27ck180 FIND v(dout1_27) AT=95.025n

.meas tran vdout1_28ck180 FIND v(dout1_28) AT=95.025n

.meas tran vdout1_29ck180 FIND v(dout1_29) AT=95.025n

.meas tran vdout1_30ck180 FIND v(dout1_30) AT=95.025n

.meas tran vdout1_31ck180 FIND v(dout1_31) AT=95.025n

.meas tran vdout1_32ck180 FIND v(dout1_32) AT=95.025n

.meas tran vdout1_33ck180 FIND v(dout1_33) AT=95.025n

.meas tran vdout1_34ck180 FIND v(dout1_34) AT=95.025n

.meas tran vdout1_35ck180 FIND v(dout1_35) AT=95.025n

.meas tran vdout1_36ck180 FIND v(dout1_36) AT=95.025n

.meas tran vdout1_37ck180 FIND v(dout1_37) AT=95.025n

.meas tran vdout1_38ck180 FIND v(dout1_38) AT=95.025n

.meas tran vdout1_39ck180 FIND v(dout1_39) AT=95.025n

.meas tran vdout1_40ck180 FIND v(dout1_40) AT=95.025n

.meas tran vdout1_41ck180 FIND v(dout1_41) AT=95.025n

.meas tran vdout1_42ck180 FIND v(dout1_42) AT=95.025n

.meas tran vdout1_43ck180 FIND v(dout1_43) AT=95.025n

.meas tran vdout1_44ck180 FIND v(dout1_44) AT=95.025n

.meas tran vdout1_45ck180 FIND v(dout1_45) AT=95.025n

.meas tran vdout1_46ck180 FIND v(dout1_46) AT=95.025n

.meas tran vdout1_47ck180 FIND v(dout1_47) AT=95.025n

.meas tran vdout1_48ck180 FIND v(dout1_48) AT=95.025n

.meas tran vdout1_49ck180 FIND v(dout1_49) AT=95.025n

.meas tran vdout1_50ck180 FIND v(dout1_50) AT=95.025n

.meas tran vdout1_51ck180 FIND v(dout1_51) AT=95.025n

.meas tran vdout1_52ck180 FIND v(dout1_52) AT=95.025n

.meas tran vdout1_53ck180 FIND v(dout1_53) AT=95.025n

.meas tran vdout1_54ck180 FIND v(dout1_54) AT=95.025n

.meas tran vdout1_55ck180 FIND v(dout1_55) AT=95.025n

.meas tran vdout1_56ck180 FIND v(dout1_56) AT=95.025n

.meas tran vdout1_57ck180 FIND v(dout1_57) AT=95.025n

.meas tran vdout1_58ck180 FIND v(dout1_58) AT=95.025n

.meas tran vdout1_59ck180 FIND v(dout1_59) AT=95.025n

.meas tran vdout1_60ck180 FIND v(dout1_60) AT=95.025n

.meas tran vdout1_61ck180 FIND v(dout1_61) AT=95.025n

.meas tran vdout1_62ck180 FIND v(dout1_62) AT=95.025n

.meas tran vdout1_63ck180 FIND v(dout1_63) AT=95.025n

.meas tran vdout1_64ck180 FIND v(dout1_64) AT=95.025n

.meas tran vdout1_65ck180 FIND v(dout1_65) AT=95.025n

.meas tran vdout1_66ck180 FIND v(dout1_66) AT=95.025n

.meas tran vdout1_67ck180 FIND v(dout1_67) AT=95.025n

.meas tran vdout1_68ck180 FIND v(dout1_68) AT=95.025n

.meas tran vdout1_69ck180 FIND v(dout1_69) AT=95.025n

.meas tran vdout1_70ck180 FIND v(dout1_70) AT=95.025n

.meas tran vdout1_71ck180 FIND v(dout1_71) AT=95.025n

.meas tran vdout1_72ck180 FIND v(dout1_72) AT=95.025n

.meas tran vdout1_73ck180 FIND v(dout1_73) AT=95.025n

.meas tran vdout1_74ck180 FIND v(dout1_74) AT=95.025n

.meas tran vdout1_75ck180 FIND v(dout1_75) AT=95.025n

.meas tran vdout1_76ck180 FIND v(dout1_76) AT=95.025n

.meas tran vdout1_77ck180 FIND v(dout1_77) AT=95.025n

.meas tran vdout1_78ck180 FIND v(dout1_78) AT=95.025n

.meas tran vdout1_79ck180 FIND v(dout1_79) AT=95.025n

.meas tran vdout1_80ck180 FIND v(dout1_80) AT=95.025n

.meas tran vdout1_81ck180 FIND v(dout1_81) AT=95.025n

.meas tran vdout1_82ck180 FIND v(dout1_82) AT=95.025n

.meas tran vdout1_83ck180 FIND v(dout1_83) AT=95.025n

.meas tran vdout1_84ck180 FIND v(dout1_84) AT=95.025n

.meas tran vdout1_85ck180 FIND v(dout1_85) AT=95.025n

.meas tran vdout1_86ck180 FIND v(dout1_86) AT=95.025n

.meas tran vdout1_87ck180 FIND v(dout1_87) AT=95.025n

.meas tran vdout1_88ck180 FIND v(dout1_88) AT=95.025n

.meas tran vdout1_89ck180 FIND v(dout1_89) AT=95.025n

.meas tran vdout1_90ck180 FIND v(dout1_90) AT=95.025n

.meas tran vdout1_91ck180 FIND v(dout1_91) AT=95.025n

.meas tran vdout1_92ck180 FIND v(dout1_92) AT=95.025n

.meas tran vdout1_93ck180 FIND v(dout1_93) AT=95.025n

.meas tran vdout1_94ck180 FIND v(dout1_94) AT=95.025n

.meas tran vdout1_95ck180 FIND v(dout1_95) AT=95.025n

.meas tran vdout1_96ck180 FIND v(dout1_96) AT=95.025n

.meas tran vdout1_97ck180 FIND v(dout1_97) AT=95.025n

.meas tran vdout1_98ck180 FIND v(dout1_98) AT=95.025n

.meas tran vdout1_99ck180 FIND v(dout1_99) AT=95.025n

.meas tran vdout1_100ck180 FIND v(dout1_100) AT=95.025n

.meas tran vdout1_101ck180 FIND v(dout1_101) AT=95.025n

.meas tran vdout1_102ck180 FIND v(dout1_102) AT=95.025n

.meas tran vdout1_103ck180 FIND v(dout1_103) AT=95.025n

.meas tran vdout1_104ck180 FIND v(dout1_104) AT=95.025n

.meas tran vdout1_105ck180 FIND v(dout1_105) AT=95.025n

.meas tran vdout1_106ck180 FIND v(dout1_106) AT=95.025n

.meas tran vdout1_107ck180 FIND v(dout1_107) AT=95.025n

.meas tran vdout1_108ck180 FIND v(dout1_108) AT=95.025n

.meas tran vdout1_109ck180 FIND v(dout1_109) AT=95.025n

.meas tran vdout1_110ck180 FIND v(dout1_110) AT=95.025n

.meas tran vdout1_111ck180 FIND v(dout1_111) AT=95.025n

.meas tran vdout1_112ck180 FIND v(dout1_112) AT=95.025n

.meas tran vdout1_113ck180 FIND v(dout1_113) AT=95.025n

.meas tran vdout1_114ck180 FIND v(dout1_114) AT=95.025n

.meas tran vdout1_115ck180 FIND v(dout1_115) AT=95.025n

.meas tran vdout1_116ck180 FIND v(dout1_116) AT=95.025n

.meas tran vdout1_117ck180 FIND v(dout1_117) AT=95.025n

.meas tran vdout1_118ck180 FIND v(dout1_118) AT=95.025n

.meas tran vdout1_119ck180 FIND v(dout1_119) AT=95.025n

.meas tran vdout1_120ck180 FIND v(dout1_120) AT=95.025n

.meas tran vdout1_121ck180 FIND v(dout1_121) AT=95.025n

.meas tran vdout1_122ck180 FIND v(dout1_122) AT=95.025n

.meas tran vdout1_123ck180 FIND v(dout1_123) AT=95.025n

.meas tran vdout1_124ck180 FIND v(dout1_124) AT=95.025n

.meas tran vdout1_125ck180 FIND v(dout1_125) AT=95.025n

.meas tran vdout1_126ck180 FIND v(dout1_126) AT=95.025n

.meas tran vdout1_127ck180 FIND v(dout1_127) AT=95.025n

.meas tran vdout1_128ck180 FIND v(dout1_128) AT=95.025n

.meas tran vdout1_129ck180 FIND v(dout1_129) AT=95.025n

.meas tran vdout1_130ck180 FIND v(dout1_130) AT=95.025n

.meas tran vdout1_131ck180 FIND v(dout1_131) AT=95.025n

.meas tran vdout1_132ck180 FIND v(dout1_132) AT=95.025n

.meas tran vdout1_133ck180 FIND v(dout1_133) AT=95.025n

.meas tran vdout1_134ck180 FIND v(dout1_134) AT=95.025n

.meas tran vdout1_135ck180 FIND v(dout1_135) AT=95.025n

.meas tran vdout1_136ck180 FIND v(dout1_136) AT=95.025n

.meas tran vdout1_137ck180 FIND v(dout1_137) AT=95.025n

.meas tran vdout1_138ck180 FIND v(dout1_138) AT=95.025n

.meas tran vdout1_139ck180 FIND v(dout1_139) AT=95.025n

.meas tran vdout1_140ck180 FIND v(dout1_140) AT=95.025n

.meas tran vdout1_141ck180 FIND v(dout1_141) AT=95.025n

.meas tran vdout1_142ck180 FIND v(dout1_142) AT=95.025n

.meas tran vdout1_143ck180 FIND v(dout1_143) AT=95.025n

.meas tran vdout1_144ck180 FIND v(dout1_144) AT=95.025n

.meas tran vdout1_145ck180 FIND v(dout1_145) AT=95.025n

.meas tran vdout1_146ck180 FIND v(dout1_146) AT=95.025n

.meas tran vdout1_147ck180 FIND v(dout1_147) AT=95.025n

.meas tran vdout1_148ck180 FIND v(dout1_148) AT=95.025n

.meas tran vdout1_149ck180 FIND v(dout1_149) AT=95.025n

.meas tran vdout1_150ck180 FIND v(dout1_150) AT=95.025n

.meas tran vdout1_151ck180 FIND v(dout1_151) AT=95.025n

.meas tran vdout1_152ck180 FIND v(dout1_152) AT=95.025n

.meas tran vdout1_153ck180 FIND v(dout1_153) AT=95.025n

.meas tran vdout1_154ck180 FIND v(dout1_154) AT=95.025n

.meas tran vdout1_155ck180 FIND v(dout1_155) AT=95.025n

.meas tran vdout1_156ck180 FIND v(dout1_156) AT=95.025n

.meas tran vdout1_157ck180 FIND v(dout1_157) AT=95.025n

.meas tran vdout1_158ck180 FIND v(dout1_158) AT=95.025n

.meas tran vdout1_159ck180 FIND v(dout1_159) AT=95.025n

.meas tran vdout1_160ck180 FIND v(dout1_160) AT=95.025n

.meas tran vdout1_161ck180 FIND v(dout1_161) AT=95.025n

.meas tran vdout1_162ck180 FIND v(dout1_162) AT=95.025n

.meas tran vdout1_163ck180 FIND v(dout1_163) AT=95.025n

.meas tran vdout1_164ck180 FIND v(dout1_164) AT=95.025n

.meas tran vdout1_165ck180 FIND v(dout1_165) AT=95.025n

.meas tran vdout1_166ck180 FIND v(dout1_166) AT=95.025n

.meas tran vdout1_167ck180 FIND v(dout1_167) AT=95.025n

.meas tran vdout1_168ck180 FIND v(dout1_168) AT=95.025n

.meas tran vdout1_169ck180 FIND v(dout1_169) AT=95.025n

.meas tran vdout1_170ck180 FIND v(dout1_170) AT=95.025n

.meas tran vdout1_171ck180 FIND v(dout1_171) AT=95.025n

.meas tran vdout1_172ck180 FIND v(dout1_172) AT=95.025n

.meas tran vdout1_173ck180 FIND v(dout1_173) AT=95.025n

.meas tran vdout1_174ck180 FIND v(dout1_174) AT=95.025n

.meas tran vdout1_175ck180 FIND v(dout1_175) AT=95.025n

.meas tran vdout1_176ck180 FIND v(dout1_176) AT=95.025n

.meas tran vdout1_177ck180 FIND v(dout1_177) AT=95.025n

.meas tran vdout1_178ck180 FIND v(dout1_178) AT=95.025n

.meas tran vdout1_179ck180 FIND v(dout1_179) AT=95.025n

.meas tran vdout1_180ck180 FIND v(dout1_180) AT=95.025n

.meas tran vdout1_181ck180 FIND v(dout1_181) AT=95.025n

.meas tran vdout1_182ck180 FIND v(dout1_182) AT=95.025n

.meas tran vdout1_183ck180 FIND v(dout1_183) AT=95.025n

.meas tran vdout1_184ck180 FIND v(dout1_184) AT=95.025n

.meas tran vdout1_185ck180 FIND v(dout1_185) AT=95.025n

.meas tran vdout1_186ck180 FIND v(dout1_186) AT=95.025n

.meas tran vdout1_187ck180 FIND v(dout1_187) AT=95.025n

.meas tran vdout1_188ck180 FIND v(dout1_188) AT=95.025n

.meas tran vdout1_189ck180 FIND v(dout1_189) AT=95.025n

.meas tran vdout1_190ck180 FIND v(dout1_190) AT=95.025n

.meas tran vdout1_191ck180 FIND v(dout1_191) AT=95.025n

.meas tran vdout1_192ck180 FIND v(dout1_192) AT=95.025n

.meas tran vdout1_193ck180 FIND v(dout1_193) AT=95.025n

.meas tran vdout1_194ck180 FIND v(dout1_194) AT=95.025n

.meas tran vdout1_195ck180 FIND v(dout1_195) AT=95.025n

.meas tran vdout1_196ck180 FIND v(dout1_196) AT=95.025n

.meas tran vdout1_197ck180 FIND v(dout1_197) AT=95.025n

.meas tran vdout1_198ck180 FIND v(dout1_198) AT=95.025n

.meas tran vdout1_199ck180 FIND v(dout1_199) AT=95.025n

.meas tran vdout1_200ck180 FIND v(dout1_200) AT=95.025n

.meas tran vdout1_201ck180 FIND v(dout1_201) AT=95.025n

.meas tran vdout1_202ck180 FIND v(dout1_202) AT=95.025n

.meas tran vdout1_203ck180 FIND v(dout1_203) AT=95.025n

.meas tran vdout1_204ck180 FIND v(dout1_204) AT=95.025n

.meas tran vdout1_205ck180 FIND v(dout1_205) AT=95.025n

.meas tran vdout1_206ck180 FIND v(dout1_206) AT=95.025n

.meas tran vdout1_207ck180 FIND v(dout1_207) AT=95.025n

.meas tran vdout1_208ck180 FIND v(dout1_208) AT=95.025n

.meas tran vdout1_209ck180 FIND v(dout1_209) AT=95.025n

.meas tran vdout1_210ck180 FIND v(dout1_210) AT=95.025n

.meas tran vdout1_211ck180 FIND v(dout1_211) AT=95.025n

.meas tran vdout1_212ck180 FIND v(dout1_212) AT=95.025n

.meas tran vdout1_213ck180 FIND v(dout1_213) AT=95.025n

.meas tran vdout1_214ck180 FIND v(dout1_214) AT=95.025n

.meas tran vdout1_215ck180 FIND v(dout1_215) AT=95.025n

.meas tran vdout1_216ck180 FIND v(dout1_216) AT=95.025n

.meas tran vdout1_217ck180 FIND v(dout1_217) AT=95.025n

.meas tran vdout1_218ck180 FIND v(dout1_218) AT=95.025n

.meas tran vdout1_219ck180 FIND v(dout1_219) AT=95.025n

.meas tran vdout1_220ck180 FIND v(dout1_220) AT=95.025n

.meas tran vdout1_221ck180 FIND v(dout1_221) AT=95.025n

.meas tran vdout1_222ck180 FIND v(dout1_222) AT=95.025n

.meas tran vdout1_223ck180 FIND v(dout1_223) AT=95.025n

.meas tran vdout1_224ck180 FIND v(dout1_224) AT=95.025n

.meas tran vdout1_225ck180 FIND v(dout1_225) AT=95.025n

.meas tran vdout1_226ck180 FIND v(dout1_226) AT=95.025n

.meas tran vdout1_227ck180 FIND v(dout1_227) AT=95.025n

.meas tran vdout1_228ck180 FIND v(dout1_228) AT=95.025n

.meas tran vdout1_229ck180 FIND v(dout1_229) AT=95.025n

.meas tran vdout1_230ck180 FIND v(dout1_230) AT=95.025n

.meas tran vdout1_231ck180 FIND v(dout1_231) AT=95.025n

.meas tran vdout1_232ck180 FIND v(dout1_232) AT=95.025n

.meas tran vdout1_233ck180 FIND v(dout1_233) AT=95.025n

.meas tran vdout1_234ck180 FIND v(dout1_234) AT=95.025n

.meas tran vdout1_235ck180 FIND v(dout1_235) AT=95.025n

.meas tran vdout1_236ck180 FIND v(dout1_236) AT=95.025n

.meas tran vdout1_237ck180 FIND v(dout1_237) AT=95.025n

.meas tran vdout1_238ck180 FIND v(dout1_238) AT=95.025n

.meas tran vdout1_239ck180 FIND v(dout1_239) AT=95.025n

.meas tran vdout1_240ck180 FIND v(dout1_240) AT=95.025n

.meas tran vdout1_241ck180 FIND v(dout1_241) AT=95.025n

.meas tran vdout1_242ck180 FIND v(dout1_242) AT=95.025n

.meas tran vdout1_243ck180 FIND v(dout1_243) AT=95.025n

.meas tran vdout1_244ck180 FIND v(dout1_244) AT=95.025n

.meas tran vdout1_245ck180 FIND v(dout1_245) AT=95.025n

.meas tran vdout1_246ck180 FIND v(dout1_246) AT=95.025n

.meas tran vdout1_247ck180 FIND v(dout1_247) AT=95.025n

.meas tran vdout1_248ck180 FIND v(dout1_248) AT=95.025n

.meas tran vdout1_249ck180 FIND v(dout1_249) AT=95.025n

.meas tran vdout1_250ck180 FIND v(dout1_250) AT=95.025n

.meas tran vdout1_251ck180 FIND v(dout1_251) AT=95.025n

.meas tran vdout1_252ck180 FIND v(dout1_252) AT=95.025n

.meas tran vdout1_253ck180 FIND v(dout1_253) AT=95.025n

.meas tran vdout1_254ck180 FIND v(dout1_254) AT=95.025n

.meas tran vdout1_255ck180 FIND v(dout1_255) AT=95.025n

.meas tran vdout1_256ck180 FIND v(dout1_256) AT=95.025n

.meas tran vdout1_257ck180 FIND v(dout1_257) AT=95.025n

.meas tran vdout1_258ck180 FIND v(dout1_258) AT=95.025n

.meas tran vdout1_259ck180 FIND v(dout1_259) AT=95.025n

.meas tran vdout1_260ck180 FIND v(dout1_260) AT=95.025n

.meas tran vdout1_261ck180 FIND v(dout1_261) AT=95.025n

.meas tran vdout1_262ck180 FIND v(dout1_262) AT=95.025n

.meas tran vdout1_263ck180 FIND v(dout1_263) AT=95.025n

.meas tran vdout1_264ck180 FIND v(dout1_264) AT=95.025n

.meas tran vdout1_265ck180 FIND v(dout1_265) AT=95.025n

.meas tran vdout1_266ck180 FIND v(dout1_266) AT=95.025n

.meas tran vdout1_267ck180 FIND v(dout1_267) AT=95.025n

.meas tran vdout1_268ck180 FIND v(dout1_268) AT=95.025n

.meas tran vdout1_269ck180 FIND v(dout1_269) AT=95.025n

.meas tran vdout1_270ck180 FIND v(dout1_270) AT=95.025n

.meas tran vdout1_271ck180 FIND v(dout1_271) AT=95.025n

.meas tran vdout1_272ck180 FIND v(dout1_272) AT=95.025n

.meas tran vdout1_273ck180 FIND v(dout1_273) AT=95.025n

.meas tran vdout1_274ck180 FIND v(dout1_274) AT=95.025n

.meas tran vdout1_275ck180 FIND v(dout1_275) AT=95.025n

.meas tran vdout1_276ck180 FIND v(dout1_276) AT=95.025n

.meas tran vdout1_277ck180 FIND v(dout1_277) AT=95.025n

.meas tran vdout1_278ck180 FIND v(dout1_278) AT=95.025n

.meas tran vdout1_279ck180 FIND v(dout1_279) AT=95.025n

.meas tran vdout1_280ck180 FIND v(dout1_280) AT=95.025n

.meas tran vdout1_281ck180 FIND v(dout1_281) AT=95.025n

.meas tran vdout1_282ck180 FIND v(dout1_282) AT=95.025n

.meas tran vdout1_283ck180 FIND v(dout1_283) AT=95.025n

.meas tran vdout1_284ck180 FIND v(dout1_284) AT=95.025n

.meas tran vdout1_285ck180 FIND v(dout1_285) AT=95.025n

.meas tran vdout1_286ck180 FIND v(dout1_286) AT=95.025n

.meas tran vdout1_287ck180 FIND v(dout1_287) AT=95.025n

.meas tran vdout1_288ck180 FIND v(dout1_288) AT=95.025n

.meas tran vdout1_289ck180 FIND v(dout1_289) AT=95.025n

.meas tran vdout1_290ck180 FIND v(dout1_290) AT=95.025n

.meas tran vdout1_291ck180 FIND v(dout1_291) AT=95.025n

.meas tran vdout1_292ck180 FIND v(dout1_292) AT=95.025n

.meas tran vdout1_293ck180 FIND v(dout1_293) AT=95.025n

.meas tran vdout1_294ck180 FIND v(dout1_294) AT=95.025n

.meas tran vdout1_295ck180 FIND v(dout1_295) AT=95.025n

.meas tran vdout1_296ck180 FIND v(dout1_296) AT=95.025n

.meas tran vdout1_297ck180 FIND v(dout1_297) AT=95.025n

.meas tran vdout1_298ck180 FIND v(dout1_298) AT=95.025n

.meas tran vdout1_299ck180 FIND v(dout1_299) AT=95.025n

.meas tran vdout1_300ck180 FIND v(dout1_300) AT=95.025n

.meas tran vdout1_301ck180 FIND v(dout1_301) AT=95.025n

.meas tran vdout1_302ck180 FIND v(dout1_302) AT=95.025n

.meas tran vdout1_303ck180 FIND v(dout1_303) AT=95.025n

.meas tran vdout1_304ck180 FIND v(dout1_304) AT=95.025n

.meas tran vdout1_305ck180 FIND v(dout1_305) AT=95.025n

.meas tran vdout1_306ck180 FIND v(dout1_306) AT=95.025n

.meas tran vdout1_307ck180 FIND v(dout1_307) AT=95.025n

.meas tran vdout1_308ck180 FIND v(dout1_308) AT=95.025n

.meas tran vdout1_309ck180 FIND v(dout1_309) AT=95.025n

.meas tran vdout1_310ck180 FIND v(dout1_310) AT=95.025n

.meas tran vdout1_311ck180 FIND v(dout1_311) AT=95.025n

.meas tran vdout1_312ck180 FIND v(dout1_312) AT=95.025n

.meas tran vdout1_313ck180 FIND v(dout1_313) AT=95.025n

.meas tran vdout1_314ck180 FIND v(dout1_314) AT=95.025n

.meas tran vdout1_315ck180 FIND v(dout1_315) AT=95.025n

.meas tran vdout1_316ck180 FIND v(dout1_316) AT=95.025n

.meas tran vdout1_317ck180 FIND v(dout1_317) AT=95.025n

.meas tran vdout1_318ck180 FIND v(dout1_318) AT=95.025n

.meas tran vdout1_319ck180 FIND v(dout1_319) AT=95.025n

.meas tran vdout1_320ck180 FIND v(dout1_320) AT=95.025n

.meas tran vdout1_321ck180 FIND v(dout1_321) AT=95.025n

.meas tran vdout1_322ck180 FIND v(dout1_322) AT=95.025n

.meas tran vdout1_323ck180 FIND v(dout1_323) AT=95.025n

.meas tran vdout1_324ck180 FIND v(dout1_324) AT=95.025n

.meas tran vdout1_325ck180 FIND v(dout1_325) AT=95.025n

.meas tran vdout1_326ck180 FIND v(dout1_326) AT=95.025n

.meas tran vdout1_327ck180 FIND v(dout1_327) AT=95.025n

.meas tran vdout1_328ck180 FIND v(dout1_328) AT=95.025n

.meas tran vdout1_329ck180 FIND v(dout1_329) AT=95.025n

.meas tran vdout1_330ck180 FIND v(dout1_330) AT=95.025n

.meas tran vdout1_331ck180 FIND v(dout1_331) AT=95.025n

.meas tran vdout1_332ck180 FIND v(dout1_332) AT=95.025n

.meas tran vdout1_333ck180 FIND v(dout1_333) AT=95.025n

.meas tran vdout1_334ck180 FIND v(dout1_334) AT=95.025n

.meas tran vdout1_335ck180 FIND v(dout1_335) AT=95.025n

.meas tran vdout1_336ck180 FIND v(dout1_336) AT=95.025n

.meas tran vdout1_337ck180 FIND v(dout1_337) AT=95.025n

.meas tran vdout1_338ck180 FIND v(dout1_338) AT=95.025n

.meas tran vdout1_339ck180 FIND v(dout1_339) AT=95.025n

.meas tran vdout1_340ck180 FIND v(dout1_340) AT=95.025n

.meas tran vdout1_341ck180 FIND v(dout1_341) AT=95.025n

.meas tran vdout1_342ck180 FIND v(dout1_342) AT=95.025n

.meas tran vdout1_343ck180 FIND v(dout1_343) AT=95.025n

.meas tran vdout1_344ck180 FIND v(dout1_344) AT=95.025n

.meas tran vdout1_345ck180 FIND v(dout1_345) AT=95.025n

.meas tran vdout1_346ck180 FIND v(dout1_346) AT=95.025n

.meas tran vdout1_347ck180 FIND v(dout1_347) AT=95.025n

.meas tran vdout1_348ck180 FIND v(dout1_348) AT=95.025n

.meas tran vdout1_349ck180 FIND v(dout1_349) AT=95.025n

.meas tran vdout1_350ck180 FIND v(dout1_350) AT=95.025n

.meas tran vdout1_351ck180 FIND v(dout1_351) AT=95.025n

.meas tran vdout1_352ck180 FIND v(dout1_352) AT=95.025n

.meas tran vdout1_353ck180 FIND v(dout1_353) AT=95.025n

.meas tran vdout1_354ck180 FIND v(dout1_354) AT=95.025n

.meas tran vdout1_355ck180 FIND v(dout1_355) AT=95.025n

.meas tran vdout1_356ck180 FIND v(dout1_356) AT=95.025n

.meas tran vdout1_357ck180 FIND v(dout1_357) AT=95.025n

.meas tran vdout1_358ck180 FIND v(dout1_358) AT=95.025n

.meas tran vdout1_359ck180 FIND v(dout1_359) AT=95.025n

.meas tran vdout1_360ck180 FIND v(dout1_360) AT=95.025n

.meas tran vdout1_361ck180 FIND v(dout1_361) AT=95.025n

.meas tran vdout1_362ck180 FIND v(dout1_362) AT=95.025n

.meas tran vdout1_363ck180 FIND v(dout1_363) AT=95.025n

.meas tran vdout1_364ck180 FIND v(dout1_364) AT=95.025n

.meas tran vdout1_365ck180 FIND v(dout1_365) AT=95.025n

.meas tran vdout1_366ck180 FIND v(dout1_366) AT=95.025n

.meas tran vdout1_367ck180 FIND v(dout1_367) AT=95.025n

.meas tran vdout1_368ck180 FIND v(dout1_368) AT=95.025n

.meas tran vdout1_369ck180 FIND v(dout1_369) AT=95.025n

.meas tran vdout1_370ck180 FIND v(dout1_370) AT=95.025n

.meas tran vdout1_371ck180 FIND v(dout1_371) AT=95.025n

.meas tran vdout1_372ck180 FIND v(dout1_372) AT=95.025n

.meas tran vdout1_373ck180 FIND v(dout1_373) AT=95.025n

.meas tran vdout1_374ck180 FIND v(dout1_374) AT=95.025n

.meas tran vdout1_375ck180 FIND v(dout1_375) AT=95.025n

.meas tran vdout1_376ck180 FIND v(dout1_376) AT=95.025n

.meas tran vdout1_377ck180 FIND v(dout1_377) AT=95.025n

.meas tran vdout1_378ck180 FIND v(dout1_378) AT=95.025n

.meas tran vdout1_379ck180 FIND v(dout1_379) AT=95.025n

.meas tran vdout1_380ck180 FIND v(dout1_380) AT=95.025n

.meas tran vdout1_381ck180 FIND v(dout1_381) AT=95.025n

.meas tran vdout1_382ck180 FIND v(dout1_382) AT=95.025n

.meas tran vdout1_383ck180 FIND v(dout1_383) AT=95.025n

.meas tran vdout1_384ck180 FIND v(dout1_384) AT=95.025n

.meas tran vdout1_385ck180 FIND v(dout1_385) AT=95.025n

.meas tran vdout1_386ck180 FIND v(dout1_386) AT=95.025n

.meas tran vdout1_387ck180 FIND v(dout1_387) AT=95.025n

.meas tran vdout1_388ck180 FIND v(dout1_388) AT=95.025n

.meas tran vdout1_389ck180 FIND v(dout1_389) AT=95.025n

.meas tran vdout1_390ck180 FIND v(dout1_390) AT=95.025n

.meas tran vdout1_391ck180 FIND v(dout1_391) AT=95.025n

.meas tran vdout1_392ck180 FIND v(dout1_392) AT=95.025n

.meas tran vdout1_393ck180 FIND v(dout1_393) AT=95.025n

.meas tran vdout1_394ck180 FIND v(dout1_394) AT=95.025n

.meas tran vdout1_395ck180 FIND v(dout1_395) AT=95.025n

.meas tran vdout1_396ck180 FIND v(dout1_396) AT=95.025n

.meas tran vdout1_397ck180 FIND v(dout1_397) AT=95.025n

.meas tran vdout1_398ck180 FIND v(dout1_398) AT=95.025n

.meas tran vdout1_399ck180 FIND v(dout1_399) AT=95.025n

.meas tran vdout1_400ck180 FIND v(dout1_400) AT=95.025n

.meas tran vdout1_401ck180 FIND v(dout1_401) AT=95.025n

.meas tran vdout1_402ck180 FIND v(dout1_402) AT=95.025n

.meas tran vdout1_403ck180 FIND v(dout1_403) AT=95.025n

.meas tran vdout1_404ck180 FIND v(dout1_404) AT=95.025n

.meas tran vdout1_405ck180 FIND v(dout1_405) AT=95.025n

.meas tran vdout1_406ck180 FIND v(dout1_406) AT=95.025n

.meas tran vdout1_407ck180 FIND v(dout1_407) AT=95.025n

.meas tran vdout1_408ck180 FIND v(dout1_408) AT=95.025n

.meas tran vdout1_409ck180 FIND v(dout1_409) AT=95.025n

.meas tran vdout1_410ck180 FIND v(dout1_410) AT=95.025n

.meas tran vdout1_411ck180 FIND v(dout1_411) AT=95.025n

.meas tran vdout1_412ck180 FIND v(dout1_412) AT=95.025n

.meas tran vdout1_413ck180 FIND v(dout1_413) AT=95.025n

.meas tran vdout1_414ck180 FIND v(dout1_414) AT=95.025n

.meas tran vdout1_415ck180 FIND v(dout1_415) AT=95.025n

.meas tran vdout1_416ck180 FIND v(dout1_416) AT=95.025n

.meas tran vdout1_417ck180 FIND v(dout1_417) AT=95.025n

.meas tran vdout1_418ck180 FIND v(dout1_418) AT=95.025n

.meas tran vdout1_419ck180 FIND v(dout1_419) AT=95.025n

.meas tran vdout1_420ck180 FIND v(dout1_420) AT=95.025n

.meas tran vdout1_421ck180 FIND v(dout1_421) AT=95.025n

.meas tran vdout1_422ck180 FIND v(dout1_422) AT=95.025n

.meas tran vdout1_423ck180 FIND v(dout1_423) AT=95.025n

.meas tran vdout1_424ck180 FIND v(dout1_424) AT=95.025n

.meas tran vdout1_425ck180 FIND v(dout1_425) AT=95.025n

.meas tran vdout1_426ck180 FIND v(dout1_426) AT=95.025n

.meas tran vdout1_427ck180 FIND v(dout1_427) AT=95.025n

.meas tran vdout1_428ck180 FIND v(dout1_428) AT=95.025n

.meas tran vdout1_429ck180 FIND v(dout1_429) AT=95.025n

.meas tran vdout1_430ck180 FIND v(dout1_430) AT=95.025n

.meas tran vdout1_431ck180 FIND v(dout1_431) AT=95.025n

.meas tran vdout1_432ck180 FIND v(dout1_432) AT=95.025n

.meas tran vdout1_433ck180 FIND v(dout1_433) AT=95.025n

.meas tran vdout1_434ck180 FIND v(dout1_434) AT=95.025n

.meas tran vdout1_435ck180 FIND v(dout1_435) AT=95.025n

.meas tran vdout1_436ck180 FIND v(dout1_436) AT=95.025n

.meas tran vdout1_437ck180 FIND v(dout1_437) AT=95.025n

.meas tran vdout1_438ck180 FIND v(dout1_438) AT=95.025n

.meas tran vdout1_439ck180 FIND v(dout1_439) AT=95.025n

.meas tran vdout1_440ck180 FIND v(dout1_440) AT=95.025n

.meas tran vdout1_441ck180 FIND v(dout1_441) AT=95.025n

.meas tran vdout1_442ck180 FIND v(dout1_442) AT=95.025n

.meas tran vdout1_443ck180 FIND v(dout1_443) AT=95.025n

.meas tran vdout1_444ck180 FIND v(dout1_444) AT=95.025n

.meas tran vdout1_445ck180 FIND v(dout1_445) AT=95.025n

.meas tran vdout1_446ck180 FIND v(dout1_446) AT=95.025n

.meas tran vdout1_447ck180 FIND v(dout1_447) AT=95.025n

.meas tran vdout1_448ck180 FIND v(dout1_448) AT=95.025n

.meas tran vdout1_449ck180 FIND v(dout1_449) AT=95.025n

.meas tran vdout1_450ck180 FIND v(dout1_450) AT=95.025n

.meas tran vdout1_451ck180 FIND v(dout1_451) AT=95.025n

.meas tran vdout1_452ck180 FIND v(dout1_452) AT=95.025n

.meas tran vdout1_453ck180 FIND v(dout1_453) AT=95.025n

.meas tran vdout1_454ck180 FIND v(dout1_454) AT=95.025n

.meas tran vdout1_455ck180 FIND v(dout1_455) AT=95.025n

.meas tran vdout1_456ck180 FIND v(dout1_456) AT=95.025n

.meas tran vdout1_457ck180 FIND v(dout1_457) AT=95.025n

.meas tran vdout1_458ck180 FIND v(dout1_458) AT=95.025n

.meas tran vdout1_459ck180 FIND v(dout1_459) AT=95.025n

.meas tran vdout1_460ck180 FIND v(dout1_460) AT=95.025n

.meas tran vdout1_461ck180 FIND v(dout1_461) AT=95.025n

.meas tran vdout1_462ck180 FIND v(dout1_462) AT=95.025n

.meas tran vdout1_463ck180 FIND v(dout1_463) AT=95.025n

.meas tran vdout1_464ck180 FIND v(dout1_464) AT=95.025n

.meas tran vdout1_465ck180 FIND v(dout1_465) AT=95.025n

.meas tran vdout1_466ck180 FIND v(dout1_466) AT=95.025n

.meas tran vdout1_467ck180 FIND v(dout1_467) AT=95.025n

.meas tran vdout1_468ck180 FIND v(dout1_468) AT=95.025n

.meas tran vdout1_469ck180 FIND v(dout1_469) AT=95.025n

.meas tran vdout1_470ck180 FIND v(dout1_470) AT=95.025n

.meas tran vdout1_471ck180 FIND v(dout1_471) AT=95.025n

.meas tran vdout1_472ck180 FIND v(dout1_472) AT=95.025n

.meas tran vdout1_473ck180 FIND v(dout1_473) AT=95.025n

.meas tran vdout1_474ck180 FIND v(dout1_474) AT=95.025n

.meas tran vdout1_475ck180 FIND v(dout1_475) AT=95.025n

.meas tran vdout1_476ck180 FIND v(dout1_476) AT=95.025n

.meas tran vdout1_477ck180 FIND v(dout1_477) AT=95.025n

.meas tran vdout1_478ck180 FIND v(dout1_478) AT=95.025n

.meas tran vdout1_479ck180 FIND v(dout1_479) AT=95.025n

.meas tran vdout1_480ck180 FIND v(dout1_480) AT=95.025n

.meas tran vdout1_481ck180 FIND v(dout1_481) AT=95.025n

.meas tran vdout1_482ck180 FIND v(dout1_482) AT=95.025n

.meas tran vdout1_483ck180 FIND v(dout1_483) AT=95.025n

.meas tran vdout1_484ck180 FIND v(dout1_484) AT=95.025n

.meas tran vdout1_485ck180 FIND v(dout1_485) AT=95.025n

.meas tran vdout1_486ck180 FIND v(dout1_486) AT=95.025n

.meas tran vdout1_487ck180 FIND v(dout1_487) AT=95.025n

.meas tran vdout1_488ck180 FIND v(dout1_488) AT=95.025n

.meas tran vdout1_489ck180 FIND v(dout1_489) AT=95.025n

.meas tran vdout1_490ck180 FIND v(dout1_490) AT=95.025n

.meas tran vdout1_491ck180 FIND v(dout1_491) AT=95.025n

.meas tran vdout1_492ck180 FIND v(dout1_492) AT=95.025n

.meas tran vdout1_493ck180 FIND v(dout1_493) AT=95.025n

.meas tran vdout1_494ck180 FIND v(dout1_494) AT=95.025n

.meas tran vdout1_495ck180 FIND v(dout1_495) AT=95.025n

.meas tran vdout1_496ck180 FIND v(dout1_496) AT=95.025n

.meas tran vdout1_497ck180 FIND v(dout1_497) AT=95.025n

.meas tran vdout1_498ck180 FIND v(dout1_498) AT=95.025n

.meas tran vdout1_499ck180 FIND v(dout1_499) AT=95.025n

.meas tran vdout1_500ck180 FIND v(dout1_500) AT=95.025n

.meas tran vdout1_501ck180 FIND v(dout1_501) AT=95.025n

.meas tran vdout1_502ck180 FIND v(dout1_502) AT=95.025n

.meas tran vdout1_503ck180 FIND v(dout1_503) AT=95.025n

.meas tran vdout1_504ck180 FIND v(dout1_504) AT=95.025n

.meas tran vdout1_505ck180 FIND v(dout1_505) AT=95.025n

.meas tran vdout1_506ck180 FIND v(dout1_506) AT=95.025n

.meas tran vdout1_507ck180 FIND v(dout1_507) AT=95.025n

.meas tran vdout1_508ck180 FIND v(dout1_508) AT=95.025n

.meas tran vdout1_509ck180 FIND v(dout1_509) AT=95.025n

.meas tran vdout1_510ck180 FIND v(dout1_510) AT=95.025n

.meas tran vdout1_511ck180 FIND v(dout1_511) AT=95.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_32ck190 FIND v(dout1_32) AT=100.025n

.meas tran vdout1_33ck190 FIND v(dout1_33) AT=100.025n

.meas tran vdout1_34ck190 FIND v(dout1_34) AT=100.025n

.meas tran vdout1_35ck190 FIND v(dout1_35) AT=100.025n

.meas tran vdout1_36ck190 FIND v(dout1_36) AT=100.025n

.meas tran vdout1_37ck190 FIND v(dout1_37) AT=100.025n

.meas tran vdout1_38ck190 FIND v(dout1_38) AT=100.025n

.meas tran vdout1_39ck190 FIND v(dout1_39) AT=100.025n

.meas tran vdout1_40ck190 FIND v(dout1_40) AT=100.025n

.meas tran vdout1_41ck190 FIND v(dout1_41) AT=100.025n

.meas tran vdout1_42ck190 FIND v(dout1_42) AT=100.025n

.meas tran vdout1_43ck190 FIND v(dout1_43) AT=100.025n

.meas tran vdout1_44ck190 FIND v(dout1_44) AT=100.025n

.meas tran vdout1_45ck190 FIND v(dout1_45) AT=100.025n

.meas tran vdout1_46ck190 FIND v(dout1_46) AT=100.025n

.meas tran vdout1_47ck190 FIND v(dout1_47) AT=100.025n

.meas tran vdout1_48ck190 FIND v(dout1_48) AT=100.025n

.meas tran vdout1_49ck190 FIND v(dout1_49) AT=100.025n

.meas tran vdout1_50ck190 FIND v(dout1_50) AT=100.025n

.meas tran vdout1_51ck190 FIND v(dout1_51) AT=100.025n

.meas tran vdout1_52ck190 FIND v(dout1_52) AT=100.025n

.meas tran vdout1_53ck190 FIND v(dout1_53) AT=100.025n

.meas tran vdout1_54ck190 FIND v(dout1_54) AT=100.025n

.meas tran vdout1_55ck190 FIND v(dout1_55) AT=100.025n

.meas tran vdout1_56ck190 FIND v(dout1_56) AT=100.025n

.meas tran vdout1_57ck190 FIND v(dout1_57) AT=100.025n

.meas tran vdout1_58ck190 FIND v(dout1_58) AT=100.025n

.meas tran vdout1_59ck190 FIND v(dout1_59) AT=100.025n

.meas tran vdout1_60ck190 FIND v(dout1_60) AT=100.025n

.meas tran vdout1_61ck190 FIND v(dout1_61) AT=100.025n

.meas tran vdout1_62ck190 FIND v(dout1_62) AT=100.025n

.meas tran vdout1_63ck190 FIND v(dout1_63) AT=100.025n

.meas tran vdout1_64ck190 FIND v(dout1_64) AT=100.025n

.meas tran vdout1_65ck190 FIND v(dout1_65) AT=100.025n

.meas tran vdout1_66ck190 FIND v(dout1_66) AT=100.025n

.meas tran vdout1_67ck190 FIND v(dout1_67) AT=100.025n

.meas tran vdout1_68ck190 FIND v(dout1_68) AT=100.025n

.meas tran vdout1_69ck190 FIND v(dout1_69) AT=100.025n

.meas tran vdout1_70ck190 FIND v(dout1_70) AT=100.025n

.meas tran vdout1_71ck190 FIND v(dout1_71) AT=100.025n

.meas tran vdout1_72ck190 FIND v(dout1_72) AT=100.025n

.meas tran vdout1_73ck190 FIND v(dout1_73) AT=100.025n

.meas tran vdout1_74ck190 FIND v(dout1_74) AT=100.025n

.meas tran vdout1_75ck190 FIND v(dout1_75) AT=100.025n

.meas tran vdout1_76ck190 FIND v(dout1_76) AT=100.025n

.meas tran vdout1_77ck190 FIND v(dout1_77) AT=100.025n

.meas tran vdout1_78ck190 FIND v(dout1_78) AT=100.025n

.meas tran vdout1_79ck190 FIND v(dout1_79) AT=100.025n

.meas tran vdout1_80ck190 FIND v(dout1_80) AT=100.025n

.meas tran vdout1_81ck190 FIND v(dout1_81) AT=100.025n

.meas tran vdout1_82ck190 FIND v(dout1_82) AT=100.025n

.meas tran vdout1_83ck190 FIND v(dout1_83) AT=100.025n

.meas tran vdout1_84ck190 FIND v(dout1_84) AT=100.025n

.meas tran vdout1_85ck190 FIND v(dout1_85) AT=100.025n

.meas tran vdout1_86ck190 FIND v(dout1_86) AT=100.025n

.meas tran vdout1_87ck190 FIND v(dout1_87) AT=100.025n

.meas tran vdout1_88ck190 FIND v(dout1_88) AT=100.025n

.meas tran vdout1_89ck190 FIND v(dout1_89) AT=100.025n

.meas tran vdout1_90ck190 FIND v(dout1_90) AT=100.025n

.meas tran vdout1_91ck190 FIND v(dout1_91) AT=100.025n

.meas tran vdout1_92ck190 FIND v(dout1_92) AT=100.025n

.meas tran vdout1_93ck190 FIND v(dout1_93) AT=100.025n

.meas tran vdout1_94ck190 FIND v(dout1_94) AT=100.025n

.meas tran vdout1_95ck190 FIND v(dout1_95) AT=100.025n

.meas tran vdout1_96ck190 FIND v(dout1_96) AT=100.025n

.meas tran vdout1_97ck190 FIND v(dout1_97) AT=100.025n

.meas tran vdout1_98ck190 FIND v(dout1_98) AT=100.025n

.meas tran vdout1_99ck190 FIND v(dout1_99) AT=100.025n

.meas tran vdout1_100ck190 FIND v(dout1_100) AT=100.025n

.meas tran vdout1_101ck190 FIND v(dout1_101) AT=100.025n

.meas tran vdout1_102ck190 FIND v(dout1_102) AT=100.025n

.meas tran vdout1_103ck190 FIND v(dout1_103) AT=100.025n

.meas tran vdout1_104ck190 FIND v(dout1_104) AT=100.025n

.meas tran vdout1_105ck190 FIND v(dout1_105) AT=100.025n

.meas tran vdout1_106ck190 FIND v(dout1_106) AT=100.025n

.meas tran vdout1_107ck190 FIND v(dout1_107) AT=100.025n

.meas tran vdout1_108ck190 FIND v(dout1_108) AT=100.025n

.meas tran vdout1_109ck190 FIND v(dout1_109) AT=100.025n

.meas tran vdout1_110ck190 FIND v(dout1_110) AT=100.025n

.meas tran vdout1_111ck190 FIND v(dout1_111) AT=100.025n

.meas tran vdout1_112ck190 FIND v(dout1_112) AT=100.025n

.meas tran vdout1_113ck190 FIND v(dout1_113) AT=100.025n

.meas tran vdout1_114ck190 FIND v(dout1_114) AT=100.025n

.meas tran vdout1_115ck190 FIND v(dout1_115) AT=100.025n

.meas tran vdout1_116ck190 FIND v(dout1_116) AT=100.025n

.meas tran vdout1_117ck190 FIND v(dout1_117) AT=100.025n

.meas tran vdout1_118ck190 FIND v(dout1_118) AT=100.025n

.meas tran vdout1_119ck190 FIND v(dout1_119) AT=100.025n

.meas tran vdout1_120ck190 FIND v(dout1_120) AT=100.025n

.meas tran vdout1_121ck190 FIND v(dout1_121) AT=100.025n

.meas tran vdout1_122ck190 FIND v(dout1_122) AT=100.025n

.meas tran vdout1_123ck190 FIND v(dout1_123) AT=100.025n

.meas tran vdout1_124ck190 FIND v(dout1_124) AT=100.025n

.meas tran vdout1_125ck190 FIND v(dout1_125) AT=100.025n

.meas tran vdout1_126ck190 FIND v(dout1_126) AT=100.025n

.meas tran vdout1_127ck190 FIND v(dout1_127) AT=100.025n

.meas tran vdout1_128ck190 FIND v(dout1_128) AT=100.025n

.meas tran vdout1_129ck190 FIND v(dout1_129) AT=100.025n

.meas tran vdout1_130ck190 FIND v(dout1_130) AT=100.025n

.meas tran vdout1_131ck190 FIND v(dout1_131) AT=100.025n

.meas tran vdout1_132ck190 FIND v(dout1_132) AT=100.025n

.meas tran vdout1_133ck190 FIND v(dout1_133) AT=100.025n

.meas tran vdout1_134ck190 FIND v(dout1_134) AT=100.025n

.meas tran vdout1_135ck190 FIND v(dout1_135) AT=100.025n

.meas tran vdout1_136ck190 FIND v(dout1_136) AT=100.025n

.meas tran vdout1_137ck190 FIND v(dout1_137) AT=100.025n

.meas tran vdout1_138ck190 FIND v(dout1_138) AT=100.025n

.meas tran vdout1_139ck190 FIND v(dout1_139) AT=100.025n

.meas tran vdout1_140ck190 FIND v(dout1_140) AT=100.025n

.meas tran vdout1_141ck190 FIND v(dout1_141) AT=100.025n

.meas tran vdout1_142ck190 FIND v(dout1_142) AT=100.025n

.meas tran vdout1_143ck190 FIND v(dout1_143) AT=100.025n

.meas tran vdout1_144ck190 FIND v(dout1_144) AT=100.025n

.meas tran vdout1_145ck190 FIND v(dout1_145) AT=100.025n

.meas tran vdout1_146ck190 FIND v(dout1_146) AT=100.025n

.meas tran vdout1_147ck190 FIND v(dout1_147) AT=100.025n

.meas tran vdout1_148ck190 FIND v(dout1_148) AT=100.025n

.meas tran vdout1_149ck190 FIND v(dout1_149) AT=100.025n

.meas tran vdout1_150ck190 FIND v(dout1_150) AT=100.025n

.meas tran vdout1_151ck190 FIND v(dout1_151) AT=100.025n

.meas tran vdout1_152ck190 FIND v(dout1_152) AT=100.025n

.meas tran vdout1_153ck190 FIND v(dout1_153) AT=100.025n

.meas tran vdout1_154ck190 FIND v(dout1_154) AT=100.025n

.meas tran vdout1_155ck190 FIND v(dout1_155) AT=100.025n

.meas tran vdout1_156ck190 FIND v(dout1_156) AT=100.025n

.meas tran vdout1_157ck190 FIND v(dout1_157) AT=100.025n

.meas tran vdout1_158ck190 FIND v(dout1_158) AT=100.025n

.meas tran vdout1_159ck190 FIND v(dout1_159) AT=100.025n

.meas tran vdout1_160ck190 FIND v(dout1_160) AT=100.025n

.meas tran vdout1_161ck190 FIND v(dout1_161) AT=100.025n

.meas tran vdout1_162ck190 FIND v(dout1_162) AT=100.025n

.meas tran vdout1_163ck190 FIND v(dout1_163) AT=100.025n

.meas tran vdout1_164ck190 FIND v(dout1_164) AT=100.025n

.meas tran vdout1_165ck190 FIND v(dout1_165) AT=100.025n

.meas tran vdout1_166ck190 FIND v(dout1_166) AT=100.025n

.meas tran vdout1_167ck190 FIND v(dout1_167) AT=100.025n

.meas tran vdout1_168ck190 FIND v(dout1_168) AT=100.025n

.meas tran vdout1_169ck190 FIND v(dout1_169) AT=100.025n

.meas tran vdout1_170ck190 FIND v(dout1_170) AT=100.025n

.meas tran vdout1_171ck190 FIND v(dout1_171) AT=100.025n

.meas tran vdout1_172ck190 FIND v(dout1_172) AT=100.025n

.meas tran vdout1_173ck190 FIND v(dout1_173) AT=100.025n

.meas tran vdout1_174ck190 FIND v(dout1_174) AT=100.025n

.meas tran vdout1_175ck190 FIND v(dout1_175) AT=100.025n

.meas tran vdout1_176ck190 FIND v(dout1_176) AT=100.025n

.meas tran vdout1_177ck190 FIND v(dout1_177) AT=100.025n

.meas tran vdout1_178ck190 FIND v(dout1_178) AT=100.025n

.meas tran vdout1_179ck190 FIND v(dout1_179) AT=100.025n

.meas tran vdout1_180ck190 FIND v(dout1_180) AT=100.025n

.meas tran vdout1_181ck190 FIND v(dout1_181) AT=100.025n

.meas tran vdout1_182ck190 FIND v(dout1_182) AT=100.025n

.meas tran vdout1_183ck190 FIND v(dout1_183) AT=100.025n

.meas tran vdout1_184ck190 FIND v(dout1_184) AT=100.025n

.meas tran vdout1_185ck190 FIND v(dout1_185) AT=100.025n

.meas tran vdout1_186ck190 FIND v(dout1_186) AT=100.025n

.meas tran vdout1_187ck190 FIND v(dout1_187) AT=100.025n

.meas tran vdout1_188ck190 FIND v(dout1_188) AT=100.025n

.meas tran vdout1_189ck190 FIND v(dout1_189) AT=100.025n

.meas tran vdout1_190ck190 FIND v(dout1_190) AT=100.025n

.meas tran vdout1_191ck190 FIND v(dout1_191) AT=100.025n

.meas tran vdout1_192ck190 FIND v(dout1_192) AT=100.025n

.meas tran vdout1_193ck190 FIND v(dout1_193) AT=100.025n

.meas tran vdout1_194ck190 FIND v(dout1_194) AT=100.025n

.meas tran vdout1_195ck190 FIND v(dout1_195) AT=100.025n

.meas tran vdout1_196ck190 FIND v(dout1_196) AT=100.025n

.meas tran vdout1_197ck190 FIND v(dout1_197) AT=100.025n

.meas tran vdout1_198ck190 FIND v(dout1_198) AT=100.025n

.meas tran vdout1_199ck190 FIND v(dout1_199) AT=100.025n

.meas tran vdout1_200ck190 FIND v(dout1_200) AT=100.025n

.meas tran vdout1_201ck190 FIND v(dout1_201) AT=100.025n

.meas tran vdout1_202ck190 FIND v(dout1_202) AT=100.025n

.meas tran vdout1_203ck190 FIND v(dout1_203) AT=100.025n

.meas tran vdout1_204ck190 FIND v(dout1_204) AT=100.025n

.meas tran vdout1_205ck190 FIND v(dout1_205) AT=100.025n

.meas tran vdout1_206ck190 FIND v(dout1_206) AT=100.025n

.meas tran vdout1_207ck190 FIND v(dout1_207) AT=100.025n

.meas tran vdout1_208ck190 FIND v(dout1_208) AT=100.025n

.meas tran vdout1_209ck190 FIND v(dout1_209) AT=100.025n

.meas tran vdout1_210ck190 FIND v(dout1_210) AT=100.025n

.meas tran vdout1_211ck190 FIND v(dout1_211) AT=100.025n

.meas tran vdout1_212ck190 FIND v(dout1_212) AT=100.025n

.meas tran vdout1_213ck190 FIND v(dout1_213) AT=100.025n

.meas tran vdout1_214ck190 FIND v(dout1_214) AT=100.025n

.meas tran vdout1_215ck190 FIND v(dout1_215) AT=100.025n

.meas tran vdout1_216ck190 FIND v(dout1_216) AT=100.025n

.meas tran vdout1_217ck190 FIND v(dout1_217) AT=100.025n

.meas tran vdout1_218ck190 FIND v(dout1_218) AT=100.025n

.meas tran vdout1_219ck190 FIND v(dout1_219) AT=100.025n

.meas tran vdout1_220ck190 FIND v(dout1_220) AT=100.025n

.meas tran vdout1_221ck190 FIND v(dout1_221) AT=100.025n

.meas tran vdout1_222ck190 FIND v(dout1_222) AT=100.025n

.meas tran vdout1_223ck190 FIND v(dout1_223) AT=100.025n

.meas tran vdout1_224ck190 FIND v(dout1_224) AT=100.025n

.meas tran vdout1_225ck190 FIND v(dout1_225) AT=100.025n

.meas tran vdout1_226ck190 FIND v(dout1_226) AT=100.025n

.meas tran vdout1_227ck190 FIND v(dout1_227) AT=100.025n

.meas tran vdout1_228ck190 FIND v(dout1_228) AT=100.025n

.meas tran vdout1_229ck190 FIND v(dout1_229) AT=100.025n

.meas tran vdout1_230ck190 FIND v(dout1_230) AT=100.025n

.meas tran vdout1_231ck190 FIND v(dout1_231) AT=100.025n

.meas tran vdout1_232ck190 FIND v(dout1_232) AT=100.025n

.meas tran vdout1_233ck190 FIND v(dout1_233) AT=100.025n

.meas tran vdout1_234ck190 FIND v(dout1_234) AT=100.025n

.meas tran vdout1_235ck190 FIND v(dout1_235) AT=100.025n

.meas tran vdout1_236ck190 FIND v(dout1_236) AT=100.025n

.meas tran vdout1_237ck190 FIND v(dout1_237) AT=100.025n

.meas tran vdout1_238ck190 FIND v(dout1_238) AT=100.025n

.meas tran vdout1_239ck190 FIND v(dout1_239) AT=100.025n

.meas tran vdout1_240ck190 FIND v(dout1_240) AT=100.025n

.meas tran vdout1_241ck190 FIND v(dout1_241) AT=100.025n

.meas tran vdout1_242ck190 FIND v(dout1_242) AT=100.025n

.meas tran vdout1_243ck190 FIND v(dout1_243) AT=100.025n

.meas tran vdout1_244ck190 FIND v(dout1_244) AT=100.025n

.meas tran vdout1_245ck190 FIND v(dout1_245) AT=100.025n

.meas tran vdout1_246ck190 FIND v(dout1_246) AT=100.025n

.meas tran vdout1_247ck190 FIND v(dout1_247) AT=100.025n

.meas tran vdout1_248ck190 FIND v(dout1_248) AT=100.025n

.meas tran vdout1_249ck190 FIND v(dout1_249) AT=100.025n

.meas tran vdout1_250ck190 FIND v(dout1_250) AT=100.025n

.meas tran vdout1_251ck190 FIND v(dout1_251) AT=100.025n

.meas tran vdout1_252ck190 FIND v(dout1_252) AT=100.025n

.meas tran vdout1_253ck190 FIND v(dout1_253) AT=100.025n

.meas tran vdout1_254ck190 FIND v(dout1_254) AT=100.025n

.meas tran vdout1_255ck190 FIND v(dout1_255) AT=100.025n

.meas tran vdout1_256ck190 FIND v(dout1_256) AT=100.025n

.meas tran vdout1_257ck190 FIND v(dout1_257) AT=100.025n

.meas tran vdout1_258ck190 FIND v(dout1_258) AT=100.025n

.meas tran vdout1_259ck190 FIND v(dout1_259) AT=100.025n

.meas tran vdout1_260ck190 FIND v(dout1_260) AT=100.025n

.meas tran vdout1_261ck190 FIND v(dout1_261) AT=100.025n

.meas tran vdout1_262ck190 FIND v(dout1_262) AT=100.025n

.meas tran vdout1_263ck190 FIND v(dout1_263) AT=100.025n

.meas tran vdout1_264ck190 FIND v(dout1_264) AT=100.025n

.meas tran vdout1_265ck190 FIND v(dout1_265) AT=100.025n

.meas tran vdout1_266ck190 FIND v(dout1_266) AT=100.025n

.meas tran vdout1_267ck190 FIND v(dout1_267) AT=100.025n

.meas tran vdout1_268ck190 FIND v(dout1_268) AT=100.025n

.meas tran vdout1_269ck190 FIND v(dout1_269) AT=100.025n

.meas tran vdout1_270ck190 FIND v(dout1_270) AT=100.025n

.meas tran vdout1_271ck190 FIND v(dout1_271) AT=100.025n

.meas tran vdout1_272ck190 FIND v(dout1_272) AT=100.025n

.meas tran vdout1_273ck190 FIND v(dout1_273) AT=100.025n

.meas tran vdout1_274ck190 FIND v(dout1_274) AT=100.025n

.meas tran vdout1_275ck190 FIND v(dout1_275) AT=100.025n

.meas tran vdout1_276ck190 FIND v(dout1_276) AT=100.025n

.meas tran vdout1_277ck190 FIND v(dout1_277) AT=100.025n

.meas tran vdout1_278ck190 FIND v(dout1_278) AT=100.025n

.meas tran vdout1_279ck190 FIND v(dout1_279) AT=100.025n

.meas tran vdout1_280ck190 FIND v(dout1_280) AT=100.025n

.meas tran vdout1_281ck190 FIND v(dout1_281) AT=100.025n

.meas tran vdout1_282ck190 FIND v(dout1_282) AT=100.025n

.meas tran vdout1_283ck190 FIND v(dout1_283) AT=100.025n

.meas tran vdout1_284ck190 FIND v(dout1_284) AT=100.025n

.meas tran vdout1_285ck190 FIND v(dout1_285) AT=100.025n

.meas tran vdout1_286ck190 FIND v(dout1_286) AT=100.025n

.meas tran vdout1_287ck190 FIND v(dout1_287) AT=100.025n

.meas tran vdout1_288ck190 FIND v(dout1_288) AT=100.025n

.meas tran vdout1_289ck190 FIND v(dout1_289) AT=100.025n

.meas tran vdout1_290ck190 FIND v(dout1_290) AT=100.025n

.meas tran vdout1_291ck190 FIND v(dout1_291) AT=100.025n

.meas tran vdout1_292ck190 FIND v(dout1_292) AT=100.025n

.meas tran vdout1_293ck190 FIND v(dout1_293) AT=100.025n

.meas tran vdout1_294ck190 FIND v(dout1_294) AT=100.025n

.meas tran vdout1_295ck190 FIND v(dout1_295) AT=100.025n

.meas tran vdout1_296ck190 FIND v(dout1_296) AT=100.025n

.meas tran vdout1_297ck190 FIND v(dout1_297) AT=100.025n

.meas tran vdout1_298ck190 FIND v(dout1_298) AT=100.025n

.meas tran vdout1_299ck190 FIND v(dout1_299) AT=100.025n

.meas tran vdout1_300ck190 FIND v(dout1_300) AT=100.025n

.meas tran vdout1_301ck190 FIND v(dout1_301) AT=100.025n

.meas tran vdout1_302ck190 FIND v(dout1_302) AT=100.025n

.meas tran vdout1_303ck190 FIND v(dout1_303) AT=100.025n

.meas tran vdout1_304ck190 FIND v(dout1_304) AT=100.025n

.meas tran vdout1_305ck190 FIND v(dout1_305) AT=100.025n

.meas tran vdout1_306ck190 FIND v(dout1_306) AT=100.025n

.meas tran vdout1_307ck190 FIND v(dout1_307) AT=100.025n

.meas tran vdout1_308ck190 FIND v(dout1_308) AT=100.025n

.meas tran vdout1_309ck190 FIND v(dout1_309) AT=100.025n

.meas tran vdout1_310ck190 FIND v(dout1_310) AT=100.025n

.meas tran vdout1_311ck190 FIND v(dout1_311) AT=100.025n

.meas tran vdout1_312ck190 FIND v(dout1_312) AT=100.025n

.meas tran vdout1_313ck190 FIND v(dout1_313) AT=100.025n

.meas tran vdout1_314ck190 FIND v(dout1_314) AT=100.025n

.meas tran vdout1_315ck190 FIND v(dout1_315) AT=100.025n

.meas tran vdout1_316ck190 FIND v(dout1_316) AT=100.025n

.meas tran vdout1_317ck190 FIND v(dout1_317) AT=100.025n

.meas tran vdout1_318ck190 FIND v(dout1_318) AT=100.025n

.meas tran vdout1_319ck190 FIND v(dout1_319) AT=100.025n

.meas tran vdout1_320ck190 FIND v(dout1_320) AT=100.025n

.meas tran vdout1_321ck190 FIND v(dout1_321) AT=100.025n

.meas tran vdout1_322ck190 FIND v(dout1_322) AT=100.025n

.meas tran vdout1_323ck190 FIND v(dout1_323) AT=100.025n

.meas tran vdout1_324ck190 FIND v(dout1_324) AT=100.025n

.meas tran vdout1_325ck190 FIND v(dout1_325) AT=100.025n

.meas tran vdout1_326ck190 FIND v(dout1_326) AT=100.025n

.meas tran vdout1_327ck190 FIND v(dout1_327) AT=100.025n

.meas tran vdout1_328ck190 FIND v(dout1_328) AT=100.025n

.meas tran vdout1_329ck190 FIND v(dout1_329) AT=100.025n

.meas tran vdout1_330ck190 FIND v(dout1_330) AT=100.025n

.meas tran vdout1_331ck190 FIND v(dout1_331) AT=100.025n

.meas tran vdout1_332ck190 FIND v(dout1_332) AT=100.025n

.meas tran vdout1_333ck190 FIND v(dout1_333) AT=100.025n

.meas tran vdout1_334ck190 FIND v(dout1_334) AT=100.025n

.meas tran vdout1_335ck190 FIND v(dout1_335) AT=100.025n

.meas tran vdout1_336ck190 FIND v(dout1_336) AT=100.025n

.meas tran vdout1_337ck190 FIND v(dout1_337) AT=100.025n

.meas tran vdout1_338ck190 FIND v(dout1_338) AT=100.025n

.meas tran vdout1_339ck190 FIND v(dout1_339) AT=100.025n

.meas tran vdout1_340ck190 FIND v(dout1_340) AT=100.025n

.meas tran vdout1_341ck190 FIND v(dout1_341) AT=100.025n

.meas tran vdout1_342ck190 FIND v(dout1_342) AT=100.025n

.meas tran vdout1_343ck190 FIND v(dout1_343) AT=100.025n

.meas tran vdout1_344ck190 FIND v(dout1_344) AT=100.025n

.meas tran vdout1_345ck190 FIND v(dout1_345) AT=100.025n

.meas tran vdout1_346ck190 FIND v(dout1_346) AT=100.025n

.meas tran vdout1_347ck190 FIND v(dout1_347) AT=100.025n

.meas tran vdout1_348ck190 FIND v(dout1_348) AT=100.025n

.meas tran vdout1_349ck190 FIND v(dout1_349) AT=100.025n

.meas tran vdout1_350ck190 FIND v(dout1_350) AT=100.025n

.meas tran vdout1_351ck190 FIND v(dout1_351) AT=100.025n

.meas tran vdout1_352ck190 FIND v(dout1_352) AT=100.025n

.meas tran vdout1_353ck190 FIND v(dout1_353) AT=100.025n

.meas tran vdout1_354ck190 FIND v(dout1_354) AT=100.025n

.meas tran vdout1_355ck190 FIND v(dout1_355) AT=100.025n

.meas tran vdout1_356ck190 FIND v(dout1_356) AT=100.025n

.meas tran vdout1_357ck190 FIND v(dout1_357) AT=100.025n

.meas tran vdout1_358ck190 FIND v(dout1_358) AT=100.025n

.meas tran vdout1_359ck190 FIND v(dout1_359) AT=100.025n

.meas tran vdout1_360ck190 FIND v(dout1_360) AT=100.025n

.meas tran vdout1_361ck190 FIND v(dout1_361) AT=100.025n

.meas tran vdout1_362ck190 FIND v(dout1_362) AT=100.025n

.meas tran vdout1_363ck190 FIND v(dout1_363) AT=100.025n

.meas tran vdout1_364ck190 FIND v(dout1_364) AT=100.025n

.meas tran vdout1_365ck190 FIND v(dout1_365) AT=100.025n

.meas tran vdout1_366ck190 FIND v(dout1_366) AT=100.025n

.meas tran vdout1_367ck190 FIND v(dout1_367) AT=100.025n

.meas tran vdout1_368ck190 FIND v(dout1_368) AT=100.025n

.meas tran vdout1_369ck190 FIND v(dout1_369) AT=100.025n

.meas tran vdout1_370ck190 FIND v(dout1_370) AT=100.025n

.meas tran vdout1_371ck190 FIND v(dout1_371) AT=100.025n

.meas tran vdout1_372ck190 FIND v(dout1_372) AT=100.025n

.meas tran vdout1_373ck190 FIND v(dout1_373) AT=100.025n

.meas tran vdout1_374ck190 FIND v(dout1_374) AT=100.025n

.meas tran vdout1_375ck190 FIND v(dout1_375) AT=100.025n

.meas tran vdout1_376ck190 FIND v(dout1_376) AT=100.025n

.meas tran vdout1_377ck190 FIND v(dout1_377) AT=100.025n

.meas tran vdout1_378ck190 FIND v(dout1_378) AT=100.025n

.meas tran vdout1_379ck190 FIND v(dout1_379) AT=100.025n

.meas tran vdout1_380ck190 FIND v(dout1_380) AT=100.025n

.meas tran vdout1_381ck190 FIND v(dout1_381) AT=100.025n

.meas tran vdout1_382ck190 FIND v(dout1_382) AT=100.025n

.meas tran vdout1_383ck190 FIND v(dout1_383) AT=100.025n

.meas tran vdout1_384ck190 FIND v(dout1_384) AT=100.025n

.meas tran vdout1_385ck190 FIND v(dout1_385) AT=100.025n

.meas tran vdout1_386ck190 FIND v(dout1_386) AT=100.025n

.meas tran vdout1_387ck190 FIND v(dout1_387) AT=100.025n

.meas tran vdout1_388ck190 FIND v(dout1_388) AT=100.025n

.meas tran vdout1_389ck190 FIND v(dout1_389) AT=100.025n

.meas tran vdout1_390ck190 FIND v(dout1_390) AT=100.025n

.meas tran vdout1_391ck190 FIND v(dout1_391) AT=100.025n

.meas tran vdout1_392ck190 FIND v(dout1_392) AT=100.025n

.meas tran vdout1_393ck190 FIND v(dout1_393) AT=100.025n

.meas tran vdout1_394ck190 FIND v(dout1_394) AT=100.025n

.meas tran vdout1_395ck190 FIND v(dout1_395) AT=100.025n

.meas tran vdout1_396ck190 FIND v(dout1_396) AT=100.025n

.meas tran vdout1_397ck190 FIND v(dout1_397) AT=100.025n

.meas tran vdout1_398ck190 FIND v(dout1_398) AT=100.025n

.meas tran vdout1_399ck190 FIND v(dout1_399) AT=100.025n

.meas tran vdout1_400ck190 FIND v(dout1_400) AT=100.025n

.meas tran vdout1_401ck190 FIND v(dout1_401) AT=100.025n

.meas tran vdout1_402ck190 FIND v(dout1_402) AT=100.025n

.meas tran vdout1_403ck190 FIND v(dout1_403) AT=100.025n

.meas tran vdout1_404ck190 FIND v(dout1_404) AT=100.025n

.meas tran vdout1_405ck190 FIND v(dout1_405) AT=100.025n

.meas tran vdout1_406ck190 FIND v(dout1_406) AT=100.025n

.meas tran vdout1_407ck190 FIND v(dout1_407) AT=100.025n

.meas tran vdout1_408ck190 FIND v(dout1_408) AT=100.025n

.meas tran vdout1_409ck190 FIND v(dout1_409) AT=100.025n

.meas tran vdout1_410ck190 FIND v(dout1_410) AT=100.025n

.meas tran vdout1_411ck190 FIND v(dout1_411) AT=100.025n

.meas tran vdout1_412ck190 FIND v(dout1_412) AT=100.025n

.meas tran vdout1_413ck190 FIND v(dout1_413) AT=100.025n

.meas tran vdout1_414ck190 FIND v(dout1_414) AT=100.025n

.meas tran vdout1_415ck190 FIND v(dout1_415) AT=100.025n

.meas tran vdout1_416ck190 FIND v(dout1_416) AT=100.025n

.meas tran vdout1_417ck190 FIND v(dout1_417) AT=100.025n

.meas tran vdout1_418ck190 FIND v(dout1_418) AT=100.025n

.meas tran vdout1_419ck190 FIND v(dout1_419) AT=100.025n

.meas tran vdout1_420ck190 FIND v(dout1_420) AT=100.025n

.meas tran vdout1_421ck190 FIND v(dout1_421) AT=100.025n

.meas tran vdout1_422ck190 FIND v(dout1_422) AT=100.025n

.meas tran vdout1_423ck190 FIND v(dout1_423) AT=100.025n

.meas tran vdout1_424ck190 FIND v(dout1_424) AT=100.025n

.meas tran vdout1_425ck190 FIND v(dout1_425) AT=100.025n

.meas tran vdout1_426ck190 FIND v(dout1_426) AT=100.025n

.meas tran vdout1_427ck190 FIND v(dout1_427) AT=100.025n

.meas tran vdout1_428ck190 FIND v(dout1_428) AT=100.025n

.meas tran vdout1_429ck190 FIND v(dout1_429) AT=100.025n

.meas tran vdout1_430ck190 FIND v(dout1_430) AT=100.025n

.meas tran vdout1_431ck190 FIND v(dout1_431) AT=100.025n

.meas tran vdout1_432ck190 FIND v(dout1_432) AT=100.025n

.meas tran vdout1_433ck190 FIND v(dout1_433) AT=100.025n

.meas tran vdout1_434ck190 FIND v(dout1_434) AT=100.025n

.meas tran vdout1_435ck190 FIND v(dout1_435) AT=100.025n

.meas tran vdout1_436ck190 FIND v(dout1_436) AT=100.025n

.meas tran vdout1_437ck190 FIND v(dout1_437) AT=100.025n

.meas tran vdout1_438ck190 FIND v(dout1_438) AT=100.025n

.meas tran vdout1_439ck190 FIND v(dout1_439) AT=100.025n

.meas tran vdout1_440ck190 FIND v(dout1_440) AT=100.025n

.meas tran vdout1_441ck190 FIND v(dout1_441) AT=100.025n

.meas tran vdout1_442ck190 FIND v(dout1_442) AT=100.025n

.meas tran vdout1_443ck190 FIND v(dout1_443) AT=100.025n

.meas tran vdout1_444ck190 FIND v(dout1_444) AT=100.025n

.meas tran vdout1_445ck190 FIND v(dout1_445) AT=100.025n

.meas tran vdout1_446ck190 FIND v(dout1_446) AT=100.025n

.meas tran vdout1_447ck190 FIND v(dout1_447) AT=100.025n

.meas tran vdout1_448ck190 FIND v(dout1_448) AT=100.025n

.meas tran vdout1_449ck190 FIND v(dout1_449) AT=100.025n

.meas tran vdout1_450ck190 FIND v(dout1_450) AT=100.025n

.meas tran vdout1_451ck190 FIND v(dout1_451) AT=100.025n

.meas tran vdout1_452ck190 FIND v(dout1_452) AT=100.025n

.meas tran vdout1_453ck190 FIND v(dout1_453) AT=100.025n

.meas tran vdout1_454ck190 FIND v(dout1_454) AT=100.025n

.meas tran vdout1_455ck190 FIND v(dout1_455) AT=100.025n

.meas tran vdout1_456ck190 FIND v(dout1_456) AT=100.025n

.meas tran vdout1_457ck190 FIND v(dout1_457) AT=100.025n

.meas tran vdout1_458ck190 FIND v(dout1_458) AT=100.025n

.meas tran vdout1_459ck190 FIND v(dout1_459) AT=100.025n

.meas tran vdout1_460ck190 FIND v(dout1_460) AT=100.025n

.meas tran vdout1_461ck190 FIND v(dout1_461) AT=100.025n

.meas tran vdout1_462ck190 FIND v(dout1_462) AT=100.025n

.meas tran vdout1_463ck190 FIND v(dout1_463) AT=100.025n

.meas tran vdout1_464ck190 FIND v(dout1_464) AT=100.025n

.meas tran vdout1_465ck190 FIND v(dout1_465) AT=100.025n

.meas tran vdout1_466ck190 FIND v(dout1_466) AT=100.025n

.meas tran vdout1_467ck190 FIND v(dout1_467) AT=100.025n

.meas tran vdout1_468ck190 FIND v(dout1_468) AT=100.025n

.meas tran vdout1_469ck190 FIND v(dout1_469) AT=100.025n

.meas tran vdout1_470ck190 FIND v(dout1_470) AT=100.025n

.meas tran vdout1_471ck190 FIND v(dout1_471) AT=100.025n

.meas tran vdout1_472ck190 FIND v(dout1_472) AT=100.025n

.meas tran vdout1_473ck190 FIND v(dout1_473) AT=100.025n

.meas tran vdout1_474ck190 FIND v(dout1_474) AT=100.025n

.meas tran vdout1_475ck190 FIND v(dout1_475) AT=100.025n

.meas tran vdout1_476ck190 FIND v(dout1_476) AT=100.025n

.meas tran vdout1_477ck190 FIND v(dout1_477) AT=100.025n

.meas tran vdout1_478ck190 FIND v(dout1_478) AT=100.025n

.meas tran vdout1_479ck190 FIND v(dout1_479) AT=100.025n

.meas tran vdout1_480ck190 FIND v(dout1_480) AT=100.025n

.meas tran vdout1_481ck190 FIND v(dout1_481) AT=100.025n

.meas tran vdout1_482ck190 FIND v(dout1_482) AT=100.025n

.meas tran vdout1_483ck190 FIND v(dout1_483) AT=100.025n

.meas tran vdout1_484ck190 FIND v(dout1_484) AT=100.025n

.meas tran vdout1_485ck190 FIND v(dout1_485) AT=100.025n

.meas tran vdout1_486ck190 FIND v(dout1_486) AT=100.025n

.meas tran vdout1_487ck190 FIND v(dout1_487) AT=100.025n

.meas tran vdout1_488ck190 FIND v(dout1_488) AT=100.025n

.meas tran vdout1_489ck190 FIND v(dout1_489) AT=100.025n

.meas tran vdout1_490ck190 FIND v(dout1_490) AT=100.025n

.meas tran vdout1_491ck190 FIND v(dout1_491) AT=100.025n

.meas tran vdout1_492ck190 FIND v(dout1_492) AT=100.025n

.meas tran vdout1_493ck190 FIND v(dout1_493) AT=100.025n

.meas tran vdout1_494ck190 FIND v(dout1_494) AT=100.025n

.meas tran vdout1_495ck190 FIND v(dout1_495) AT=100.025n

.meas tran vdout1_496ck190 FIND v(dout1_496) AT=100.025n

.meas tran vdout1_497ck190 FIND v(dout1_497) AT=100.025n

.meas tran vdout1_498ck190 FIND v(dout1_498) AT=100.025n

.meas tran vdout1_499ck190 FIND v(dout1_499) AT=100.025n

.meas tran vdout1_500ck190 FIND v(dout1_500) AT=100.025n

.meas tran vdout1_501ck190 FIND v(dout1_501) AT=100.025n

.meas tran vdout1_502ck190 FIND v(dout1_502) AT=100.025n

.meas tran vdout1_503ck190 FIND v(dout1_503) AT=100.025n

.meas tran vdout1_504ck190 FIND v(dout1_504) AT=100.025n

.meas tran vdout1_505ck190 FIND v(dout1_505) AT=100.025n

.meas tran vdout1_506ck190 FIND v(dout1_506) AT=100.025n

.meas tran vdout1_507ck190 FIND v(dout1_507) AT=100.025n

.meas tran vdout1_508ck190 FIND v(dout1_508) AT=100.025n

.meas tran vdout1_509ck190 FIND v(dout1_509) AT=100.025n

.meas tran vdout1_510ck190 FIND v(dout1_510) AT=100.025n

.meas tran vdout1_511ck190 FIND v(dout1_511) AT=100.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_22ck200 FIND v(dout1_22) AT=105.025n

.meas tran vdout1_23ck200 FIND v(dout1_23) AT=105.025n

.meas tran vdout1_24ck200 FIND v(dout1_24) AT=105.025n

.meas tran vdout1_25ck200 FIND v(dout1_25) AT=105.025n

.meas tran vdout1_26ck200 FIND v(dout1_26) AT=105.025n

.meas tran vdout1_27ck200 FIND v(dout1_27) AT=105.025n

.meas tran vdout1_28ck200 FIND v(dout1_28) AT=105.025n

.meas tran vdout1_29ck200 FIND v(dout1_29) AT=105.025n

.meas tran vdout1_30ck200 FIND v(dout1_30) AT=105.025n

.meas tran vdout1_31ck200 FIND v(dout1_31) AT=105.025n

.meas tran vdout1_32ck200 FIND v(dout1_32) AT=105.025n

.meas tran vdout1_33ck200 FIND v(dout1_33) AT=105.025n

.meas tran vdout1_34ck200 FIND v(dout1_34) AT=105.025n

.meas tran vdout1_35ck200 FIND v(dout1_35) AT=105.025n

.meas tran vdout1_36ck200 FIND v(dout1_36) AT=105.025n

.meas tran vdout1_37ck200 FIND v(dout1_37) AT=105.025n

.meas tran vdout1_38ck200 FIND v(dout1_38) AT=105.025n

.meas tran vdout1_39ck200 FIND v(dout1_39) AT=105.025n

.meas tran vdout1_40ck200 FIND v(dout1_40) AT=105.025n

.meas tran vdout1_41ck200 FIND v(dout1_41) AT=105.025n

.meas tran vdout1_42ck200 FIND v(dout1_42) AT=105.025n

.meas tran vdout1_43ck200 FIND v(dout1_43) AT=105.025n

.meas tran vdout1_44ck200 FIND v(dout1_44) AT=105.025n

.meas tran vdout1_45ck200 FIND v(dout1_45) AT=105.025n

.meas tran vdout1_46ck200 FIND v(dout1_46) AT=105.025n

.meas tran vdout1_47ck200 FIND v(dout1_47) AT=105.025n

.meas tran vdout1_48ck200 FIND v(dout1_48) AT=105.025n

.meas tran vdout1_49ck200 FIND v(dout1_49) AT=105.025n

.meas tran vdout1_50ck200 FIND v(dout1_50) AT=105.025n

.meas tran vdout1_51ck200 FIND v(dout1_51) AT=105.025n

.meas tran vdout1_52ck200 FIND v(dout1_52) AT=105.025n

.meas tran vdout1_53ck200 FIND v(dout1_53) AT=105.025n

.meas tran vdout1_54ck200 FIND v(dout1_54) AT=105.025n

.meas tran vdout1_55ck200 FIND v(dout1_55) AT=105.025n

.meas tran vdout1_56ck200 FIND v(dout1_56) AT=105.025n

.meas tran vdout1_57ck200 FIND v(dout1_57) AT=105.025n

.meas tran vdout1_58ck200 FIND v(dout1_58) AT=105.025n

.meas tran vdout1_59ck200 FIND v(dout1_59) AT=105.025n

.meas tran vdout1_60ck200 FIND v(dout1_60) AT=105.025n

.meas tran vdout1_61ck200 FIND v(dout1_61) AT=105.025n

.meas tran vdout1_62ck200 FIND v(dout1_62) AT=105.025n

.meas tran vdout1_63ck200 FIND v(dout1_63) AT=105.025n

.meas tran vdout1_64ck200 FIND v(dout1_64) AT=105.025n

.meas tran vdout1_65ck200 FIND v(dout1_65) AT=105.025n

.meas tran vdout1_66ck200 FIND v(dout1_66) AT=105.025n

.meas tran vdout1_67ck200 FIND v(dout1_67) AT=105.025n

.meas tran vdout1_68ck200 FIND v(dout1_68) AT=105.025n

.meas tran vdout1_69ck200 FIND v(dout1_69) AT=105.025n

.meas tran vdout1_70ck200 FIND v(dout1_70) AT=105.025n

.meas tran vdout1_71ck200 FIND v(dout1_71) AT=105.025n

.meas tran vdout1_72ck200 FIND v(dout1_72) AT=105.025n

.meas tran vdout1_73ck200 FIND v(dout1_73) AT=105.025n

.meas tran vdout1_74ck200 FIND v(dout1_74) AT=105.025n

.meas tran vdout1_75ck200 FIND v(dout1_75) AT=105.025n

.meas tran vdout1_76ck200 FIND v(dout1_76) AT=105.025n

.meas tran vdout1_77ck200 FIND v(dout1_77) AT=105.025n

.meas tran vdout1_78ck200 FIND v(dout1_78) AT=105.025n

.meas tran vdout1_79ck200 FIND v(dout1_79) AT=105.025n

.meas tran vdout1_80ck200 FIND v(dout1_80) AT=105.025n

.meas tran vdout1_81ck200 FIND v(dout1_81) AT=105.025n

.meas tran vdout1_82ck200 FIND v(dout1_82) AT=105.025n

.meas tran vdout1_83ck200 FIND v(dout1_83) AT=105.025n

.meas tran vdout1_84ck200 FIND v(dout1_84) AT=105.025n

.meas tran vdout1_85ck200 FIND v(dout1_85) AT=105.025n

.meas tran vdout1_86ck200 FIND v(dout1_86) AT=105.025n

.meas tran vdout1_87ck200 FIND v(dout1_87) AT=105.025n

.meas tran vdout1_88ck200 FIND v(dout1_88) AT=105.025n

.meas tran vdout1_89ck200 FIND v(dout1_89) AT=105.025n

.meas tran vdout1_90ck200 FIND v(dout1_90) AT=105.025n

.meas tran vdout1_91ck200 FIND v(dout1_91) AT=105.025n

.meas tran vdout1_92ck200 FIND v(dout1_92) AT=105.025n

.meas tran vdout1_93ck200 FIND v(dout1_93) AT=105.025n

.meas tran vdout1_94ck200 FIND v(dout1_94) AT=105.025n

.meas tran vdout1_95ck200 FIND v(dout1_95) AT=105.025n

.meas tran vdout1_96ck200 FIND v(dout1_96) AT=105.025n

.meas tran vdout1_97ck200 FIND v(dout1_97) AT=105.025n

.meas tran vdout1_98ck200 FIND v(dout1_98) AT=105.025n

.meas tran vdout1_99ck200 FIND v(dout1_99) AT=105.025n

.meas tran vdout1_100ck200 FIND v(dout1_100) AT=105.025n

.meas tran vdout1_101ck200 FIND v(dout1_101) AT=105.025n

.meas tran vdout1_102ck200 FIND v(dout1_102) AT=105.025n

.meas tran vdout1_103ck200 FIND v(dout1_103) AT=105.025n

.meas tran vdout1_104ck200 FIND v(dout1_104) AT=105.025n

.meas tran vdout1_105ck200 FIND v(dout1_105) AT=105.025n

.meas tran vdout1_106ck200 FIND v(dout1_106) AT=105.025n

.meas tran vdout1_107ck200 FIND v(dout1_107) AT=105.025n

.meas tran vdout1_108ck200 FIND v(dout1_108) AT=105.025n

.meas tran vdout1_109ck200 FIND v(dout1_109) AT=105.025n

.meas tran vdout1_110ck200 FIND v(dout1_110) AT=105.025n

.meas tran vdout1_111ck200 FIND v(dout1_111) AT=105.025n

.meas tran vdout1_112ck200 FIND v(dout1_112) AT=105.025n

.meas tran vdout1_113ck200 FIND v(dout1_113) AT=105.025n

.meas tran vdout1_114ck200 FIND v(dout1_114) AT=105.025n

.meas tran vdout1_115ck200 FIND v(dout1_115) AT=105.025n

.meas tran vdout1_116ck200 FIND v(dout1_116) AT=105.025n

.meas tran vdout1_117ck200 FIND v(dout1_117) AT=105.025n

.meas tran vdout1_118ck200 FIND v(dout1_118) AT=105.025n

.meas tran vdout1_119ck200 FIND v(dout1_119) AT=105.025n

.meas tran vdout1_120ck200 FIND v(dout1_120) AT=105.025n

.meas tran vdout1_121ck200 FIND v(dout1_121) AT=105.025n

.meas tran vdout1_122ck200 FIND v(dout1_122) AT=105.025n

.meas tran vdout1_123ck200 FIND v(dout1_123) AT=105.025n

.meas tran vdout1_124ck200 FIND v(dout1_124) AT=105.025n

.meas tran vdout1_125ck200 FIND v(dout1_125) AT=105.025n

.meas tran vdout1_126ck200 FIND v(dout1_126) AT=105.025n

.meas tran vdout1_127ck200 FIND v(dout1_127) AT=105.025n

.meas tran vdout1_128ck200 FIND v(dout1_128) AT=105.025n

.meas tran vdout1_129ck200 FIND v(dout1_129) AT=105.025n

.meas tran vdout1_130ck200 FIND v(dout1_130) AT=105.025n

.meas tran vdout1_131ck200 FIND v(dout1_131) AT=105.025n

.meas tran vdout1_132ck200 FIND v(dout1_132) AT=105.025n

.meas tran vdout1_133ck200 FIND v(dout1_133) AT=105.025n

.meas tran vdout1_134ck200 FIND v(dout1_134) AT=105.025n

.meas tran vdout1_135ck200 FIND v(dout1_135) AT=105.025n

.meas tran vdout1_136ck200 FIND v(dout1_136) AT=105.025n

.meas tran vdout1_137ck200 FIND v(dout1_137) AT=105.025n

.meas tran vdout1_138ck200 FIND v(dout1_138) AT=105.025n

.meas tran vdout1_139ck200 FIND v(dout1_139) AT=105.025n

.meas tran vdout1_140ck200 FIND v(dout1_140) AT=105.025n

.meas tran vdout1_141ck200 FIND v(dout1_141) AT=105.025n

.meas tran vdout1_142ck200 FIND v(dout1_142) AT=105.025n

.meas tran vdout1_143ck200 FIND v(dout1_143) AT=105.025n

.meas tran vdout1_144ck200 FIND v(dout1_144) AT=105.025n

.meas tran vdout1_145ck200 FIND v(dout1_145) AT=105.025n

.meas tran vdout1_146ck200 FIND v(dout1_146) AT=105.025n

.meas tran vdout1_147ck200 FIND v(dout1_147) AT=105.025n

.meas tran vdout1_148ck200 FIND v(dout1_148) AT=105.025n

.meas tran vdout1_149ck200 FIND v(dout1_149) AT=105.025n

.meas tran vdout1_150ck200 FIND v(dout1_150) AT=105.025n

.meas tran vdout1_151ck200 FIND v(dout1_151) AT=105.025n

.meas tran vdout1_152ck200 FIND v(dout1_152) AT=105.025n

.meas tran vdout1_153ck200 FIND v(dout1_153) AT=105.025n

.meas tran vdout1_154ck200 FIND v(dout1_154) AT=105.025n

.meas tran vdout1_155ck200 FIND v(dout1_155) AT=105.025n

.meas tran vdout1_156ck200 FIND v(dout1_156) AT=105.025n

.meas tran vdout1_157ck200 FIND v(dout1_157) AT=105.025n

.meas tran vdout1_158ck200 FIND v(dout1_158) AT=105.025n

.meas tran vdout1_159ck200 FIND v(dout1_159) AT=105.025n

.meas tran vdout1_160ck200 FIND v(dout1_160) AT=105.025n

.meas tran vdout1_161ck200 FIND v(dout1_161) AT=105.025n

.meas tran vdout1_162ck200 FIND v(dout1_162) AT=105.025n

.meas tran vdout1_163ck200 FIND v(dout1_163) AT=105.025n

.meas tran vdout1_164ck200 FIND v(dout1_164) AT=105.025n

.meas tran vdout1_165ck200 FIND v(dout1_165) AT=105.025n

.meas tran vdout1_166ck200 FIND v(dout1_166) AT=105.025n

.meas tran vdout1_167ck200 FIND v(dout1_167) AT=105.025n

.meas tran vdout1_168ck200 FIND v(dout1_168) AT=105.025n

.meas tran vdout1_169ck200 FIND v(dout1_169) AT=105.025n

.meas tran vdout1_170ck200 FIND v(dout1_170) AT=105.025n

.meas tran vdout1_171ck200 FIND v(dout1_171) AT=105.025n

.meas tran vdout1_172ck200 FIND v(dout1_172) AT=105.025n

.meas tran vdout1_173ck200 FIND v(dout1_173) AT=105.025n

.meas tran vdout1_174ck200 FIND v(dout1_174) AT=105.025n

.meas tran vdout1_175ck200 FIND v(dout1_175) AT=105.025n

.meas tran vdout1_176ck200 FIND v(dout1_176) AT=105.025n

.meas tran vdout1_177ck200 FIND v(dout1_177) AT=105.025n

.meas tran vdout1_178ck200 FIND v(dout1_178) AT=105.025n

.meas tran vdout1_179ck200 FIND v(dout1_179) AT=105.025n

.meas tran vdout1_180ck200 FIND v(dout1_180) AT=105.025n

.meas tran vdout1_181ck200 FIND v(dout1_181) AT=105.025n

.meas tran vdout1_182ck200 FIND v(dout1_182) AT=105.025n

.meas tran vdout1_183ck200 FIND v(dout1_183) AT=105.025n

.meas tran vdout1_184ck200 FIND v(dout1_184) AT=105.025n

.meas tran vdout1_185ck200 FIND v(dout1_185) AT=105.025n

.meas tran vdout1_186ck200 FIND v(dout1_186) AT=105.025n

.meas tran vdout1_187ck200 FIND v(dout1_187) AT=105.025n

.meas tran vdout1_188ck200 FIND v(dout1_188) AT=105.025n

.meas tran vdout1_189ck200 FIND v(dout1_189) AT=105.025n

.meas tran vdout1_190ck200 FIND v(dout1_190) AT=105.025n

.meas tran vdout1_191ck200 FIND v(dout1_191) AT=105.025n

.meas tran vdout1_192ck200 FIND v(dout1_192) AT=105.025n

.meas tran vdout1_193ck200 FIND v(dout1_193) AT=105.025n

.meas tran vdout1_194ck200 FIND v(dout1_194) AT=105.025n

.meas tran vdout1_195ck200 FIND v(dout1_195) AT=105.025n

.meas tran vdout1_196ck200 FIND v(dout1_196) AT=105.025n

.meas tran vdout1_197ck200 FIND v(dout1_197) AT=105.025n

.meas tran vdout1_198ck200 FIND v(dout1_198) AT=105.025n

.meas tran vdout1_199ck200 FIND v(dout1_199) AT=105.025n

.meas tran vdout1_200ck200 FIND v(dout1_200) AT=105.025n

.meas tran vdout1_201ck200 FIND v(dout1_201) AT=105.025n

.meas tran vdout1_202ck200 FIND v(dout1_202) AT=105.025n

.meas tran vdout1_203ck200 FIND v(dout1_203) AT=105.025n

.meas tran vdout1_204ck200 FIND v(dout1_204) AT=105.025n

.meas tran vdout1_205ck200 FIND v(dout1_205) AT=105.025n

.meas tran vdout1_206ck200 FIND v(dout1_206) AT=105.025n

.meas tran vdout1_207ck200 FIND v(dout1_207) AT=105.025n

.meas tran vdout1_208ck200 FIND v(dout1_208) AT=105.025n

.meas tran vdout1_209ck200 FIND v(dout1_209) AT=105.025n

.meas tran vdout1_210ck200 FIND v(dout1_210) AT=105.025n

.meas tran vdout1_211ck200 FIND v(dout1_211) AT=105.025n

.meas tran vdout1_212ck200 FIND v(dout1_212) AT=105.025n

.meas tran vdout1_213ck200 FIND v(dout1_213) AT=105.025n

.meas tran vdout1_214ck200 FIND v(dout1_214) AT=105.025n

.meas tran vdout1_215ck200 FIND v(dout1_215) AT=105.025n

.meas tran vdout1_216ck200 FIND v(dout1_216) AT=105.025n

.meas tran vdout1_217ck200 FIND v(dout1_217) AT=105.025n

.meas tran vdout1_218ck200 FIND v(dout1_218) AT=105.025n

.meas tran vdout1_219ck200 FIND v(dout1_219) AT=105.025n

.meas tran vdout1_220ck200 FIND v(dout1_220) AT=105.025n

.meas tran vdout1_221ck200 FIND v(dout1_221) AT=105.025n

.meas tran vdout1_222ck200 FIND v(dout1_222) AT=105.025n

.meas tran vdout1_223ck200 FIND v(dout1_223) AT=105.025n

.meas tran vdout1_224ck200 FIND v(dout1_224) AT=105.025n

.meas tran vdout1_225ck200 FIND v(dout1_225) AT=105.025n

.meas tran vdout1_226ck200 FIND v(dout1_226) AT=105.025n

.meas tran vdout1_227ck200 FIND v(dout1_227) AT=105.025n

.meas tran vdout1_228ck200 FIND v(dout1_228) AT=105.025n

.meas tran vdout1_229ck200 FIND v(dout1_229) AT=105.025n

.meas tran vdout1_230ck200 FIND v(dout1_230) AT=105.025n

.meas tran vdout1_231ck200 FIND v(dout1_231) AT=105.025n

.meas tran vdout1_232ck200 FIND v(dout1_232) AT=105.025n

.meas tran vdout1_233ck200 FIND v(dout1_233) AT=105.025n

.meas tran vdout1_234ck200 FIND v(dout1_234) AT=105.025n

.meas tran vdout1_235ck200 FIND v(dout1_235) AT=105.025n

.meas tran vdout1_236ck200 FIND v(dout1_236) AT=105.025n

.meas tran vdout1_237ck200 FIND v(dout1_237) AT=105.025n

.meas tran vdout1_238ck200 FIND v(dout1_238) AT=105.025n

.meas tran vdout1_239ck200 FIND v(dout1_239) AT=105.025n

.meas tran vdout1_240ck200 FIND v(dout1_240) AT=105.025n

.meas tran vdout1_241ck200 FIND v(dout1_241) AT=105.025n

.meas tran vdout1_242ck200 FIND v(dout1_242) AT=105.025n

.meas tran vdout1_243ck200 FIND v(dout1_243) AT=105.025n

.meas tran vdout1_244ck200 FIND v(dout1_244) AT=105.025n

.meas tran vdout1_245ck200 FIND v(dout1_245) AT=105.025n

.meas tran vdout1_246ck200 FIND v(dout1_246) AT=105.025n

.meas tran vdout1_247ck200 FIND v(dout1_247) AT=105.025n

.meas tran vdout1_248ck200 FIND v(dout1_248) AT=105.025n

.meas tran vdout1_249ck200 FIND v(dout1_249) AT=105.025n

.meas tran vdout1_250ck200 FIND v(dout1_250) AT=105.025n

.meas tran vdout1_251ck200 FIND v(dout1_251) AT=105.025n

.meas tran vdout1_252ck200 FIND v(dout1_252) AT=105.025n

.meas tran vdout1_253ck200 FIND v(dout1_253) AT=105.025n

.meas tran vdout1_254ck200 FIND v(dout1_254) AT=105.025n

.meas tran vdout1_255ck200 FIND v(dout1_255) AT=105.025n

.meas tran vdout1_256ck200 FIND v(dout1_256) AT=105.025n

.meas tran vdout1_257ck200 FIND v(dout1_257) AT=105.025n

.meas tran vdout1_258ck200 FIND v(dout1_258) AT=105.025n

.meas tran vdout1_259ck200 FIND v(dout1_259) AT=105.025n

.meas tran vdout1_260ck200 FIND v(dout1_260) AT=105.025n

.meas tran vdout1_261ck200 FIND v(dout1_261) AT=105.025n

.meas tran vdout1_262ck200 FIND v(dout1_262) AT=105.025n

.meas tran vdout1_263ck200 FIND v(dout1_263) AT=105.025n

.meas tran vdout1_264ck200 FIND v(dout1_264) AT=105.025n

.meas tran vdout1_265ck200 FIND v(dout1_265) AT=105.025n

.meas tran vdout1_266ck200 FIND v(dout1_266) AT=105.025n

.meas tran vdout1_267ck200 FIND v(dout1_267) AT=105.025n

.meas tran vdout1_268ck200 FIND v(dout1_268) AT=105.025n

.meas tran vdout1_269ck200 FIND v(dout1_269) AT=105.025n

.meas tran vdout1_270ck200 FIND v(dout1_270) AT=105.025n

.meas tran vdout1_271ck200 FIND v(dout1_271) AT=105.025n

.meas tran vdout1_272ck200 FIND v(dout1_272) AT=105.025n

.meas tran vdout1_273ck200 FIND v(dout1_273) AT=105.025n

.meas tran vdout1_274ck200 FIND v(dout1_274) AT=105.025n

.meas tran vdout1_275ck200 FIND v(dout1_275) AT=105.025n

.meas tran vdout1_276ck200 FIND v(dout1_276) AT=105.025n

.meas tran vdout1_277ck200 FIND v(dout1_277) AT=105.025n

.meas tran vdout1_278ck200 FIND v(dout1_278) AT=105.025n

.meas tran vdout1_279ck200 FIND v(dout1_279) AT=105.025n

.meas tran vdout1_280ck200 FIND v(dout1_280) AT=105.025n

.meas tran vdout1_281ck200 FIND v(dout1_281) AT=105.025n

.meas tran vdout1_282ck200 FIND v(dout1_282) AT=105.025n

.meas tran vdout1_283ck200 FIND v(dout1_283) AT=105.025n

.meas tran vdout1_284ck200 FIND v(dout1_284) AT=105.025n

.meas tran vdout1_285ck200 FIND v(dout1_285) AT=105.025n

.meas tran vdout1_286ck200 FIND v(dout1_286) AT=105.025n

.meas tran vdout1_287ck200 FIND v(dout1_287) AT=105.025n

.meas tran vdout1_288ck200 FIND v(dout1_288) AT=105.025n

.meas tran vdout1_289ck200 FIND v(dout1_289) AT=105.025n

.meas tran vdout1_290ck200 FIND v(dout1_290) AT=105.025n

.meas tran vdout1_291ck200 FIND v(dout1_291) AT=105.025n

.meas tran vdout1_292ck200 FIND v(dout1_292) AT=105.025n

.meas tran vdout1_293ck200 FIND v(dout1_293) AT=105.025n

.meas tran vdout1_294ck200 FIND v(dout1_294) AT=105.025n

.meas tran vdout1_295ck200 FIND v(dout1_295) AT=105.025n

.meas tran vdout1_296ck200 FIND v(dout1_296) AT=105.025n

.meas tran vdout1_297ck200 FIND v(dout1_297) AT=105.025n

.meas tran vdout1_298ck200 FIND v(dout1_298) AT=105.025n

.meas tran vdout1_299ck200 FIND v(dout1_299) AT=105.025n

.meas tran vdout1_300ck200 FIND v(dout1_300) AT=105.025n

.meas tran vdout1_301ck200 FIND v(dout1_301) AT=105.025n

.meas tran vdout1_302ck200 FIND v(dout1_302) AT=105.025n

.meas tran vdout1_303ck200 FIND v(dout1_303) AT=105.025n

.meas tran vdout1_304ck200 FIND v(dout1_304) AT=105.025n

.meas tran vdout1_305ck200 FIND v(dout1_305) AT=105.025n

.meas tran vdout1_306ck200 FIND v(dout1_306) AT=105.025n

.meas tran vdout1_307ck200 FIND v(dout1_307) AT=105.025n

.meas tran vdout1_308ck200 FIND v(dout1_308) AT=105.025n

.meas tran vdout1_309ck200 FIND v(dout1_309) AT=105.025n

.meas tran vdout1_310ck200 FIND v(dout1_310) AT=105.025n

.meas tran vdout1_311ck200 FIND v(dout1_311) AT=105.025n

.meas tran vdout1_312ck200 FIND v(dout1_312) AT=105.025n

.meas tran vdout1_313ck200 FIND v(dout1_313) AT=105.025n

.meas tran vdout1_314ck200 FIND v(dout1_314) AT=105.025n

.meas tran vdout1_315ck200 FIND v(dout1_315) AT=105.025n

.meas tran vdout1_316ck200 FIND v(dout1_316) AT=105.025n

.meas tran vdout1_317ck200 FIND v(dout1_317) AT=105.025n

.meas tran vdout1_318ck200 FIND v(dout1_318) AT=105.025n

.meas tran vdout1_319ck200 FIND v(dout1_319) AT=105.025n

.meas tran vdout1_320ck200 FIND v(dout1_320) AT=105.025n

.meas tran vdout1_321ck200 FIND v(dout1_321) AT=105.025n

.meas tran vdout1_322ck200 FIND v(dout1_322) AT=105.025n

.meas tran vdout1_323ck200 FIND v(dout1_323) AT=105.025n

.meas tran vdout1_324ck200 FIND v(dout1_324) AT=105.025n

.meas tran vdout1_325ck200 FIND v(dout1_325) AT=105.025n

.meas tran vdout1_326ck200 FIND v(dout1_326) AT=105.025n

.meas tran vdout1_327ck200 FIND v(dout1_327) AT=105.025n

.meas tran vdout1_328ck200 FIND v(dout1_328) AT=105.025n

.meas tran vdout1_329ck200 FIND v(dout1_329) AT=105.025n

.meas tran vdout1_330ck200 FIND v(dout1_330) AT=105.025n

.meas tran vdout1_331ck200 FIND v(dout1_331) AT=105.025n

.meas tran vdout1_332ck200 FIND v(dout1_332) AT=105.025n

.meas tran vdout1_333ck200 FIND v(dout1_333) AT=105.025n

.meas tran vdout1_334ck200 FIND v(dout1_334) AT=105.025n

.meas tran vdout1_335ck200 FIND v(dout1_335) AT=105.025n

.meas tran vdout1_336ck200 FIND v(dout1_336) AT=105.025n

.meas tran vdout1_337ck200 FIND v(dout1_337) AT=105.025n

.meas tran vdout1_338ck200 FIND v(dout1_338) AT=105.025n

.meas tran vdout1_339ck200 FIND v(dout1_339) AT=105.025n

.meas tran vdout1_340ck200 FIND v(dout1_340) AT=105.025n

.meas tran vdout1_341ck200 FIND v(dout1_341) AT=105.025n

.meas tran vdout1_342ck200 FIND v(dout1_342) AT=105.025n

.meas tran vdout1_343ck200 FIND v(dout1_343) AT=105.025n

.meas tran vdout1_344ck200 FIND v(dout1_344) AT=105.025n

.meas tran vdout1_345ck200 FIND v(dout1_345) AT=105.025n

.meas tran vdout1_346ck200 FIND v(dout1_346) AT=105.025n

.meas tran vdout1_347ck200 FIND v(dout1_347) AT=105.025n

.meas tran vdout1_348ck200 FIND v(dout1_348) AT=105.025n

.meas tran vdout1_349ck200 FIND v(dout1_349) AT=105.025n

.meas tran vdout1_350ck200 FIND v(dout1_350) AT=105.025n

.meas tran vdout1_351ck200 FIND v(dout1_351) AT=105.025n

.meas tran vdout1_352ck200 FIND v(dout1_352) AT=105.025n

.meas tran vdout1_353ck200 FIND v(dout1_353) AT=105.025n

.meas tran vdout1_354ck200 FIND v(dout1_354) AT=105.025n

.meas tran vdout1_355ck200 FIND v(dout1_355) AT=105.025n

.meas tran vdout1_356ck200 FIND v(dout1_356) AT=105.025n

.meas tran vdout1_357ck200 FIND v(dout1_357) AT=105.025n

.meas tran vdout1_358ck200 FIND v(dout1_358) AT=105.025n

.meas tran vdout1_359ck200 FIND v(dout1_359) AT=105.025n

.meas tran vdout1_360ck200 FIND v(dout1_360) AT=105.025n

.meas tran vdout1_361ck200 FIND v(dout1_361) AT=105.025n

.meas tran vdout1_362ck200 FIND v(dout1_362) AT=105.025n

.meas tran vdout1_363ck200 FIND v(dout1_363) AT=105.025n

.meas tran vdout1_364ck200 FIND v(dout1_364) AT=105.025n

.meas tran vdout1_365ck200 FIND v(dout1_365) AT=105.025n

.meas tran vdout1_366ck200 FIND v(dout1_366) AT=105.025n

.meas tran vdout1_367ck200 FIND v(dout1_367) AT=105.025n

.meas tran vdout1_368ck200 FIND v(dout1_368) AT=105.025n

.meas tran vdout1_369ck200 FIND v(dout1_369) AT=105.025n

.meas tran vdout1_370ck200 FIND v(dout1_370) AT=105.025n

.meas tran vdout1_371ck200 FIND v(dout1_371) AT=105.025n

.meas tran vdout1_372ck200 FIND v(dout1_372) AT=105.025n

.meas tran vdout1_373ck200 FIND v(dout1_373) AT=105.025n

.meas tran vdout1_374ck200 FIND v(dout1_374) AT=105.025n

.meas tran vdout1_375ck200 FIND v(dout1_375) AT=105.025n

.meas tran vdout1_376ck200 FIND v(dout1_376) AT=105.025n

.meas tran vdout1_377ck200 FIND v(dout1_377) AT=105.025n

.meas tran vdout1_378ck200 FIND v(dout1_378) AT=105.025n

.meas tran vdout1_379ck200 FIND v(dout1_379) AT=105.025n

.meas tran vdout1_380ck200 FIND v(dout1_380) AT=105.025n

.meas tran vdout1_381ck200 FIND v(dout1_381) AT=105.025n

.meas tran vdout1_382ck200 FIND v(dout1_382) AT=105.025n

.meas tran vdout1_383ck200 FIND v(dout1_383) AT=105.025n

.meas tran vdout1_384ck200 FIND v(dout1_384) AT=105.025n

.meas tran vdout1_385ck200 FIND v(dout1_385) AT=105.025n

.meas tran vdout1_386ck200 FIND v(dout1_386) AT=105.025n

.meas tran vdout1_387ck200 FIND v(dout1_387) AT=105.025n

.meas tran vdout1_388ck200 FIND v(dout1_388) AT=105.025n

.meas tran vdout1_389ck200 FIND v(dout1_389) AT=105.025n

.meas tran vdout1_390ck200 FIND v(dout1_390) AT=105.025n

.meas tran vdout1_391ck200 FIND v(dout1_391) AT=105.025n

.meas tran vdout1_392ck200 FIND v(dout1_392) AT=105.025n

.meas tran vdout1_393ck200 FIND v(dout1_393) AT=105.025n

.meas tran vdout1_394ck200 FIND v(dout1_394) AT=105.025n

.meas tran vdout1_395ck200 FIND v(dout1_395) AT=105.025n

.meas tran vdout1_396ck200 FIND v(dout1_396) AT=105.025n

.meas tran vdout1_397ck200 FIND v(dout1_397) AT=105.025n

.meas tran vdout1_398ck200 FIND v(dout1_398) AT=105.025n

.meas tran vdout1_399ck200 FIND v(dout1_399) AT=105.025n

.meas tran vdout1_400ck200 FIND v(dout1_400) AT=105.025n

.meas tran vdout1_401ck200 FIND v(dout1_401) AT=105.025n

.meas tran vdout1_402ck200 FIND v(dout1_402) AT=105.025n

.meas tran vdout1_403ck200 FIND v(dout1_403) AT=105.025n

.meas tran vdout1_404ck200 FIND v(dout1_404) AT=105.025n

.meas tran vdout1_405ck200 FIND v(dout1_405) AT=105.025n

.meas tran vdout1_406ck200 FIND v(dout1_406) AT=105.025n

.meas tran vdout1_407ck200 FIND v(dout1_407) AT=105.025n

.meas tran vdout1_408ck200 FIND v(dout1_408) AT=105.025n

.meas tran vdout1_409ck200 FIND v(dout1_409) AT=105.025n

.meas tran vdout1_410ck200 FIND v(dout1_410) AT=105.025n

.meas tran vdout1_411ck200 FIND v(dout1_411) AT=105.025n

.meas tran vdout1_412ck200 FIND v(dout1_412) AT=105.025n

.meas tran vdout1_413ck200 FIND v(dout1_413) AT=105.025n

.meas tran vdout1_414ck200 FIND v(dout1_414) AT=105.025n

.meas tran vdout1_415ck200 FIND v(dout1_415) AT=105.025n

.meas tran vdout1_416ck200 FIND v(dout1_416) AT=105.025n

.meas tran vdout1_417ck200 FIND v(dout1_417) AT=105.025n

.meas tran vdout1_418ck200 FIND v(dout1_418) AT=105.025n

.meas tran vdout1_419ck200 FIND v(dout1_419) AT=105.025n

.meas tran vdout1_420ck200 FIND v(dout1_420) AT=105.025n

.meas tran vdout1_421ck200 FIND v(dout1_421) AT=105.025n

.meas tran vdout1_422ck200 FIND v(dout1_422) AT=105.025n

.meas tran vdout1_423ck200 FIND v(dout1_423) AT=105.025n

.meas tran vdout1_424ck200 FIND v(dout1_424) AT=105.025n

.meas tran vdout1_425ck200 FIND v(dout1_425) AT=105.025n

.meas tran vdout1_426ck200 FIND v(dout1_426) AT=105.025n

.meas tran vdout1_427ck200 FIND v(dout1_427) AT=105.025n

.meas tran vdout1_428ck200 FIND v(dout1_428) AT=105.025n

.meas tran vdout1_429ck200 FIND v(dout1_429) AT=105.025n

.meas tran vdout1_430ck200 FIND v(dout1_430) AT=105.025n

.meas tran vdout1_431ck200 FIND v(dout1_431) AT=105.025n

.meas tran vdout1_432ck200 FIND v(dout1_432) AT=105.025n

.meas tran vdout1_433ck200 FIND v(dout1_433) AT=105.025n

.meas tran vdout1_434ck200 FIND v(dout1_434) AT=105.025n

.meas tran vdout1_435ck200 FIND v(dout1_435) AT=105.025n

.meas tran vdout1_436ck200 FIND v(dout1_436) AT=105.025n

.meas tran vdout1_437ck200 FIND v(dout1_437) AT=105.025n

.meas tran vdout1_438ck200 FIND v(dout1_438) AT=105.025n

.meas tran vdout1_439ck200 FIND v(dout1_439) AT=105.025n

.meas tran vdout1_440ck200 FIND v(dout1_440) AT=105.025n

.meas tran vdout1_441ck200 FIND v(dout1_441) AT=105.025n

.meas tran vdout1_442ck200 FIND v(dout1_442) AT=105.025n

.meas tran vdout1_443ck200 FIND v(dout1_443) AT=105.025n

.meas tran vdout1_444ck200 FIND v(dout1_444) AT=105.025n

.meas tran vdout1_445ck200 FIND v(dout1_445) AT=105.025n

.meas tran vdout1_446ck200 FIND v(dout1_446) AT=105.025n

.meas tran vdout1_447ck200 FIND v(dout1_447) AT=105.025n

.meas tran vdout1_448ck200 FIND v(dout1_448) AT=105.025n

.meas tran vdout1_449ck200 FIND v(dout1_449) AT=105.025n

.meas tran vdout1_450ck200 FIND v(dout1_450) AT=105.025n

.meas tran vdout1_451ck200 FIND v(dout1_451) AT=105.025n

.meas tran vdout1_452ck200 FIND v(dout1_452) AT=105.025n

.meas tran vdout1_453ck200 FIND v(dout1_453) AT=105.025n

.meas tran vdout1_454ck200 FIND v(dout1_454) AT=105.025n

.meas tran vdout1_455ck200 FIND v(dout1_455) AT=105.025n

.meas tran vdout1_456ck200 FIND v(dout1_456) AT=105.025n

.meas tran vdout1_457ck200 FIND v(dout1_457) AT=105.025n

.meas tran vdout1_458ck200 FIND v(dout1_458) AT=105.025n

.meas tran vdout1_459ck200 FIND v(dout1_459) AT=105.025n

.meas tran vdout1_460ck200 FIND v(dout1_460) AT=105.025n

.meas tran vdout1_461ck200 FIND v(dout1_461) AT=105.025n

.meas tran vdout1_462ck200 FIND v(dout1_462) AT=105.025n

.meas tran vdout1_463ck200 FIND v(dout1_463) AT=105.025n

.meas tran vdout1_464ck200 FIND v(dout1_464) AT=105.025n

.meas tran vdout1_465ck200 FIND v(dout1_465) AT=105.025n

.meas tran vdout1_466ck200 FIND v(dout1_466) AT=105.025n

.meas tran vdout1_467ck200 FIND v(dout1_467) AT=105.025n

.meas tran vdout1_468ck200 FIND v(dout1_468) AT=105.025n

.meas tran vdout1_469ck200 FIND v(dout1_469) AT=105.025n

.meas tran vdout1_470ck200 FIND v(dout1_470) AT=105.025n

.meas tran vdout1_471ck200 FIND v(dout1_471) AT=105.025n

.meas tran vdout1_472ck200 FIND v(dout1_472) AT=105.025n

.meas tran vdout1_473ck200 FIND v(dout1_473) AT=105.025n

.meas tran vdout1_474ck200 FIND v(dout1_474) AT=105.025n

.meas tran vdout1_475ck200 FIND v(dout1_475) AT=105.025n

.meas tran vdout1_476ck200 FIND v(dout1_476) AT=105.025n

.meas tran vdout1_477ck200 FIND v(dout1_477) AT=105.025n

.meas tran vdout1_478ck200 FIND v(dout1_478) AT=105.025n

.meas tran vdout1_479ck200 FIND v(dout1_479) AT=105.025n

.meas tran vdout1_480ck200 FIND v(dout1_480) AT=105.025n

.meas tran vdout1_481ck200 FIND v(dout1_481) AT=105.025n

.meas tran vdout1_482ck200 FIND v(dout1_482) AT=105.025n

.meas tran vdout1_483ck200 FIND v(dout1_483) AT=105.025n

.meas tran vdout1_484ck200 FIND v(dout1_484) AT=105.025n

.meas tran vdout1_485ck200 FIND v(dout1_485) AT=105.025n

.meas tran vdout1_486ck200 FIND v(dout1_486) AT=105.025n

.meas tran vdout1_487ck200 FIND v(dout1_487) AT=105.025n

.meas tran vdout1_488ck200 FIND v(dout1_488) AT=105.025n

.meas tran vdout1_489ck200 FIND v(dout1_489) AT=105.025n

.meas tran vdout1_490ck200 FIND v(dout1_490) AT=105.025n

.meas tran vdout1_491ck200 FIND v(dout1_491) AT=105.025n

.meas tran vdout1_492ck200 FIND v(dout1_492) AT=105.025n

.meas tran vdout1_493ck200 FIND v(dout1_493) AT=105.025n

.meas tran vdout1_494ck200 FIND v(dout1_494) AT=105.025n

.meas tran vdout1_495ck200 FIND v(dout1_495) AT=105.025n

.meas tran vdout1_496ck200 FIND v(dout1_496) AT=105.025n

.meas tran vdout1_497ck200 FIND v(dout1_497) AT=105.025n

.meas tran vdout1_498ck200 FIND v(dout1_498) AT=105.025n

.meas tran vdout1_499ck200 FIND v(dout1_499) AT=105.025n

.meas tran vdout1_500ck200 FIND v(dout1_500) AT=105.025n

.meas tran vdout1_501ck200 FIND v(dout1_501) AT=105.025n

.meas tran vdout1_502ck200 FIND v(dout1_502) AT=105.025n

.meas tran vdout1_503ck200 FIND v(dout1_503) AT=105.025n

.meas tran vdout1_504ck200 FIND v(dout1_504) AT=105.025n

.meas tran vdout1_505ck200 FIND v(dout1_505) AT=105.025n

.meas tran vdout1_506ck200 FIND v(dout1_506) AT=105.025n

.meas tran vdout1_507ck200 FIND v(dout1_507) AT=105.025n

.meas tran vdout1_508ck200 FIND v(dout1_508) AT=105.025n

.meas tran vdout1_509ck200 FIND v(dout1_509) AT=105.025n

.meas tran vdout1_510ck200 FIND v(dout1_510) AT=105.025n

.meas tran vdout1_511ck200 FIND v(dout1_511) AT=105.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_32ck230 FIND v(dout1_32) AT=120.025n

.meas tran vdout1_33ck230 FIND v(dout1_33) AT=120.025n

.meas tran vdout1_34ck230 FIND v(dout1_34) AT=120.025n

.meas tran vdout1_35ck230 FIND v(dout1_35) AT=120.025n

.meas tran vdout1_36ck230 FIND v(dout1_36) AT=120.025n

.meas tran vdout1_37ck230 FIND v(dout1_37) AT=120.025n

.meas tran vdout1_38ck230 FIND v(dout1_38) AT=120.025n

.meas tran vdout1_39ck230 FIND v(dout1_39) AT=120.025n

.meas tran vdout1_40ck230 FIND v(dout1_40) AT=120.025n

.meas tran vdout1_41ck230 FIND v(dout1_41) AT=120.025n

.meas tran vdout1_42ck230 FIND v(dout1_42) AT=120.025n

.meas tran vdout1_43ck230 FIND v(dout1_43) AT=120.025n

.meas tran vdout1_44ck230 FIND v(dout1_44) AT=120.025n

.meas tran vdout1_45ck230 FIND v(dout1_45) AT=120.025n

.meas tran vdout1_46ck230 FIND v(dout1_46) AT=120.025n

.meas tran vdout1_47ck230 FIND v(dout1_47) AT=120.025n

.meas tran vdout1_48ck230 FIND v(dout1_48) AT=120.025n

.meas tran vdout1_49ck230 FIND v(dout1_49) AT=120.025n

.meas tran vdout1_50ck230 FIND v(dout1_50) AT=120.025n

.meas tran vdout1_51ck230 FIND v(dout1_51) AT=120.025n

.meas tran vdout1_52ck230 FIND v(dout1_52) AT=120.025n

.meas tran vdout1_53ck230 FIND v(dout1_53) AT=120.025n

.meas tran vdout1_54ck230 FIND v(dout1_54) AT=120.025n

.meas tran vdout1_55ck230 FIND v(dout1_55) AT=120.025n

.meas tran vdout1_56ck230 FIND v(dout1_56) AT=120.025n

.meas tran vdout1_57ck230 FIND v(dout1_57) AT=120.025n

.meas tran vdout1_58ck230 FIND v(dout1_58) AT=120.025n

.meas tran vdout1_59ck230 FIND v(dout1_59) AT=120.025n

.meas tran vdout1_60ck230 FIND v(dout1_60) AT=120.025n

.meas tran vdout1_61ck230 FIND v(dout1_61) AT=120.025n

.meas tran vdout1_62ck230 FIND v(dout1_62) AT=120.025n

.meas tran vdout1_63ck230 FIND v(dout1_63) AT=120.025n

.meas tran vdout1_64ck230 FIND v(dout1_64) AT=120.025n

.meas tran vdout1_65ck230 FIND v(dout1_65) AT=120.025n

.meas tran vdout1_66ck230 FIND v(dout1_66) AT=120.025n

.meas tran vdout1_67ck230 FIND v(dout1_67) AT=120.025n

.meas tran vdout1_68ck230 FIND v(dout1_68) AT=120.025n

.meas tran vdout1_69ck230 FIND v(dout1_69) AT=120.025n

.meas tran vdout1_70ck230 FIND v(dout1_70) AT=120.025n

.meas tran vdout1_71ck230 FIND v(dout1_71) AT=120.025n

.meas tran vdout1_72ck230 FIND v(dout1_72) AT=120.025n

.meas tran vdout1_73ck230 FIND v(dout1_73) AT=120.025n

.meas tran vdout1_74ck230 FIND v(dout1_74) AT=120.025n

.meas tran vdout1_75ck230 FIND v(dout1_75) AT=120.025n

.meas tran vdout1_76ck230 FIND v(dout1_76) AT=120.025n

.meas tran vdout1_77ck230 FIND v(dout1_77) AT=120.025n

.meas tran vdout1_78ck230 FIND v(dout1_78) AT=120.025n

.meas tran vdout1_79ck230 FIND v(dout1_79) AT=120.025n

.meas tran vdout1_80ck230 FIND v(dout1_80) AT=120.025n

.meas tran vdout1_81ck230 FIND v(dout1_81) AT=120.025n

.meas tran vdout1_82ck230 FIND v(dout1_82) AT=120.025n

.meas tran vdout1_83ck230 FIND v(dout1_83) AT=120.025n

.meas tran vdout1_84ck230 FIND v(dout1_84) AT=120.025n

.meas tran vdout1_85ck230 FIND v(dout1_85) AT=120.025n

.meas tran vdout1_86ck230 FIND v(dout1_86) AT=120.025n

.meas tran vdout1_87ck230 FIND v(dout1_87) AT=120.025n

.meas tran vdout1_88ck230 FIND v(dout1_88) AT=120.025n

.meas tran vdout1_89ck230 FIND v(dout1_89) AT=120.025n

.meas tran vdout1_90ck230 FIND v(dout1_90) AT=120.025n

.meas tran vdout1_91ck230 FIND v(dout1_91) AT=120.025n

.meas tran vdout1_92ck230 FIND v(dout1_92) AT=120.025n

.meas tran vdout1_93ck230 FIND v(dout1_93) AT=120.025n

.meas tran vdout1_94ck230 FIND v(dout1_94) AT=120.025n

.meas tran vdout1_95ck230 FIND v(dout1_95) AT=120.025n

.meas tran vdout1_96ck230 FIND v(dout1_96) AT=120.025n

.meas tran vdout1_97ck230 FIND v(dout1_97) AT=120.025n

.meas tran vdout1_98ck230 FIND v(dout1_98) AT=120.025n

.meas tran vdout1_99ck230 FIND v(dout1_99) AT=120.025n

.meas tran vdout1_100ck230 FIND v(dout1_100) AT=120.025n

.meas tran vdout1_101ck230 FIND v(dout1_101) AT=120.025n

.meas tran vdout1_102ck230 FIND v(dout1_102) AT=120.025n

.meas tran vdout1_103ck230 FIND v(dout1_103) AT=120.025n

.meas tran vdout1_104ck230 FIND v(dout1_104) AT=120.025n

.meas tran vdout1_105ck230 FIND v(dout1_105) AT=120.025n

.meas tran vdout1_106ck230 FIND v(dout1_106) AT=120.025n

.meas tran vdout1_107ck230 FIND v(dout1_107) AT=120.025n

.meas tran vdout1_108ck230 FIND v(dout1_108) AT=120.025n

.meas tran vdout1_109ck230 FIND v(dout1_109) AT=120.025n

.meas tran vdout1_110ck230 FIND v(dout1_110) AT=120.025n

.meas tran vdout1_111ck230 FIND v(dout1_111) AT=120.025n

.meas tran vdout1_112ck230 FIND v(dout1_112) AT=120.025n

.meas tran vdout1_113ck230 FIND v(dout1_113) AT=120.025n

.meas tran vdout1_114ck230 FIND v(dout1_114) AT=120.025n

.meas tran vdout1_115ck230 FIND v(dout1_115) AT=120.025n

.meas tran vdout1_116ck230 FIND v(dout1_116) AT=120.025n

.meas tran vdout1_117ck230 FIND v(dout1_117) AT=120.025n

.meas tran vdout1_118ck230 FIND v(dout1_118) AT=120.025n

.meas tran vdout1_119ck230 FIND v(dout1_119) AT=120.025n

.meas tran vdout1_120ck230 FIND v(dout1_120) AT=120.025n

.meas tran vdout1_121ck230 FIND v(dout1_121) AT=120.025n

.meas tran vdout1_122ck230 FIND v(dout1_122) AT=120.025n

.meas tran vdout1_123ck230 FIND v(dout1_123) AT=120.025n

.meas tran vdout1_124ck230 FIND v(dout1_124) AT=120.025n

.meas tran vdout1_125ck230 FIND v(dout1_125) AT=120.025n

.meas tran vdout1_126ck230 FIND v(dout1_126) AT=120.025n

.meas tran vdout1_127ck230 FIND v(dout1_127) AT=120.025n

.meas tran vdout1_128ck230 FIND v(dout1_128) AT=120.025n

.meas tran vdout1_129ck230 FIND v(dout1_129) AT=120.025n

.meas tran vdout1_130ck230 FIND v(dout1_130) AT=120.025n

.meas tran vdout1_131ck230 FIND v(dout1_131) AT=120.025n

.meas tran vdout1_132ck230 FIND v(dout1_132) AT=120.025n

.meas tran vdout1_133ck230 FIND v(dout1_133) AT=120.025n

.meas tran vdout1_134ck230 FIND v(dout1_134) AT=120.025n

.meas tran vdout1_135ck230 FIND v(dout1_135) AT=120.025n

.meas tran vdout1_136ck230 FIND v(dout1_136) AT=120.025n

.meas tran vdout1_137ck230 FIND v(dout1_137) AT=120.025n

.meas tran vdout1_138ck230 FIND v(dout1_138) AT=120.025n

.meas tran vdout1_139ck230 FIND v(dout1_139) AT=120.025n

.meas tran vdout1_140ck230 FIND v(dout1_140) AT=120.025n

.meas tran vdout1_141ck230 FIND v(dout1_141) AT=120.025n

.meas tran vdout1_142ck230 FIND v(dout1_142) AT=120.025n

.meas tran vdout1_143ck230 FIND v(dout1_143) AT=120.025n

.meas tran vdout1_144ck230 FIND v(dout1_144) AT=120.025n

.meas tran vdout1_145ck230 FIND v(dout1_145) AT=120.025n

.meas tran vdout1_146ck230 FIND v(dout1_146) AT=120.025n

.meas tran vdout1_147ck230 FIND v(dout1_147) AT=120.025n

.meas tran vdout1_148ck230 FIND v(dout1_148) AT=120.025n

.meas tran vdout1_149ck230 FIND v(dout1_149) AT=120.025n

.meas tran vdout1_150ck230 FIND v(dout1_150) AT=120.025n

.meas tran vdout1_151ck230 FIND v(dout1_151) AT=120.025n

.meas tran vdout1_152ck230 FIND v(dout1_152) AT=120.025n

.meas tran vdout1_153ck230 FIND v(dout1_153) AT=120.025n

.meas tran vdout1_154ck230 FIND v(dout1_154) AT=120.025n

.meas tran vdout1_155ck230 FIND v(dout1_155) AT=120.025n

.meas tran vdout1_156ck230 FIND v(dout1_156) AT=120.025n

.meas tran vdout1_157ck230 FIND v(dout1_157) AT=120.025n

.meas tran vdout1_158ck230 FIND v(dout1_158) AT=120.025n

.meas tran vdout1_159ck230 FIND v(dout1_159) AT=120.025n

.meas tran vdout1_160ck230 FIND v(dout1_160) AT=120.025n

.meas tran vdout1_161ck230 FIND v(dout1_161) AT=120.025n

.meas tran vdout1_162ck230 FIND v(dout1_162) AT=120.025n

.meas tran vdout1_163ck230 FIND v(dout1_163) AT=120.025n

.meas tran vdout1_164ck230 FIND v(dout1_164) AT=120.025n

.meas tran vdout1_165ck230 FIND v(dout1_165) AT=120.025n

.meas tran vdout1_166ck230 FIND v(dout1_166) AT=120.025n

.meas tran vdout1_167ck230 FIND v(dout1_167) AT=120.025n

.meas tran vdout1_168ck230 FIND v(dout1_168) AT=120.025n

.meas tran vdout1_169ck230 FIND v(dout1_169) AT=120.025n

.meas tran vdout1_170ck230 FIND v(dout1_170) AT=120.025n

.meas tran vdout1_171ck230 FIND v(dout1_171) AT=120.025n

.meas tran vdout1_172ck230 FIND v(dout1_172) AT=120.025n

.meas tran vdout1_173ck230 FIND v(dout1_173) AT=120.025n

.meas tran vdout1_174ck230 FIND v(dout1_174) AT=120.025n

.meas tran vdout1_175ck230 FIND v(dout1_175) AT=120.025n

.meas tran vdout1_176ck230 FIND v(dout1_176) AT=120.025n

.meas tran vdout1_177ck230 FIND v(dout1_177) AT=120.025n

.meas tran vdout1_178ck230 FIND v(dout1_178) AT=120.025n

.meas tran vdout1_179ck230 FIND v(dout1_179) AT=120.025n

.meas tran vdout1_180ck230 FIND v(dout1_180) AT=120.025n

.meas tran vdout1_181ck230 FIND v(dout1_181) AT=120.025n

.meas tran vdout1_182ck230 FIND v(dout1_182) AT=120.025n

.meas tran vdout1_183ck230 FIND v(dout1_183) AT=120.025n

.meas tran vdout1_184ck230 FIND v(dout1_184) AT=120.025n

.meas tran vdout1_185ck230 FIND v(dout1_185) AT=120.025n

.meas tran vdout1_186ck230 FIND v(dout1_186) AT=120.025n

.meas tran vdout1_187ck230 FIND v(dout1_187) AT=120.025n

.meas tran vdout1_188ck230 FIND v(dout1_188) AT=120.025n

.meas tran vdout1_189ck230 FIND v(dout1_189) AT=120.025n

.meas tran vdout1_190ck230 FIND v(dout1_190) AT=120.025n

.meas tran vdout1_191ck230 FIND v(dout1_191) AT=120.025n

.meas tran vdout1_192ck230 FIND v(dout1_192) AT=120.025n

.meas tran vdout1_193ck230 FIND v(dout1_193) AT=120.025n

.meas tran vdout1_194ck230 FIND v(dout1_194) AT=120.025n

.meas tran vdout1_195ck230 FIND v(dout1_195) AT=120.025n

.meas tran vdout1_196ck230 FIND v(dout1_196) AT=120.025n

.meas tran vdout1_197ck230 FIND v(dout1_197) AT=120.025n

.meas tran vdout1_198ck230 FIND v(dout1_198) AT=120.025n

.meas tran vdout1_199ck230 FIND v(dout1_199) AT=120.025n

.meas tran vdout1_200ck230 FIND v(dout1_200) AT=120.025n

.meas tran vdout1_201ck230 FIND v(dout1_201) AT=120.025n

.meas tran vdout1_202ck230 FIND v(dout1_202) AT=120.025n

.meas tran vdout1_203ck230 FIND v(dout1_203) AT=120.025n

.meas tran vdout1_204ck230 FIND v(dout1_204) AT=120.025n

.meas tran vdout1_205ck230 FIND v(dout1_205) AT=120.025n

.meas tran vdout1_206ck230 FIND v(dout1_206) AT=120.025n

.meas tran vdout1_207ck230 FIND v(dout1_207) AT=120.025n

.meas tran vdout1_208ck230 FIND v(dout1_208) AT=120.025n

.meas tran vdout1_209ck230 FIND v(dout1_209) AT=120.025n

.meas tran vdout1_210ck230 FIND v(dout1_210) AT=120.025n

.meas tran vdout1_211ck230 FIND v(dout1_211) AT=120.025n

.meas tran vdout1_212ck230 FIND v(dout1_212) AT=120.025n

.meas tran vdout1_213ck230 FIND v(dout1_213) AT=120.025n

.meas tran vdout1_214ck230 FIND v(dout1_214) AT=120.025n

.meas tran vdout1_215ck230 FIND v(dout1_215) AT=120.025n

.meas tran vdout1_216ck230 FIND v(dout1_216) AT=120.025n

.meas tran vdout1_217ck230 FIND v(dout1_217) AT=120.025n

.meas tran vdout1_218ck230 FIND v(dout1_218) AT=120.025n

.meas tran vdout1_219ck230 FIND v(dout1_219) AT=120.025n

.meas tran vdout1_220ck230 FIND v(dout1_220) AT=120.025n

.meas tran vdout1_221ck230 FIND v(dout1_221) AT=120.025n

.meas tran vdout1_222ck230 FIND v(dout1_222) AT=120.025n

.meas tran vdout1_223ck230 FIND v(dout1_223) AT=120.025n

.meas tran vdout1_224ck230 FIND v(dout1_224) AT=120.025n

.meas tran vdout1_225ck230 FIND v(dout1_225) AT=120.025n

.meas tran vdout1_226ck230 FIND v(dout1_226) AT=120.025n

.meas tran vdout1_227ck230 FIND v(dout1_227) AT=120.025n

.meas tran vdout1_228ck230 FIND v(dout1_228) AT=120.025n

.meas tran vdout1_229ck230 FIND v(dout1_229) AT=120.025n

.meas tran vdout1_230ck230 FIND v(dout1_230) AT=120.025n

.meas tran vdout1_231ck230 FIND v(dout1_231) AT=120.025n

.meas tran vdout1_232ck230 FIND v(dout1_232) AT=120.025n

.meas tran vdout1_233ck230 FIND v(dout1_233) AT=120.025n

.meas tran vdout1_234ck230 FIND v(dout1_234) AT=120.025n

.meas tran vdout1_235ck230 FIND v(dout1_235) AT=120.025n

.meas tran vdout1_236ck230 FIND v(dout1_236) AT=120.025n

.meas tran vdout1_237ck230 FIND v(dout1_237) AT=120.025n

.meas tran vdout1_238ck230 FIND v(dout1_238) AT=120.025n

.meas tran vdout1_239ck230 FIND v(dout1_239) AT=120.025n

.meas tran vdout1_240ck230 FIND v(dout1_240) AT=120.025n

.meas tran vdout1_241ck230 FIND v(dout1_241) AT=120.025n

.meas tran vdout1_242ck230 FIND v(dout1_242) AT=120.025n

.meas tran vdout1_243ck230 FIND v(dout1_243) AT=120.025n

.meas tran vdout1_244ck230 FIND v(dout1_244) AT=120.025n

.meas tran vdout1_245ck230 FIND v(dout1_245) AT=120.025n

.meas tran vdout1_246ck230 FIND v(dout1_246) AT=120.025n

.meas tran vdout1_247ck230 FIND v(dout1_247) AT=120.025n

.meas tran vdout1_248ck230 FIND v(dout1_248) AT=120.025n

.meas tran vdout1_249ck230 FIND v(dout1_249) AT=120.025n

.meas tran vdout1_250ck230 FIND v(dout1_250) AT=120.025n

.meas tran vdout1_251ck230 FIND v(dout1_251) AT=120.025n

.meas tran vdout1_252ck230 FIND v(dout1_252) AT=120.025n

.meas tran vdout1_253ck230 FIND v(dout1_253) AT=120.025n

.meas tran vdout1_254ck230 FIND v(dout1_254) AT=120.025n

.meas tran vdout1_255ck230 FIND v(dout1_255) AT=120.025n

.meas tran vdout1_256ck230 FIND v(dout1_256) AT=120.025n

.meas tran vdout1_257ck230 FIND v(dout1_257) AT=120.025n

.meas tran vdout1_258ck230 FIND v(dout1_258) AT=120.025n

.meas tran vdout1_259ck230 FIND v(dout1_259) AT=120.025n

.meas tran vdout1_260ck230 FIND v(dout1_260) AT=120.025n

.meas tran vdout1_261ck230 FIND v(dout1_261) AT=120.025n

.meas tran vdout1_262ck230 FIND v(dout1_262) AT=120.025n

.meas tran vdout1_263ck230 FIND v(dout1_263) AT=120.025n

.meas tran vdout1_264ck230 FIND v(dout1_264) AT=120.025n

.meas tran vdout1_265ck230 FIND v(dout1_265) AT=120.025n

.meas tran vdout1_266ck230 FIND v(dout1_266) AT=120.025n

.meas tran vdout1_267ck230 FIND v(dout1_267) AT=120.025n

.meas tran vdout1_268ck230 FIND v(dout1_268) AT=120.025n

.meas tran vdout1_269ck230 FIND v(dout1_269) AT=120.025n

.meas tran vdout1_270ck230 FIND v(dout1_270) AT=120.025n

.meas tran vdout1_271ck230 FIND v(dout1_271) AT=120.025n

.meas tran vdout1_272ck230 FIND v(dout1_272) AT=120.025n

.meas tran vdout1_273ck230 FIND v(dout1_273) AT=120.025n

.meas tran vdout1_274ck230 FIND v(dout1_274) AT=120.025n

.meas tran vdout1_275ck230 FIND v(dout1_275) AT=120.025n

.meas tran vdout1_276ck230 FIND v(dout1_276) AT=120.025n

.meas tran vdout1_277ck230 FIND v(dout1_277) AT=120.025n

.meas tran vdout1_278ck230 FIND v(dout1_278) AT=120.025n

.meas tran vdout1_279ck230 FIND v(dout1_279) AT=120.025n

.meas tran vdout1_280ck230 FIND v(dout1_280) AT=120.025n

.meas tran vdout1_281ck230 FIND v(dout1_281) AT=120.025n

.meas tran vdout1_282ck230 FIND v(dout1_282) AT=120.025n

.meas tran vdout1_283ck230 FIND v(dout1_283) AT=120.025n

.meas tran vdout1_284ck230 FIND v(dout1_284) AT=120.025n

.meas tran vdout1_285ck230 FIND v(dout1_285) AT=120.025n

.meas tran vdout1_286ck230 FIND v(dout1_286) AT=120.025n

.meas tran vdout1_287ck230 FIND v(dout1_287) AT=120.025n

.meas tran vdout1_288ck230 FIND v(dout1_288) AT=120.025n

.meas tran vdout1_289ck230 FIND v(dout1_289) AT=120.025n

.meas tran vdout1_290ck230 FIND v(dout1_290) AT=120.025n

.meas tran vdout1_291ck230 FIND v(dout1_291) AT=120.025n

.meas tran vdout1_292ck230 FIND v(dout1_292) AT=120.025n

.meas tran vdout1_293ck230 FIND v(dout1_293) AT=120.025n

.meas tran vdout1_294ck230 FIND v(dout1_294) AT=120.025n

.meas tran vdout1_295ck230 FIND v(dout1_295) AT=120.025n

.meas tran vdout1_296ck230 FIND v(dout1_296) AT=120.025n

.meas tran vdout1_297ck230 FIND v(dout1_297) AT=120.025n

.meas tran vdout1_298ck230 FIND v(dout1_298) AT=120.025n

.meas tran vdout1_299ck230 FIND v(dout1_299) AT=120.025n

.meas tran vdout1_300ck230 FIND v(dout1_300) AT=120.025n

.meas tran vdout1_301ck230 FIND v(dout1_301) AT=120.025n

.meas tran vdout1_302ck230 FIND v(dout1_302) AT=120.025n

.meas tran vdout1_303ck230 FIND v(dout1_303) AT=120.025n

.meas tran vdout1_304ck230 FIND v(dout1_304) AT=120.025n

.meas tran vdout1_305ck230 FIND v(dout1_305) AT=120.025n

.meas tran vdout1_306ck230 FIND v(dout1_306) AT=120.025n

.meas tran vdout1_307ck230 FIND v(dout1_307) AT=120.025n

.meas tran vdout1_308ck230 FIND v(dout1_308) AT=120.025n

.meas tran vdout1_309ck230 FIND v(dout1_309) AT=120.025n

.meas tran vdout1_310ck230 FIND v(dout1_310) AT=120.025n

.meas tran vdout1_311ck230 FIND v(dout1_311) AT=120.025n

.meas tran vdout1_312ck230 FIND v(dout1_312) AT=120.025n

.meas tran vdout1_313ck230 FIND v(dout1_313) AT=120.025n

.meas tran vdout1_314ck230 FIND v(dout1_314) AT=120.025n

.meas tran vdout1_315ck230 FIND v(dout1_315) AT=120.025n

.meas tran vdout1_316ck230 FIND v(dout1_316) AT=120.025n

.meas tran vdout1_317ck230 FIND v(dout1_317) AT=120.025n

.meas tran vdout1_318ck230 FIND v(dout1_318) AT=120.025n

.meas tran vdout1_319ck230 FIND v(dout1_319) AT=120.025n

.meas tran vdout1_320ck230 FIND v(dout1_320) AT=120.025n

.meas tran vdout1_321ck230 FIND v(dout1_321) AT=120.025n

.meas tran vdout1_322ck230 FIND v(dout1_322) AT=120.025n

.meas tran vdout1_323ck230 FIND v(dout1_323) AT=120.025n

.meas tran vdout1_324ck230 FIND v(dout1_324) AT=120.025n

.meas tran vdout1_325ck230 FIND v(dout1_325) AT=120.025n

.meas tran vdout1_326ck230 FIND v(dout1_326) AT=120.025n

.meas tran vdout1_327ck230 FIND v(dout1_327) AT=120.025n

.meas tran vdout1_328ck230 FIND v(dout1_328) AT=120.025n

.meas tran vdout1_329ck230 FIND v(dout1_329) AT=120.025n

.meas tran vdout1_330ck230 FIND v(dout1_330) AT=120.025n

.meas tran vdout1_331ck230 FIND v(dout1_331) AT=120.025n

.meas tran vdout1_332ck230 FIND v(dout1_332) AT=120.025n

.meas tran vdout1_333ck230 FIND v(dout1_333) AT=120.025n

.meas tran vdout1_334ck230 FIND v(dout1_334) AT=120.025n

.meas tran vdout1_335ck230 FIND v(dout1_335) AT=120.025n

.meas tran vdout1_336ck230 FIND v(dout1_336) AT=120.025n

.meas tran vdout1_337ck230 FIND v(dout1_337) AT=120.025n

.meas tran vdout1_338ck230 FIND v(dout1_338) AT=120.025n

.meas tran vdout1_339ck230 FIND v(dout1_339) AT=120.025n

.meas tran vdout1_340ck230 FIND v(dout1_340) AT=120.025n

.meas tran vdout1_341ck230 FIND v(dout1_341) AT=120.025n

.meas tran vdout1_342ck230 FIND v(dout1_342) AT=120.025n

.meas tran vdout1_343ck230 FIND v(dout1_343) AT=120.025n

.meas tran vdout1_344ck230 FIND v(dout1_344) AT=120.025n

.meas tran vdout1_345ck230 FIND v(dout1_345) AT=120.025n

.meas tran vdout1_346ck230 FIND v(dout1_346) AT=120.025n

.meas tran vdout1_347ck230 FIND v(dout1_347) AT=120.025n

.meas tran vdout1_348ck230 FIND v(dout1_348) AT=120.025n

.meas tran vdout1_349ck230 FIND v(dout1_349) AT=120.025n

.meas tran vdout1_350ck230 FIND v(dout1_350) AT=120.025n

.meas tran vdout1_351ck230 FIND v(dout1_351) AT=120.025n

.meas tran vdout1_352ck230 FIND v(dout1_352) AT=120.025n

.meas tran vdout1_353ck230 FIND v(dout1_353) AT=120.025n

.meas tran vdout1_354ck230 FIND v(dout1_354) AT=120.025n

.meas tran vdout1_355ck230 FIND v(dout1_355) AT=120.025n

.meas tran vdout1_356ck230 FIND v(dout1_356) AT=120.025n

.meas tran vdout1_357ck230 FIND v(dout1_357) AT=120.025n

.meas tran vdout1_358ck230 FIND v(dout1_358) AT=120.025n

.meas tran vdout1_359ck230 FIND v(dout1_359) AT=120.025n

.meas tran vdout1_360ck230 FIND v(dout1_360) AT=120.025n

.meas tran vdout1_361ck230 FIND v(dout1_361) AT=120.025n

.meas tran vdout1_362ck230 FIND v(dout1_362) AT=120.025n

.meas tran vdout1_363ck230 FIND v(dout1_363) AT=120.025n

.meas tran vdout1_364ck230 FIND v(dout1_364) AT=120.025n

.meas tran vdout1_365ck230 FIND v(dout1_365) AT=120.025n

.meas tran vdout1_366ck230 FIND v(dout1_366) AT=120.025n

.meas tran vdout1_367ck230 FIND v(dout1_367) AT=120.025n

.meas tran vdout1_368ck230 FIND v(dout1_368) AT=120.025n

.meas tran vdout1_369ck230 FIND v(dout1_369) AT=120.025n

.meas tran vdout1_370ck230 FIND v(dout1_370) AT=120.025n

.meas tran vdout1_371ck230 FIND v(dout1_371) AT=120.025n

.meas tran vdout1_372ck230 FIND v(dout1_372) AT=120.025n

.meas tran vdout1_373ck230 FIND v(dout1_373) AT=120.025n

.meas tran vdout1_374ck230 FIND v(dout1_374) AT=120.025n

.meas tran vdout1_375ck230 FIND v(dout1_375) AT=120.025n

.meas tran vdout1_376ck230 FIND v(dout1_376) AT=120.025n

.meas tran vdout1_377ck230 FIND v(dout1_377) AT=120.025n

.meas tran vdout1_378ck230 FIND v(dout1_378) AT=120.025n

.meas tran vdout1_379ck230 FIND v(dout1_379) AT=120.025n

.meas tran vdout1_380ck230 FIND v(dout1_380) AT=120.025n

.meas tran vdout1_381ck230 FIND v(dout1_381) AT=120.025n

.meas tran vdout1_382ck230 FIND v(dout1_382) AT=120.025n

.meas tran vdout1_383ck230 FIND v(dout1_383) AT=120.025n

.meas tran vdout1_384ck230 FIND v(dout1_384) AT=120.025n

.meas tran vdout1_385ck230 FIND v(dout1_385) AT=120.025n

.meas tran vdout1_386ck230 FIND v(dout1_386) AT=120.025n

.meas tran vdout1_387ck230 FIND v(dout1_387) AT=120.025n

.meas tran vdout1_388ck230 FIND v(dout1_388) AT=120.025n

.meas tran vdout1_389ck230 FIND v(dout1_389) AT=120.025n

.meas tran vdout1_390ck230 FIND v(dout1_390) AT=120.025n

.meas tran vdout1_391ck230 FIND v(dout1_391) AT=120.025n

.meas tran vdout1_392ck230 FIND v(dout1_392) AT=120.025n

.meas tran vdout1_393ck230 FIND v(dout1_393) AT=120.025n

.meas tran vdout1_394ck230 FIND v(dout1_394) AT=120.025n

.meas tran vdout1_395ck230 FIND v(dout1_395) AT=120.025n

.meas tran vdout1_396ck230 FIND v(dout1_396) AT=120.025n

.meas tran vdout1_397ck230 FIND v(dout1_397) AT=120.025n

.meas tran vdout1_398ck230 FIND v(dout1_398) AT=120.025n

.meas tran vdout1_399ck230 FIND v(dout1_399) AT=120.025n

.meas tran vdout1_400ck230 FIND v(dout1_400) AT=120.025n

.meas tran vdout1_401ck230 FIND v(dout1_401) AT=120.025n

.meas tran vdout1_402ck230 FIND v(dout1_402) AT=120.025n

.meas tran vdout1_403ck230 FIND v(dout1_403) AT=120.025n

.meas tran vdout1_404ck230 FIND v(dout1_404) AT=120.025n

.meas tran vdout1_405ck230 FIND v(dout1_405) AT=120.025n

.meas tran vdout1_406ck230 FIND v(dout1_406) AT=120.025n

.meas tran vdout1_407ck230 FIND v(dout1_407) AT=120.025n

.meas tran vdout1_408ck230 FIND v(dout1_408) AT=120.025n

.meas tran vdout1_409ck230 FIND v(dout1_409) AT=120.025n

.meas tran vdout1_410ck230 FIND v(dout1_410) AT=120.025n

.meas tran vdout1_411ck230 FIND v(dout1_411) AT=120.025n

.meas tran vdout1_412ck230 FIND v(dout1_412) AT=120.025n

.meas tran vdout1_413ck230 FIND v(dout1_413) AT=120.025n

.meas tran vdout1_414ck230 FIND v(dout1_414) AT=120.025n

.meas tran vdout1_415ck230 FIND v(dout1_415) AT=120.025n

.meas tran vdout1_416ck230 FIND v(dout1_416) AT=120.025n

.meas tran vdout1_417ck230 FIND v(dout1_417) AT=120.025n

.meas tran vdout1_418ck230 FIND v(dout1_418) AT=120.025n

.meas tran vdout1_419ck230 FIND v(dout1_419) AT=120.025n

.meas tran vdout1_420ck230 FIND v(dout1_420) AT=120.025n

.meas tran vdout1_421ck230 FIND v(dout1_421) AT=120.025n

.meas tran vdout1_422ck230 FIND v(dout1_422) AT=120.025n

.meas tran vdout1_423ck230 FIND v(dout1_423) AT=120.025n

.meas tran vdout1_424ck230 FIND v(dout1_424) AT=120.025n

.meas tran vdout1_425ck230 FIND v(dout1_425) AT=120.025n

.meas tran vdout1_426ck230 FIND v(dout1_426) AT=120.025n

.meas tran vdout1_427ck230 FIND v(dout1_427) AT=120.025n

.meas tran vdout1_428ck230 FIND v(dout1_428) AT=120.025n

.meas tran vdout1_429ck230 FIND v(dout1_429) AT=120.025n

.meas tran vdout1_430ck230 FIND v(dout1_430) AT=120.025n

.meas tran vdout1_431ck230 FIND v(dout1_431) AT=120.025n

.meas tran vdout1_432ck230 FIND v(dout1_432) AT=120.025n

.meas tran vdout1_433ck230 FIND v(dout1_433) AT=120.025n

.meas tran vdout1_434ck230 FIND v(dout1_434) AT=120.025n

.meas tran vdout1_435ck230 FIND v(dout1_435) AT=120.025n

.meas tran vdout1_436ck230 FIND v(dout1_436) AT=120.025n

.meas tran vdout1_437ck230 FIND v(dout1_437) AT=120.025n

.meas tran vdout1_438ck230 FIND v(dout1_438) AT=120.025n

.meas tran vdout1_439ck230 FIND v(dout1_439) AT=120.025n

.meas tran vdout1_440ck230 FIND v(dout1_440) AT=120.025n

.meas tran vdout1_441ck230 FIND v(dout1_441) AT=120.025n

.meas tran vdout1_442ck230 FIND v(dout1_442) AT=120.025n

.meas tran vdout1_443ck230 FIND v(dout1_443) AT=120.025n

.meas tran vdout1_444ck230 FIND v(dout1_444) AT=120.025n

.meas tran vdout1_445ck230 FIND v(dout1_445) AT=120.025n

.meas tran vdout1_446ck230 FIND v(dout1_446) AT=120.025n

.meas tran vdout1_447ck230 FIND v(dout1_447) AT=120.025n

.meas tran vdout1_448ck230 FIND v(dout1_448) AT=120.025n

.meas tran vdout1_449ck230 FIND v(dout1_449) AT=120.025n

.meas tran vdout1_450ck230 FIND v(dout1_450) AT=120.025n

.meas tran vdout1_451ck230 FIND v(dout1_451) AT=120.025n

.meas tran vdout1_452ck230 FIND v(dout1_452) AT=120.025n

.meas tran vdout1_453ck230 FIND v(dout1_453) AT=120.025n

.meas tran vdout1_454ck230 FIND v(dout1_454) AT=120.025n

.meas tran vdout1_455ck230 FIND v(dout1_455) AT=120.025n

.meas tran vdout1_456ck230 FIND v(dout1_456) AT=120.025n

.meas tran vdout1_457ck230 FIND v(dout1_457) AT=120.025n

.meas tran vdout1_458ck230 FIND v(dout1_458) AT=120.025n

.meas tran vdout1_459ck230 FIND v(dout1_459) AT=120.025n

.meas tran vdout1_460ck230 FIND v(dout1_460) AT=120.025n

.meas tran vdout1_461ck230 FIND v(dout1_461) AT=120.025n

.meas tran vdout1_462ck230 FIND v(dout1_462) AT=120.025n

.meas tran vdout1_463ck230 FIND v(dout1_463) AT=120.025n

.meas tran vdout1_464ck230 FIND v(dout1_464) AT=120.025n

.meas tran vdout1_465ck230 FIND v(dout1_465) AT=120.025n

.meas tran vdout1_466ck230 FIND v(dout1_466) AT=120.025n

.meas tran vdout1_467ck230 FIND v(dout1_467) AT=120.025n

.meas tran vdout1_468ck230 FIND v(dout1_468) AT=120.025n

.meas tran vdout1_469ck230 FIND v(dout1_469) AT=120.025n

.meas tran vdout1_470ck230 FIND v(dout1_470) AT=120.025n

.meas tran vdout1_471ck230 FIND v(dout1_471) AT=120.025n

.meas tran vdout1_472ck230 FIND v(dout1_472) AT=120.025n

.meas tran vdout1_473ck230 FIND v(dout1_473) AT=120.025n

.meas tran vdout1_474ck230 FIND v(dout1_474) AT=120.025n

.meas tran vdout1_475ck230 FIND v(dout1_475) AT=120.025n

.meas tran vdout1_476ck230 FIND v(dout1_476) AT=120.025n

.meas tran vdout1_477ck230 FIND v(dout1_477) AT=120.025n

.meas tran vdout1_478ck230 FIND v(dout1_478) AT=120.025n

.meas tran vdout1_479ck230 FIND v(dout1_479) AT=120.025n

.meas tran vdout1_480ck230 FIND v(dout1_480) AT=120.025n

.meas tran vdout1_481ck230 FIND v(dout1_481) AT=120.025n

.meas tran vdout1_482ck230 FIND v(dout1_482) AT=120.025n

.meas tran vdout1_483ck230 FIND v(dout1_483) AT=120.025n

.meas tran vdout1_484ck230 FIND v(dout1_484) AT=120.025n

.meas tran vdout1_485ck230 FIND v(dout1_485) AT=120.025n

.meas tran vdout1_486ck230 FIND v(dout1_486) AT=120.025n

.meas tran vdout1_487ck230 FIND v(dout1_487) AT=120.025n

.meas tran vdout1_488ck230 FIND v(dout1_488) AT=120.025n

.meas tran vdout1_489ck230 FIND v(dout1_489) AT=120.025n

.meas tran vdout1_490ck230 FIND v(dout1_490) AT=120.025n

.meas tran vdout1_491ck230 FIND v(dout1_491) AT=120.025n

.meas tran vdout1_492ck230 FIND v(dout1_492) AT=120.025n

.meas tran vdout1_493ck230 FIND v(dout1_493) AT=120.025n

.meas tran vdout1_494ck230 FIND v(dout1_494) AT=120.025n

.meas tran vdout1_495ck230 FIND v(dout1_495) AT=120.025n

.meas tran vdout1_496ck230 FIND v(dout1_496) AT=120.025n

.meas tran vdout1_497ck230 FIND v(dout1_497) AT=120.025n

.meas tran vdout1_498ck230 FIND v(dout1_498) AT=120.025n

.meas tran vdout1_499ck230 FIND v(dout1_499) AT=120.025n

.meas tran vdout1_500ck230 FIND v(dout1_500) AT=120.025n

.meas tran vdout1_501ck230 FIND v(dout1_501) AT=120.025n

.meas tran vdout1_502ck230 FIND v(dout1_502) AT=120.025n

.meas tran vdout1_503ck230 FIND v(dout1_503) AT=120.025n

.meas tran vdout1_504ck230 FIND v(dout1_504) AT=120.025n

.meas tran vdout1_505ck230 FIND v(dout1_505) AT=120.025n

.meas tran vdout1_506ck230 FIND v(dout1_506) AT=120.025n

.meas tran vdout1_507ck230 FIND v(dout1_507) AT=120.025n

.meas tran vdout1_508ck230 FIND v(dout1_508) AT=120.025n

.meas tran vdout1_509ck230 FIND v(dout1_509) AT=120.025n

.meas tran vdout1_510ck230 FIND v(dout1_510) AT=120.025n

.meas tran vdout1_511ck230 FIND v(dout1_511) AT=120.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_17ck240 FIND v(dout1_17) AT=125.025n

.meas tran vdout1_18ck240 FIND v(dout1_18) AT=125.025n

.meas tran vdout1_19ck240 FIND v(dout1_19) AT=125.025n

.meas tran vdout1_20ck240 FIND v(dout1_20) AT=125.025n

.meas tran vdout1_21ck240 FIND v(dout1_21) AT=125.025n

.meas tran vdout1_22ck240 FIND v(dout1_22) AT=125.025n

.meas tran vdout1_23ck240 FIND v(dout1_23) AT=125.025n

.meas tran vdout1_24ck240 FIND v(dout1_24) AT=125.025n

.meas tran vdout1_25ck240 FIND v(dout1_25) AT=125.025n

.meas tran vdout1_26ck240 FIND v(dout1_26) AT=125.025n

.meas tran vdout1_27ck240 FIND v(dout1_27) AT=125.025n

.meas tran vdout1_28ck240 FIND v(dout1_28) AT=125.025n

.meas tran vdout1_29ck240 FIND v(dout1_29) AT=125.025n

.meas tran vdout1_30ck240 FIND v(dout1_30) AT=125.025n

.meas tran vdout1_31ck240 FIND v(dout1_31) AT=125.025n

.meas tran vdout1_32ck240 FIND v(dout1_32) AT=125.025n

.meas tran vdout1_33ck240 FIND v(dout1_33) AT=125.025n

.meas tran vdout1_34ck240 FIND v(dout1_34) AT=125.025n

.meas tran vdout1_35ck240 FIND v(dout1_35) AT=125.025n

.meas tran vdout1_36ck240 FIND v(dout1_36) AT=125.025n

.meas tran vdout1_37ck240 FIND v(dout1_37) AT=125.025n

.meas tran vdout1_38ck240 FIND v(dout1_38) AT=125.025n

.meas tran vdout1_39ck240 FIND v(dout1_39) AT=125.025n

.meas tran vdout1_40ck240 FIND v(dout1_40) AT=125.025n

.meas tran vdout1_41ck240 FIND v(dout1_41) AT=125.025n

.meas tran vdout1_42ck240 FIND v(dout1_42) AT=125.025n

.meas tran vdout1_43ck240 FIND v(dout1_43) AT=125.025n

.meas tran vdout1_44ck240 FIND v(dout1_44) AT=125.025n

.meas tran vdout1_45ck240 FIND v(dout1_45) AT=125.025n

.meas tran vdout1_46ck240 FIND v(dout1_46) AT=125.025n

.meas tran vdout1_47ck240 FIND v(dout1_47) AT=125.025n

.meas tran vdout1_48ck240 FIND v(dout1_48) AT=125.025n

.meas tran vdout1_49ck240 FIND v(dout1_49) AT=125.025n

.meas tran vdout1_50ck240 FIND v(dout1_50) AT=125.025n

.meas tran vdout1_51ck240 FIND v(dout1_51) AT=125.025n

.meas tran vdout1_52ck240 FIND v(dout1_52) AT=125.025n

.meas tran vdout1_53ck240 FIND v(dout1_53) AT=125.025n

.meas tran vdout1_54ck240 FIND v(dout1_54) AT=125.025n

.meas tran vdout1_55ck240 FIND v(dout1_55) AT=125.025n

.meas tran vdout1_56ck240 FIND v(dout1_56) AT=125.025n

.meas tran vdout1_57ck240 FIND v(dout1_57) AT=125.025n

.meas tran vdout1_58ck240 FIND v(dout1_58) AT=125.025n

.meas tran vdout1_59ck240 FIND v(dout1_59) AT=125.025n

.meas tran vdout1_60ck240 FIND v(dout1_60) AT=125.025n

.meas tran vdout1_61ck240 FIND v(dout1_61) AT=125.025n

.meas tran vdout1_62ck240 FIND v(dout1_62) AT=125.025n

.meas tran vdout1_63ck240 FIND v(dout1_63) AT=125.025n

.meas tran vdout1_64ck240 FIND v(dout1_64) AT=125.025n

.meas tran vdout1_65ck240 FIND v(dout1_65) AT=125.025n

.meas tran vdout1_66ck240 FIND v(dout1_66) AT=125.025n

.meas tran vdout1_67ck240 FIND v(dout1_67) AT=125.025n

.meas tran vdout1_68ck240 FIND v(dout1_68) AT=125.025n

.meas tran vdout1_69ck240 FIND v(dout1_69) AT=125.025n

.meas tran vdout1_70ck240 FIND v(dout1_70) AT=125.025n

.meas tran vdout1_71ck240 FIND v(dout1_71) AT=125.025n

.meas tran vdout1_72ck240 FIND v(dout1_72) AT=125.025n

.meas tran vdout1_73ck240 FIND v(dout1_73) AT=125.025n

.meas tran vdout1_74ck240 FIND v(dout1_74) AT=125.025n

.meas tran vdout1_75ck240 FIND v(dout1_75) AT=125.025n

.meas tran vdout1_76ck240 FIND v(dout1_76) AT=125.025n

.meas tran vdout1_77ck240 FIND v(dout1_77) AT=125.025n

.meas tran vdout1_78ck240 FIND v(dout1_78) AT=125.025n

.meas tran vdout1_79ck240 FIND v(dout1_79) AT=125.025n

.meas tran vdout1_80ck240 FIND v(dout1_80) AT=125.025n

.meas tran vdout1_81ck240 FIND v(dout1_81) AT=125.025n

.meas tran vdout1_82ck240 FIND v(dout1_82) AT=125.025n

.meas tran vdout1_83ck240 FIND v(dout1_83) AT=125.025n

.meas tran vdout1_84ck240 FIND v(dout1_84) AT=125.025n

.meas tran vdout1_85ck240 FIND v(dout1_85) AT=125.025n

.meas tran vdout1_86ck240 FIND v(dout1_86) AT=125.025n

.meas tran vdout1_87ck240 FIND v(dout1_87) AT=125.025n

.meas tran vdout1_88ck240 FIND v(dout1_88) AT=125.025n

.meas tran vdout1_89ck240 FIND v(dout1_89) AT=125.025n

.meas tran vdout1_90ck240 FIND v(dout1_90) AT=125.025n

.meas tran vdout1_91ck240 FIND v(dout1_91) AT=125.025n

.meas tran vdout1_92ck240 FIND v(dout1_92) AT=125.025n

.meas tran vdout1_93ck240 FIND v(dout1_93) AT=125.025n

.meas tran vdout1_94ck240 FIND v(dout1_94) AT=125.025n

.meas tran vdout1_95ck240 FIND v(dout1_95) AT=125.025n

.meas tran vdout1_96ck240 FIND v(dout1_96) AT=125.025n

.meas tran vdout1_97ck240 FIND v(dout1_97) AT=125.025n

.meas tran vdout1_98ck240 FIND v(dout1_98) AT=125.025n

.meas tran vdout1_99ck240 FIND v(dout1_99) AT=125.025n

.meas tran vdout1_100ck240 FIND v(dout1_100) AT=125.025n

.meas tran vdout1_101ck240 FIND v(dout1_101) AT=125.025n

.meas tran vdout1_102ck240 FIND v(dout1_102) AT=125.025n

.meas tran vdout1_103ck240 FIND v(dout1_103) AT=125.025n

.meas tran vdout1_104ck240 FIND v(dout1_104) AT=125.025n

.meas tran vdout1_105ck240 FIND v(dout1_105) AT=125.025n

.meas tran vdout1_106ck240 FIND v(dout1_106) AT=125.025n

.meas tran vdout1_107ck240 FIND v(dout1_107) AT=125.025n

.meas tran vdout1_108ck240 FIND v(dout1_108) AT=125.025n

.meas tran vdout1_109ck240 FIND v(dout1_109) AT=125.025n

.meas tran vdout1_110ck240 FIND v(dout1_110) AT=125.025n

.meas tran vdout1_111ck240 FIND v(dout1_111) AT=125.025n

.meas tran vdout1_112ck240 FIND v(dout1_112) AT=125.025n

.meas tran vdout1_113ck240 FIND v(dout1_113) AT=125.025n

.meas tran vdout1_114ck240 FIND v(dout1_114) AT=125.025n

.meas tran vdout1_115ck240 FIND v(dout1_115) AT=125.025n

.meas tran vdout1_116ck240 FIND v(dout1_116) AT=125.025n

.meas tran vdout1_117ck240 FIND v(dout1_117) AT=125.025n

.meas tran vdout1_118ck240 FIND v(dout1_118) AT=125.025n

.meas tran vdout1_119ck240 FIND v(dout1_119) AT=125.025n

.meas tran vdout1_120ck240 FIND v(dout1_120) AT=125.025n

.meas tran vdout1_121ck240 FIND v(dout1_121) AT=125.025n

.meas tran vdout1_122ck240 FIND v(dout1_122) AT=125.025n

.meas tran vdout1_123ck240 FIND v(dout1_123) AT=125.025n

.meas tran vdout1_124ck240 FIND v(dout1_124) AT=125.025n

.meas tran vdout1_125ck240 FIND v(dout1_125) AT=125.025n

.meas tran vdout1_126ck240 FIND v(dout1_126) AT=125.025n

.meas tran vdout1_127ck240 FIND v(dout1_127) AT=125.025n

.meas tran vdout1_128ck240 FIND v(dout1_128) AT=125.025n

.meas tran vdout1_129ck240 FIND v(dout1_129) AT=125.025n

.meas tran vdout1_130ck240 FIND v(dout1_130) AT=125.025n

.meas tran vdout1_131ck240 FIND v(dout1_131) AT=125.025n

.meas tran vdout1_132ck240 FIND v(dout1_132) AT=125.025n

.meas tran vdout1_133ck240 FIND v(dout1_133) AT=125.025n

.meas tran vdout1_134ck240 FIND v(dout1_134) AT=125.025n

.meas tran vdout1_135ck240 FIND v(dout1_135) AT=125.025n

.meas tran vdout1_136ck240 FIND v(dout1_136) AT=125.025n

.meas tran vdout1_137ck240 FIND v(dout1_137) AT=125.025n

.meas tran vdout1_138ck240 FIND v(dout1_138) AT=125.025n

.meas tran vdout1_139ck240 FIND v(dout1_139) AT=125.025n

.meas tran vdout1_140ck240 FIND v(dout1_140) AT=125.025n

.meas tran vdout1_141ck240 FIND v(dout1_141) AT=125.025n

.meas tran vdout1_142ck240 FIND v(dout1_142) AT=125.025n

.meas tran vdout1_143ck240 FIND v(dout1_143) AT=125.025n

.meas tran vdout1_144ck240 FIND v(dout1_144) AT=125.025n

.meas tran vdout1_145ck240 FIND v(dout1_145) AT=125.025n

.meas tran vdout1_146ck240 FIND v(dout1_146) AT=125.025n

.meas tran vdout1_147ck240 FIND v(dout1_147) AT=125.025n

.meas tran vdout1_148ck240 FIND v(dout1_148) AT=125.025n

.meas tran vdout1_149ck240 FIND v(dout1_149) AT=125.025n

.meas tran vdout1_150ck240 FIND v(dout1_150) AT=125.025n

.meas tran vdout1_151ck240 FIND v(dout1_151) AT=125.025n

.meas tran vdout1_152ck240 FIND v(dout1_152) AT=125.025n

.meas tran vdout1_153ck240 FIND v(dout1_153) AT=125.025n

.meas tran vdout1_154ck240 FIND v(dout1_154) AT=125.025n

.meas tran vdout1_155ck240 FIND v(dout1_155) AT=125.025n

.meas tran vdout1_156ck240 FIND v(dout1_156) AT=125.025n

.meas tran vdout1_157ck240 FIND v(dout1_157) AT=125.025n

.meas tran vdout1_158ck240 FIND v(dout1_158) AT=125.025n

.meas tran vdout1_159ck240 FIND v(dout1_159) AT=125.025n

.meas tran vdout1_160ck240 FIND v(dout1_160) AT=125.025n

.meas tran vdout1_161ck240 FIND v(dout1_161) AT=125.025n

.meas tran vdout1_162ck240 FIND v(dout1_162) AT=125.025n

.meas tran vdout1_163ck240 FIND v(dout1_163) AT=125.025n

.meas tran vdout1_164ck240 FIND v(dout1_164) AT=125.025n

.meas tran vdout1_165ck240 FIND v(dout1_165) AT=125.025n

.meas tran vdout1_166ck240 FIND v(dout1_166) AT=125.025n

.meas tran vdout1_167ck240 FIND v(dout1_167) AT=125.025n

.meas tran vdout1_168ck240 FIND v(dout1_168) AT=125.025n

.meas tran vdout1_169ck240 FIND v(dout1_169) AT=125.025n

.meas tran vdout1_170ck240 FIND v(dout1_170) AT=125.025n

.meas tran vdout1_171ck240 FIND v(dout1_171) AT=125.025n

.meas tran vdout1_172ck240 FIND v(dout1_172) AT=125.025n

.meas tran vdout1_173ck240 FIND v(dout1_173) AT=125.025n

.meas tran vdout1_174ck240 FIND v(dout1_174) AT=125.025n

.meas tran vdout1_175ck240 FIND v(dout1_175) AT=125.025n

.meas tran vdout1_176ck240 FIND v(dout1_176) AT=125.025n

.meas tran vdout1_177ck240 FIND v(dout1_177) AT=125.025n

.meas tran vdout1_178ck240 FIND v(dout1_178) AT=125.025n

.meas tran vdout1_179ck240 FIND v(dout1_179) AT=125.025n

.meas tran vdout1_180ck240 FIND v(dout1_180) AT=125.025n

.meas tran vdout1_181ck240 FIND v(dout1_181) AT=125.025n

.meas tran vdout1_182ck240 FIND v(dout1_182) AT=125.025n

.meas tran vdout1_183ck240 FIND v(dout1_183) AT=125.025n

.meas tran vdout1_184ck240 FIND v(dout1_184) AT=125.025n

.meas tran vdout1_185ck240 FIND v(dout1_185) AT=125.025n

.meas tran vdout1_186ck240 FIND v(dout1_186) AT=125.025n

.meas tran vdout1_187ck240 FIND v(dout1_187) AT=125.025n

.meas tran vdout1_188ck240 FIND v(dout1_188) AT=125.025n

.meas tran vdout1_189ck240 FIND v(dout1_189) AT=125.025n

.meas tran vdout1_190ck240 FIND v(dout1_190) AT=125.025n

.meas tran vdout1_191ck240 FIND v(dout1_191) AT=125.025n

.meas tran vdout1_192ck240 FIND v(dout1_192) AT=125.025n

.meas tran vdout1_193ck240 FIND v(dout1_193) AT=125.025n

.meas tran vdout1_194ck240 FIND v(dout1_194) AT=125.025n

.meas tran vdout1_195ck240 FIND v(dout1_195) AT=125.025n

.meas tran vdout1_196ck240 FIND v(dout1_196) AT=125.025n

.meas tran vdout1_197ck240 FIND v(dout1_197) AT=125.025n

.meas tran vdout1_198ck240 FIND v(dout1_198) AT=125.025n

.meas tran vdout1_199ck240 FIND v(dout1_199) AT=125.025n

.meas tran vdout1_200ck240 FIND v(dout1_200) AT=125.025n

.meas tran vdout1_201ck240 FIND v(dout1_201) AT=125.025n

.meas tran vdout1_202ck240 FIND v(dout1_202) AT=125.025n

.meas tran vdout1_203ck240 FIND v(dout1_203) AT=125.025n

.meas tran vdout1_204ck240 FIND v(dout1_204) AT=125.025n

.meas tran vdout1_205ck240 FIND v(dout1_205) AT=125.025n

.meas tran vdout1_206ck240 FIND v(dout1_206) AT=125.025n

.meas tran vdout1_207ck240 FIND v(dout1_207) AT=125.025n

.meas tran vdout1_208ck240 FIND v(dout1_208) AT=125.025n

.meas tran vdout1_209ck240 FIND v(dout1_209) AT=125.025n

.meas tran vdout1_210ck240 FIND v(dout1_210) AT=125.025n

.meas tran vdout1_211ck240 FIND v(dout1_211) AT=125.025n

.meas tran vdout1_212ck240 FIND v(dout1_212) AT=125.025n

.meas tran vdout1_213ck240 FIND v(dout1_213) AT=125.025n

.meas tran vdout1_214ck240 FIND v(dout1_214) AT=125.025n

.meas tran vdout1_215ck240 FIND v(dout1_215) AT=125.025n

.meas tran vdout1_216ck240 FIND v(dout1_216) AT=125.025n

.meas tran vdout1_217ck240 FIND v(dout1_217) AT=125.025n

.meas tran vdout1_218ck240 FIND v(dout1_218) AT=125.025n

.meas tran vdout1_219ck240 FIND v(dout1_219) AT=125.025n

.meas tran vdout1_220ck240 FIND v(dout1_220) AT=125.025n

.meas tran vdout1_221ck240 FIND v(dout1_221) AT=125.025n

.meas tran vdout1_222ck240 FIND v(dout1_222) AT=125.025n

.meas tran vdout1_223ck240 FIND v(dout1_223) AT=125.025n

.meas tran vdout1_224ck240 FIND v(dout1_224) AT=125.025n

.meas tran vdout1_225ck240 FIND v(dout1_225) AT=125.025n

.meas tran vdout1_226ck240 FIND v(dout1_226) AT=125.025n

.meas tran vdout1_227ck240 FIND v(dout1_227) AT=125.025n

.meas tran vdout1_228ck240 FIND v(dout1_228) AT=125.025n

.meas tran vdout1_229ck240 FIND v(dout1_229) AT=125.025n

.meas tran vdout1_230ck240 FIND v(dout1_230) AT=125.025n

.meas tran vdout1_231ck240 FIND v(dout1_231) AT=125.025n

.meas tran vdout1_232ck240 FIND v(dout1_232) AT=125.025n

.meas tran vdout1_233ck240 FIND v(dout1_233) AT=125.025n

.meas tran vdout1_234ck240 FIND v(dout1_234) AT=125.025n

.meas tran vdout1_235ck240 FIND v(dout1_235) AT=125.025n

.meas tran vdout1_236ck240 FIND v(dout1_236) AT=125.025n

.meas tran vdout1_237ck240 FIND v(dout1_237) AT=125.025n

.meas tran vdout1_238ck240 FIND v(dout1_238) AT=125.025n

.meas tran vdout1_239ck240 FIND v(dout1_239) AT=125.025n

.meas tran vdout1_240ck240 FIND v(dout1_240) AT=125.025n

.meas tran vdout1_241ck240 FIND v(dout1_241) AT=125.025n

.meas tran vdout1_242ck240 FIND v(dout1_242) AT=125.025n

.meas tran vdout1_243ck240 FIND v(dout1_243) AT=125.025n

.meas tran vdout1_244ck240 FIND v(dout1_244) AT=125.025n

.meas tran vdout1_245ck240 FIND v(dout1_245) AT=125.025n

.meas tran vdout1_246ck240 FIND v(dout1_246) AT=125.025n

.meas tran vdout1_247ck240 FIND v(dout1_247) AT=125.025n

.meas tran vdout1_248ck240 FIND v(dout1_248) AT=125.025n

.meas tran vdout1_249ck240 FIND v(dout1_249) AT=125.025n

.meas tran vdout1_250ck240 FIND v(dout1_250) AT=125.025n

.meas tran vdout1_251ck240 FIND v(dout1_251) AT=125.025n

.meas tran vdout1_252ck240 FIND v(dout1_252) AT=125.025n

.meas tran vdout1_253ck240 FIND v(dout1_253) AT=125.025n

.meas tran vdout1_254ck240 FIND v(dout1_254) AT=125.025n

.meas tran vdout1_255ck240 FIND v(dout1_255) AT=125.025n

.meas tran vdout1_256ck240 FIND v(dout1_256) AT=125.025n

.meas tran vdout1_257ck240 FIND v(dout1_257) AT=125.025n

.meas tran vdout1_258ck240 FIND v(dout1_258) AT=125.025n

.meas tran vdout1_259ck240 FIND v(dout1_259) AT=125.025n

.meas tran vdout1_260ck240 FIND v(dout1_260) AT=125.025n

.meas tran vdout1_261ck240 FIND v(dout1_261) AT=125.025n

.meas tran vdout1_262ck240 FIND v(dout1_262) AT=125.025n

.meas tran vdout1_263ck240 FIND v(dout1_263) AT=125.025n

.meas tran vdout1_264ck240 FIND v(dout1_264) AT=125.025n

.meas tran vdout1_265ck240 FIND v(dout1_265) AT=125.025n

.meas tran vdout1_266ck240 FIND v(dout1_266) AT=125.025n

.meas tran vdout1_267ck240 FIND v(dout1_267) AT=125.025n

.meas tran vdout1_268ck240 FIND v(dout1_268) AT=125.025n

.meas tran vdout1_269ck240 FIND v(dout1_269) AT=125.025n

.meas tran vdout1_270ck240 FIND v(dout1_270) AT=125.025n

.meas tran vdout1_271ck240 FIND v(dout1_271) AT=125.025n

.meas tran vdout1_272ck240 FIND v(dout1_272) AT=125.025n

.meas tran vdout1_273ck240 FIND v(dout1_273) AT=125.025n

.meas tran vdout1_274ck240 FIND v(dout1_274) AT=125.025n

.meas tran vdout1_275ck240 FIND v(dout1_275) AT=125.025n

.meas tran vdout1_276ck240 FIND v(dout1_276) AT=125.025n

.meas tran vdout1_277ck240 FIND v(dout1_277) AT=125.025n

.meas tran vdout1_278ck240 FIND v(dout1_278) AT=125.025n

.meas tran vdout1_279ck240 FIND v(dout1_279) AT=125.025n

.meas tran vdout1_280ck240 FIND v(dout1_280) AT=125.025n

.meas tran vdout1_281ck240 FIND v(dout1_281) AT=125.025n

.meas tran vdout1_282ck240 FIND v(dout1_282) AT=125.025n

.meas tran vdout1_283ck240 FIND v(dout1_283) AT=125.025n

.meas tran vdout1_284ck240 FIND v(dout1_284) AT=125.025n

.meas tran vdout1_285ck240 FIND v(dout1_285) AT=125.025n

.meas tran vdout1_286ck240 FIND v(dout1_286) AT=125.025n

.meas tran vdout1_287ck240 FIND v(dout1_287) AT=125.025n

.meas tran vdout1_288ck240 FIND v(dout1_288) AT=125.025n

.meas tran vdout1_289ck240 FIND v(dout1_289) AT=125.025n

.meas tran vdout1_290ck240 FIND v(dout1_290) AT=125.025n

.meas tran vdout1_291ck240 FIND v(dout1_291) AT=125.025n

.meas tran vdout1_292ck240 FIND v(dout1_292) AT=125.025n

.meas tran vdout1_293ck240 FIND v(dout1_293) AT=125.025n

.meas tran vdout1_294ck240 FIND v(dout1_294) AT=125.025n

.meas tran vdout1_295ck240 FIND v(dout1_295) AT=125.025n

.meas tran vdout1_296ck240 FIND v(dout1_296) AT=125.025n

.meas tran vdout1_297ck240 FIND v(dout1_297) AT=125.025n

.meas tran vdout1_298ck240 FIND v(dout1_298) AT=125.025n

.meas tran vdout1_299ck240 FIND v(dout1_299) AT=125.025n

.meas tran vdout1_300ck240 FIND v(dout1_300) AT=125.025n

.meas tran vdout1_301ck240 FIND v(dout1_301) AT=125.025n

.meas tran vdout1_302ck240 FIND v(dout1_302) AT=125.025n

.meas tran vdout1_303ck240 FIND v(dout1_303) AT=125.025n

.meas tran vdout1_304ck240 FIND v(dout1_304) AT=125.025n

.meas tran vdout1_305ck240 FIND v(dout1_305) AT=125.025n

.meas tran vdout1_306ck240 FIND v(dout1_306) AT=125.025n

.meas tran vdout1_307ck240 FIND v(dout1_307) AT=125.025n

.meas tran vdout1_308ck240 FIND v(dout1_308) AT=125.025n

.meas tran vdout1_309ck240 FIND v(dout1_309) AT=125.025n

.meas tran vdout1_310ck240 FIND v(dout1_310) AT=125.025n

.meas tran vdout1_311ck240 FIND v(dout1_311) AT=125.025n

.meas tran vdout1_312ck240 FIND v(dout1_312) AT=125.025n

.meas tran vdout1_313ck240 FIND v(dout1_313) AT=125.025n

.meas tran vdout1_314ck240 FIND v(dout1_314) AT=125.025n

.meas tran vdout1_315ck240 FIND v(dout1_315) AT=125.025n

.meas tran vdout1_316ck240 FIND v(dout1_316) AT=125.025n

.meas tran vdout1_317ck240 FIND v(dout1_317) AT=125.025n

.meas tran vdout1_318ck240 FIND v(dout1_318) AT=125.025n

.meas tran vdout1_319ck240 FIND v(dout1_319) AT=125.025n

.meas tran vdout1_320ck240 FIND v(dout1_320) AT=125.025n

.meas tran vdout1_321ck240 FIND v(dout1_321) AT=125.025n

.meas tran vdout1_322ck240 FIND v(dout1_322) AT=125.025n

.meas tran vdout1_323ck240 FIND v(dout1_323) AT=125.025n

.meas tran vdout1_324ck240 FIND v(dout1_324) AT=125.025n

.meas tran vdout1_325ck240 FIND v(dout1_325) AT=125.025n

.meas tran vdout1_326ck240 FIND v(dout1_326) AT=125.025n

.meas tran vdout1_327ck240 FIND v(dout1_327) AT=125.025n

.meas tran vdout1_328ck240 FIND v(dout1_328) AT=125.025n

.meas tran vdout1_329ck240 FIND v(dout1_329) AT=125.025n

.meas tran vdout1_330ck240 FIND v(dout1_330) AT=125.025n

.meas tran vdout1_331ck240 FIND v(dout1_331) AT=125.025n

.meas tran vdout1_332ck240 FIND v(dout1_332) AT=125.025n

.meas tran vdout1_333ck240 FIND v(dout1_333) AT=125.025n

.meas tran vdout1_334ck240 FIND v(dout1_334) AT=125.025n

.meas tran vdout1_335ck240 FIND v(dout1_335) AT=125.025n

.meas tran vdout1_336ck240 FIND v(dout1_336) AT=125.025n

.meas tran vdout1_337ck240 FIND v(dout1_337) AT=125.025n

.meas tran vdout1_338ck240 FIND v(dout1_338) AT=125.025n

.meas tran vdout1_339ck240 FIND v(dout1_339) AT=125.025n

.meas tran vdout1_340ck240 FIND v(dout1_340) AT=125.025n

.meas tran vdout1_341ck240 FIND v(dout1_341) AT=125.025n

.meas tran vdout1_342ck240 FIND v(dout1_342) AT=125.025n

.meas tran vdout1_343ck240 FIND v(dout1_343) AT=125.025n

.meas tran vdout1_344ck240 FIND v(dout1_344) AT=125.025n

.meas tran vdout1_345ck240 FIND v(dout1_345) AT=125.025n

.meas tran vdout1_346ck240 FIND v(dout1_346) AT=125.025n

.meas tran vdout1_347ck240 FIND v(dout1_347) AT=125.025n

.meas tran vdout1_348ck240 FIND v(dout1_348) AT=125.025n

.meas tran vdout1_349ck240 FIND v(dout1_349) AT=125.025n

.meas tran vdout1_350ck240 FIND v(dout1_350) AT=125.025n

.meas tran vdout1_351ck240 FIND v(dout1_351) AT=125.025n

.meas tran vdout1_352ck240 FIND v(dout1_352) AT=125.025n

.meas tran vdout1_353ck240 FIND v(dout1_353) AT=125.025n

.meas tran vdout1_354ck240 FIND v(dout1_354) AT=125.025n

.meas tran vdout1_355ck240 FIND v(dout1_355) AT=125.025n

.meas tran vdout1_356ck240 FIND v(dout1_356) AT=125.025n

.meas tran vdout1_357ck240 FIND v(dout1_357) AT=125.025n

.meas tran vdout1_358ck240 FIND v(dout1_358) AT=125.025n

.meas tran vdout1_359ck240 FIND v(dout1_359) AT=125.025n

.meas tran vdout1_360ck240 FIND v(dout1_360) AT=125.025n

.meas tran vdout1_361ck240 FIND v(dout1_361) AT=125.025n

.meas tran vdout1_362ck240 FIND v(dout1_362) AT=125.025n

.meas tran vdout1_363ck240 FIND v(dout1_363) AT=125.025n

.meas tran vdout1_364ck240 FIND v(dout1_364) AT=125.025n

.meas tran vdout1_365ck240 FIND v(dout1_365) AT=125.025n

.meas tran vdout1_366ck240 FIND v(dout1_366) AT=125.025n

.meas tran vdout1_367ck240 FIND v(dout1_367) AT=125.025n

.meas tran vdout1_368ck240 FIND v(dout1_368) AT=125.025n

.meas tran vdout1_369ck240 FIND v(dout1_369) AT=125.025n

.meas tran vdout1_370ck240 FIND v(dout1_370) AT=125.025n

.meas tran vdout1_371ck240 FIND v(dout1_371) AT=125.025n

.meas tran vdout1_372ck240 FIND v(dout1_372) AT=125.025n

.meas tran vdout1_373ck240 FIND v(dout1_373) AT=125.025n

.meas tran vdout1_374ck240 FIND v(dout1_374) AT=125.025n

.meas tran vdout1_375ck240 FIND v(dout1_375) AT=125.025n

.meas tran vdout1_376ck240 FIND v(dout1_376) AT=125.025n

.meas tran vdout1_377ck240 FIND v(dout1_377) AT=125.025n

.meas tran vdout1_378ck240 FIND v(dout1_378) AT=125.025n

.meas tran vdout1_379ck240 FIND v(dout1_379) AT=125.025n

.meas tran vdout1_380ck240 FIND v(dout1_380) AT=125.025n

.meas tran vdout1_381ck240 FIND v(dout1_381) AT=125.025n

.meas tran vdout1_382ck240 FIND v(dout1_382) AT=125.025n

.meas tran vdout1_383ck240 FIND v(dout1_383) AT=125.025n

.meas tran vdout1_384ck240 FIND v(dout1_384) AT=125.025n

.meas tran vdout1_385ck240 FIND v(dout1_385) AT=125.025n

.meas tran vdout1_386ck240 FIND v(dout1_386) AT=125.025n

.meas tran vdout1_387ck240 FIND v(dout1_387) AT=125.025n

.meas tran vdout1_388ck240 FIND v(dout1_388) AT=125.025n

.meas tran vdout1_389ck240 FIND v(dout1_389) AT=125.025n

.meas tran vdout1_390ck240 FIND v(dout1_390) AT=125.025n

.meas tran vdout1_391ck240 FIND v(dout1_391) AT=125.025n

.meas tran vdout1_392ck240 FIND v(dout1_392) AT=125.025n

.meas tran vdout1_393ck240 FIND v(dout1_393) AT=125.025n

.meas tran vdout1_394ck240 FIND v(dout1_394) AT=125.025n

.meas tran vdout1_395ck240 FIND v(dout1_395) AT=125.025n

.meas tran vdout1_396ck240 FIND v(dout1_396) AT=125.025n

.meas tran vdout1_397ck240 FIND v(dout1_397) AT=125.025n

.meas tran vdout1_398ck240 FIND v(dout1_398) AT=125.025n

.meas tran vdout1_399ck240 FIND v(dout1_399) AT=125.025n

.meas tran vdout1_400ck240 FIND v(dout1_400) AT=125.025n

.meas tran vdout1_401ck240 FIND v(dout1_401) AT=125.025n

.meas tran vdout1_402ck240 FIND v(dout1_402) AT=125.025n

.meas tran vdout1_403ck240 FIND v(dout1_403) AT=125.025n

.meas tran vdout1_404ck240 FIND v(dout1_404) AT=125.025n

.meas tran vdout1_405ck240 FIND v(dout1_405) AT=125.025n

.meas tran vdout1_406ck240 FIND v(dout1_406) AT=125.025n

.meas tran vdout1_407ck240 FIND v(dout1_407) AT=125.025n

.meas tran vdout1_408ck240 FIND v(dout1_408) AT=125.025n

.meas tran vdout1_409ck240 FIND v(dout1_409) AT=125.025n

.meas tran vdout1_410ck240 FIND v(dout1_410) AT=125.025n

.meas tran vdout1_411ck240 FIND v(dout1_411) AT=125.025n

.meas tran vdout1_412ck240 FIND v(dout1_412) AT=125.025n

.meas tran vdout1_413ck240 FIND v(dout1_413) AT=125.025n

.meas tran vdout1_414ck240 FIND v(dout1_414) AT=125.025n

.meas tran vdout1_415ck240 FIND v(dout1_415) AT=125.025n

.meas tran vdout1_416ck240 FIND v(dout1_416) AT=125.025n

.meas tran vdout1_417ck240 FIND v(dout1_417) AT=125.025n

.meas tran vdout1_418ck240 FIND v(dout1_418) AT=125.025n

.meas tran vdout1_419ck240 FIND v(dout1_419) AT=125.025n

.meas tran vdout1_420ck240 FIND v(dout1_420) AT=125.025n

.meas tran vdout1_421ck240 FIND v(dout1_421) AT=125.025n

.meas tran vdout1_422ck240 FIND v(dout1_422) AT=125.025n

.meas tran vdout1_423ck240 FIND v(dout1_423) AT=125.025n

.meas tran vdout1_424ck240 FIND v(dout1_424) AT=125.025n

.meas tran vdout1_425ck240 FIND v(dout1_425) AT=125.025n

.meas tran vdout1_426ck240 FIND v(dout1_426) AT=125.025n

.meas tran vdout1_427ck240 FIND v(dout1_427) AT=125.025n

.meas tran vdout1_428ck240 FIND v(dout1_428) AT=125.025n

.meas tran vdout1_429ck240 FIND v(dout1_429) AT=125.025n

.meas tran vdout1_430ck240 FIND v(dout1_430) AT=125.025n

.meas tran vdout1_431ck240 FIND v(dout1_431) AT=125.025n

.meas tran vdout1_432ck240 FIND v(dout1_432) AT=125.025n

.meas tran vdout1_433ck240 FIND v(dout1_433) AT=125.025n

.meas tran vdout1_434ck240 FIND v(dout1_434) AT=125.025n

.meas tran vdout1_435ck240 FIND v(dout1_435) AT=125.025n

.meas tran vdout1_436ck240 FIND v(dout1_436) AT=125.025n

.meas tran vdout1_437ck240 FIND v(dout1_437) AT=125.025n

.meas tran vdout1_438ck240 FIND v(dout1_438) AT=125.025n

.meas tran vdout1_439ck240 FIND v(dout1_439) AT=125.025n

.meas tran vdout1_440ck240 FIND v(dout1_440) AT=125.025n

.meas tran vdout1_441ck240 FIND v(dout1_441) AT=125.025n

.meas tran vdout1_442ck240 FIND v(dout1_442) AT=125.025n

.meas tran vdout1_443ck240 FIND v(dout1_443) AT=125.025n

.meas tran vdout1_444ck240 FIND v(dout1_444) AT=125.025n

.meas tran vdout1_445ck240 FIND v(dout1_445) AT=125.025n

.meas tran vdout1_446ck240 FIND v(dout1_446) AT=125.025n

.meas tran vdout1_447ck240 FIND v(dout1_447) AT=125.025n

.meas tran vdout1_448ck240 FIND v(dout1_448) AT=125.025n

.meas tran vdout1_449ck240 FIND v(dout1_449) AT=125.025n

.meas tran vdout1_450ck240 FIND v(dout1_450) AT=125.025n

.meas tran vdout1_451ck240 FIND v(dout1_451) AT=125.025n

.meas tran vdout1_452ck240 FIND v(dout1_452) AT=125.025n

.meas tran vdout1_453ck240 FIND v(dout1_453) AT=125.025n

.meas tran vdout1_454ck240 FIND v(dout1_454) AT=125.025n

.meas tran vdout1_455ck240 FIND v(dout1_455) AT=125.025n

.meas tran vdout1_456ck240 FIND v(dout1_456) AT=125.025n

.meas tran vdout1_457ck240 FIND v(dout1_457) AT=125.025n

.meas tran vdout1_458ck240 FIND v(dout1_458) AT=125.025n

.meas tran vdout1_459ck240 FIND v(dout1_459) AT=125.025n

.meas tran vdout1_460ck240 FIND v(dout1_460) AT=125.025n

.meas tran vdout1_461ck240 FIND v(dout1_461) AT=125.025n

.meas tran vdout1_462ck240 FIND v(dout1_462) AT=125.025n

.meas tran vdout1_463ck240 FIND v(dout1_463) AT=125.025n

.meas tran vdout1_464ck240 FIND v(dout1_464) AT=125.025n

.meas tran vdout1_465ck240 FIND v(dout1_465) AT=125.025n

.meas tran vdout1_466ck240 FIND v(dout1_466) AT=125.025n

.meas tran vdout1_467ck240 FIND v(dout1_467) AT=125.025n

.meas tran vdout1_468ck240 FIND v(dout1_468) AT=125.025n

.meas tran vdout1_469ck240 FIND v(dout1_469) AT=125.025n

.meas tran vdout1_470ck240 FIND v(dout1_470) AT=125.025n

.meas tran vdout1_471ck240 FIND v(dout1_471) AT=125.025n

.meas tran vdout1_472ck240 FIND v(dout1_472) AT=125.025n

.meas tran vdout1_473ck240 FIND v(dout1_473) AT=125.025n

.meas tran vdout1_474ck240 FIND v(dout1_474) AT=125.025n

.meas tran vdout1_475ck240 FIND v(dout1_475) AT=125.025n

.meas tran vdout1_476ck240 FIND v(dout1_476) AT=125.025n

.meas tran vdout1_477ck240 FIND v(dout1_477) AT=125.025n

.meas tran vdout1_478ck240 FIND v(dout1_478) AT=125.025n

.meas tran vdout1_479ck240 FIND v(dout1_479) AT=125.025n

.meas tran vdout1_480ck240 FIND v(dout1_480) AT=125.025n

.meas tran vdout1_481ck240 FIND v(dout1_481) AT=125.025n

.meas tran vdout1_482ck240 FIND v(dout1_482) AT=125.025n

.meas tran vdout1_483ck240 FIND v(dout1_483) AT=125.025n

.meas tran vdout1_484ck240 FIND v(dout1_484) AT=125.025n

.meas tran vdout1_485ck240 FIND v(dout1_485) AT=125.025n

.meas tran vdout1_486ck240 FIND v(dout1_486) AT=125.025n

.meas tran vdout1_487ck240 FIND v(dout1_487) AT=125.025n

.meas tran vdout1_488ck240 FIND v(dout1_488) AT=125.025n

.meas tran vdout1_489ck240 FIND v(dout1_489) AT=125.025n

.meas tran vdout1_490ck240 FIND v(dout1_490) AT=125.025n

.meas tran vdout1_491ck240 FIND v(dout1_491) AT=125.025n

.meas tran vdout1_492ck240 FIND v(dout1_492) AT=125.025n

.meas tran vdout1_493ck240 FIND v(dout1_493) AT=125.025n

.meas tran vdout1_494ck240 FIND v(dout1_494) AT=125.025n

.meas tran vdout1_495ck240 FIND v(dout1_495) AT=125.025n

.meas tran vdout1_496ck240 FIND v(dout1_496) AT=125.025n

.meas tran vdout1_497ck240 FIND v(dout1_497) AT=125.025n

.meas tran vdout1_498ck240 FIND v(dout1_498) AT=125.025n

.meas tran vdout1_499ck240 FIND v(dout1_499) AT=125.025n

.meas tran vdout1_500ck240 FIND v(dout1_500) AT=125.025n

.meas tran vdout1_501ck240 FIND v(dout1_501) AT=125.025n

.meas tran vdout1_502ck240 FIND v(dout1_502) AT=125.025n

.meas tran vdout1_503ck240 FIND v(dout1_503) AT=125.025n

.meas tran vdout1_504ck240 FIND v(dout1_504) AT=125.025n

.meas tran vdout1_505ck240 FIND v(dout1_505) AT=125.025n

.meas tran vdout1_506ck240 FIND v(dout1_506) AT=125.025n

.meas tran vdout1_507ck240 FIND v(dout1_507) AT=125.025n

.meas tran vdout1_508ck240 FIND v(dout1_508) AT=125.025n

.meas tran vdout1_509ck240 FIND v(dout1_509) AT=125.025n

.meas tran vdout1_510ck240 FIND v(dout1_510) AT=125.025n

.meas tran vdout1_511ck240 FIND v(dout1_511) AT=125.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_17ck250 FIND v(dout1_17) AT=130.025n

.meas tran vdout1_18ck250 FIND v(dout1_18) AT=130.025n

.meas tran vdout1_19ck250 FIND v(dout1_19) AT=130.025n

.meas tran vdout1_20ck250 FIND v(dout1_20) AT=130.025n

.meas tran vdout1_21ck250 FIND v(dout1_21) AT=130.025n

.meas tran vdout1_22ck250 FIND v(dout1_22) AT=130.025n

.meas tran vdout1_23ck250 FIND v(dout1_23) AT=130.025n

.meas tran vdout1_24ck250 FIND v(dout1_24) AT=130.025n

.meas tran vdout1_25ck250 FIND v(dout1_25) AT=130.025n

.meas tran vdout1_26ck250 FIND v(dout1_26) AT=130.025n

.meas tran vdout1_27ck250 FIND v(dout1_27) AT=130.025n

.meas tran vdout1_28ck250 FIND v(dout1_28) AT=130.025n

.meas tran vdout1_29ck250 FIND v(dout1_29) AT=130.025n

.meas tran vdout1_30ck250 FIND v(dout1_30) AT=130.025n

.meas tran vdout1_31ck250 FIND v(dout1_31) AT=130.025n

.meas tran vdout1_32ck250 FIND v(dout1_32) AT=130.025n

.meas tran vdout1_33ck250 FIND v(dout1_33) AT=130.025n

.meas tran vdout1_34ck250 FIND v(dout1_34) AT=130.025n

.meas tran vdout1_35ck250 FIND v(dout1_35) AT=130.025n

.meas tran vdout1_36ck250 FIND v(dout1_36) AT=130.025n

.meas tran vdout1_37ck250 FIND v(dout1_37) AT=130.025n

.meas tran vdout1_38ck250 FIND v(dout1_38) AT=130.025n

.meas tran vdout1_39ck250 FIND v(dout1_39) AT=130.025n

.meas tran vdout1_40ck250 FIND v(dout1_40) AT=130.025n

.meas tran vdout1_41ck250 FIND v(dout1_41) AT=130.025n

.meas tran vdout1_42ck250 FIND v(dout1_42) AT=130.025n

.meas tran vdout1_43ck250 FIND v(dout1_43) AT=130.025n

.meas tran vdout1_44ck250 FIND v(dout1_44) AT=130.025n

.meas tran vdout1_45ck250 FIND v(dout1_45) AT=130.025n

.meas tran vdout1_46ck250 FIND v(dout1_46) AT=130.025n

.meas tran vdout1_47ck250 FIND v(dout1_47) AT=130.025n

.meas tran vdout1_48ck250 FIND v(dout1_48) AT=130.025n

.meas tran vdout1_49ck250 FIND v(dout1_49) AT=130.025n

.meas tran vdout1_50ck250 FIND v(dout1_50) AT=130.025n

.meas tran vdout1_51ck250 FIND v(dout1_51) AT=130.025n

.meas tran vdout1_52ck250 FIND v(dout1_52) AT=130.025n

.meas tran vdout1_53ck250 FIND v(dout1_53) AT=130.025n

.meas tran vdout1_54ck250 FIND v(dout1_54) AT=130.025n

.meas tran vdout1_55ck250 FIND v(dout1_55) AT=130.025n

.meas tran vdout1_56ck250 FIND v(dout1_56) AT=130.025n

.meas tran vdout1_57ck250 FIND v(dout1_57) AT=130.025n

.meas tran vdout1_58ck250 FIND v(dout1_58) AT=130.025n

.meas tran vdout1_59ck250 FIND v(dout1_59) AT=130.025n

.meas tran vdout1_60ck250 FIND v(dout1_60) AT=130.025n

.meas tran vdout1_61ck250 FIND v(dout1_61) AT=130.025n

.meas tran vdout1_62ck250 FIND v(dout1_62) AT=130.025n

.meas tran vdout1_63ck250 FIND v(dout1_63) AT=130.025n

.meas tran vdout1_64ck250 FIND v(dout1_64) AT=130.025n

.meas tran vdout1_65ck250 FIND v(dout1_65) AT=130.025n

.meas tran vdout1_66ck250 FIND v(dout1_66) AT=130.025n

.meas tran vdout1_67ck250 FIND v(dout1_67) AT=130.025n

.meas tran vdout1_68ck250 FIND v(dout1_68) AT=130.025n

.meas tran vdout1_69ck250 FIND v(dout1_69) AT=130.025n

.meas tran vdout1_70ck250 FIND v(dout1_70) AT=130.025n

.meas tran vdout1_71ck250 FIND v(dout1_71) AT=130.025n

.meas tran vdout1_72ck250 FIND v(dout1_72) AT=130.025n

.meas tran vdout1_73ck250 FIND v(dout1_73) AT=130.025n

.meas tran vdout1_74ck250 FIND v(dout1_74) AT=130.025n

.meas tran vdout1_75ck250 FIND v(dout1_75) AT=130.025n

.meas tran vdout1_76ck250 FIND v(dout1_76) AT=130.025n

.meas tran vdout1_77ck250 FIND v(dout1_77) AT=130.025n

.meas tran vdout1_78ck250 FIND v(dout1_78) AT=130.025n

.meas tran vdout1_79ck250 FIND v(dout1_79) AT=130.025n

.meas tran vdout1_80ck250 FIND v(dout1_80) AT=130.025n

.meas tran vdout1_81ck250 FIND v(dout1_81) AT=130.025n

.meas tran vdout1_82ck250 FIND v(dout1_82) AT=130.025n

.meas tran vdout1_83ck250 FIND v(dout1_83) AT=130.025n

.meas tran vdout1_84ck250 FIND v(dout1_84) AT=130.025n

.meas tran vdout1_85ck250 FIND v(dout1_85) AT=130.025n

.meas tran vdout1_86ck250 FIND v(dout1_86) AT=130.025n

.meas tran vdout1_87ck250 FIND v(dout1_87) AT=130.025n

.meas tran vdout1_88ck250 FIND v(dout1_88) AT=130.025n

.meas tran vdout1_89ck250 FIND v(dout1_89) AT=130.025n

.meas tran vdout1_90ck250 FIND v(dout1_90) AT=130.025n

.meas tran vdout1_91ck250 FIND v(dout1_91) AT=130.025n

.meas tran vdout1_92ck250 FIND v(dout1_92) AT=130.025n

.meas tran vdout1_93ck250 FIND v(dout1_93) AT=130.025n

.meas tran vdout1_94ck250 FIND v(dout1_94) AT=130.025n

.meas tran vdout1_95ck250 FIND v(dout1_95) AT=130.025n

.meas tran vdout1_96ck250 FIND v(dout1_96) AT=130.025n

.meas tran vdout1_97ck250 FIND v(dout1_97) AT=130.025n

.meas tran vdout1_98ck250 FIND v(dout1_98) AT=130.025n

.meas tran vdout1_99ck250 FIND v(dout1_99) AT=130.025n

.meas tran vdout1_100ck250 FIND v(dout1_100) AT=130.025n

.meas tran vdout1_101ck250 FIND v(dout1_101) AT=130.025n

.meas tran vdout1_102ck250 FIND v(dout1_102) AT=130.025n

.meas tran vdout1_103ck250 FIND v(dout1_103) AT=130.025n

.meas tran vdout1_104ck250 FIND v(dout1_104) AT=130.025n

.meas tran vdout1_105ck250 FIND v(dout1_105) AT=130.025n

.meas tran vdout1_106ck250 FIND v(dout1_106) AT=130.025n

.meas tran vdout1_107ck250 FIND v(dout1_107) AT=130.025n

.meas tran vdout1_108ck250 FIND v(dout1_108) AT=130.025n

.meas tran vdout1_109ck250 FIND v(dout1_109) AT=130.025n

.meas tran vdout1_110ck250 FIND v(dout1_110) AT=130.025n

.meas tran vdout1_111ck250 FIND v(dout1_111) AT=130.025n

.meas tran vdout1_112ck250 FIND v(dout1_112) AT=130.025n

.meas tran vdout1_113ck250 FIND v(dout1_113) AT=130.025n

.meas tran vdout1_114ck250 FIND v(dout1_114) AT=130.025n

.meas tran vdout1_115ck250 FIND v(dout1_115) AT=130.025n

.meas tran vdout1_116ck250 FIND v(dout1_116) AT=130.025n

.meas tran vdout1_117ck250 FIND v(dout1_117) AT=130.025n

.meas tran vdout1_118ck250 FIND v(dout1_118) AT=130.025n

.meas tran vdout1_119ck250 FIND v(dout1_119) AT=130.025n

.meas tran vdout1_120ck250 FIND v(dout1_120) AT=130.025n

.meas tran vdout1_121ck250 FIND v(dout1_121) AT=130.025n

.meas tran vdout1_122ck250 FIND v(dout1_122) AT=130.025n

.meas tran vdout1_123ck250 FIND v(dout1_123) AT=130.025n

.meas tran vdout1_124ck250 FIND v(dout1_124) AT=130.025n

.meas tran vdout1_125ck250 FIND v(dout1_125) AT=130.025n

.meas tran vdout1_126ck250 FIND v(dout1_126) AT=130.025n

.meas tran vdout1_127ck250 FIND v(dout1_127) AT=130.025n

.meas tran vdout1_128ck250 FIND v(dout1_128) AT=130.025n

.meas tran vdout1_129ck250 FIND v(dout1_129) AT=130.025n

.meas tran vdout1_130ck250 FIND v(dout1_130) AT=130.025n

.meas tran vdout1_131ck250 FIND v(dout1_131) AT=130.025n

.meas tran vdout1_132ck250 FIND v(dout1_132) AT=130.025n

.meas tran vdout1_133ck250 FIND v(dout1_133) AT=130.025n

.meas tran vdout1_134ck250 FIND v(dout1_134) AT=130.025n

.meas tran vdout1_135ck250 FIND v(dout1_135) AT=130.025n

.meas tran vdout1_136ck250 FIND v(dout1_136) AT=130.025n

.meas tran vdout1_137ck250 FIND v(dout1_137) AT=130.025n

.meas tran vdout1_138ck250 FIND v(dout1_138) AT=130.025n

.meas tran vdout1_139ck250 FIND v(dout1_139) AT=130.025n

.meas tran vdout1_140ck250 FIND v(dout1_140) AT=130.025n

.meas tran vdout1_141ck250 FIND v(dout1_141) AT=130.025n

.meas tran vdout1_142ck250 FIND v(dout1_142) AT=130.025n

.meas tran vdout1_143ck250 FIND v(dout1_143) AT=130.025n

.meas tran vdout1_144ck250 FIND v(dout1_144) AT=130.025n

.meas tran vdout1_145ck250 FIND v(dout1_145) AT=130.025n

.meas tran vdout1_146ck250 FIND v(dout1_146) AT=130.025n

.meas tran vdout1_147ck250 FIND v(dout1_147) AT=130.025n

.meas tran vdout1_148ck250 FIND v(dout1_148) AT=130.025n

.meas tran vdout1_149ck250 FIND v(dout1_149) AT=130.025n

.meas tran vdout1_150ck250 FIND v(dout1_150) AT=130.025n

.meas tran vdout1_151ck250 FIND v(dout1_151) AT=130.025n

.meas tran vdout1_152ck250 FIND v(dout1_152) AT=130.025n

.meas tran vdout1_153ck250 FIND v(dout1_153) AT=130.025n

.meas tran vdout1_154ck250 FIND v(dout1_154) AT=130.025n

.meas tran vdout1_155ck250 FIND v(dout1_155) AT=130.025n

.meas tran vdout1_156ck250 FIND v(dout1_156) AT=130.025n

.meas tran vdout1_157ck250 FIND v(dout1_157) AT=130.025n

.meas tran vdout1_158ck250 FIND v(dout1_158) AT=130.025n

.meas tran vdout1_159ck250 FIND v(dout1_159) AT=130.025n

.meas tran vdout1_160ck250 FIND v(dout1_160) AT=130.025n

.meas tran vdout1_161ck250 FIND v(dout1_161) AT=130.025n

.meas tran vdout1_162ck250 FIND v(dout1_162) AT=130.025n

.meas tran vdout1_163ck250 FIND v(dout1_163) AT=130.025n

.meas tran vdout1_164ck250 FIND v(dout1_164) AT=130.025n

.meas tran vdout1_165ck250 FIND v(dout1_165) AT=130.025n

.meas tran vdout1_166ck250 FIND v(dout1_166) AT=130.025n

.meas tran vdout1_167ck250 FIND v(dout1_167) AT=130.025n

.meas tran vdout1_168ck250 FIND v(dout1_168) AT=130.025n

.meas tran vdout1_169ck250 FIND v(dout1_169) AT=130.025n

.meas tran vdout1_170ck250 FIND v(dout1_170) AT=130.025n

.meas tran vdout1_171ck250 FIND v(dout1_171) AT=130.025n

.meas tran vdout1_172ck250 FIND v(dout1_172) AT=130.025n

.meas tran vdout1_173ck250 FIND v(dout1_173) AT=130.025n

.meas tran vdout1_174ck250 FIND v(dout1_174) AT=130.025n

.meas tran vdout1_175ck250 FIND v(dout1_175) AT=130.025n

.meas tran vdout1_176ck250 FIND v(dout1_176) AT=130.025n

.meas tran vdout1_177ck250 FIND v(dout1_177) AT=130.025n

.meas tran vdout1_178ck250 FIND v(dout1_178) AT=130.025n

.meas tran vdout1_179ck250 FIND v(dout1_179) AT=130.025n

.meas tran vdout1_180ck250 FIND v(dout1_180) AT=130.025n

.meas tran vdout1_181ck250 FIND v(dout1_181) AT=130.025n

.meas tran vdout1_182ck250 FIND v(dout1_182) AT=130.025n

.meas tran vdout1_183ck250 FIND v(dout1_183) AT=130.025n

.meas tran vdout1_184ck250 FIND v(dout1_184) AT=130.025n

.meas tran vdout1_185ck250 FIND v(dout1_185) AT=130.025n

.meas tran vdout1_186ck250 FIND v(dout1_186) AT=130.025n

.meas tran vdout1_187ck250 FIND v(dout1_187) AT=130.025n

.meas tran vdout1_188ck250 FIND v(dout1_188) AT=130.025n

.meas tran vdout1_189ck250 FIND v(dout1_189) AT=130.025n

.meas tran vdout1_190ck250 FIND v(dout1_190) AT=130.025n

.meas tran vdout1_191ck250 FIND v(dout1_191) AT=130.025n

.meas tran vdout1_192ck250 FIND v(dout1_192) AT=130.025n

.meas tran vdout1_193ck250 FIND v(dout1_193) AT=130.025n

.meas tran vdout1_194ck250 FIND v(dout1_194) AT=130.025n

.meas tran vdout1_195ck250 FIND v(dout1_195) AT=130.025n

.meas tran vdout1_196ck250 FIND v(dout1_196) AT=130.025n

.meas tran vdout1_197ck250 FIND v(dout1_197) AT=130.025n

.meas tran vdout1_198ck250 FIND v(dout1_198) AT=130.025n

.meas tran vdout1_199ck250 FIND v(dout1_199) AT=130.025n

.meas tran vdout1_200ck250 FIND v(dout1_200) AT=130.025n

.meas tran vdout1_201ck250 FIND v(dout1_201) AT=130.025n

.meas tran vdout1_202ck250 FIND v(dout1_202) AT=130.025n

.meas tran vdout1_203ck250 FIND v(dout1_203) AT=130.025n

.meas tran vdout1_204ck250 FIND v(dout1_204) AT=130.025n

.meas tran vdout1_205ck250 FIND v(dout1_205) AT=130.025n

.meas tran vdout1_206ck250 FIND v(dout1_206) AT=130.025n

.meas tran vdout1_207ck250 FIND v(dout1_207) AT=130.025n

.meas tran vdout1_208ck250 FIND v(dout1_208) AT=130.025n

.meas tran vdout1_209ck250 FIND v(dout1_209) AT=130.025n

.meas tran vdout1_210ck250 FIND v(dout1_210) AT=130.025n

.meas tran vdout1_211ck250 FIND v(dout1_211) AT=130.025n

.meas tran vdout1_212ck250 FIND v(dout1_212) AT=130.025n

.meas tran vdout1_213ck250 FIND v(dout1_213) AT=130.025n

.meas tran vdout1_214ck250 FIND v(dout1_214) AT=130.025n

.meas tran vdout1_215ck250 FIND v(dout1_215) AT=130.025n

.meas tran vdout1_216ck250 FIND v(dout1_216) AT=130.025n

.meas tran vdout1_217ck250 FIND v(dout1_217) AT=130.025n

.meas tran vdout1_218ck250 FIND v(dout1_218) AT=130.025n

.meas tran vdout1_219ck250 FIND v(dout1_219) AT=130.025n

.meas tran vdout1_220ck250 FIND v(dout1_220) AT=130.025n

.meas tran vdout1_221ck250 FIND v(dout1_221) AT=130.025n

.meas tran vdout1_222ck250 FIND v(dout1_222) AT=130.025n

.meas tran vdout1_223ck250 FIND v(dout1_223) AT=130.025n

.meas tran vdout1_224ck250 FIND v(dout1_224) AT=130.025n

.meas tran vdout1_225ck250 FIND v(dout1_225) AT=130.025n

.meas tran vdout1_226ck250 FIND v(dout1_226) AT=130.025n

.meas tran vdout1_227ck250 FIND v(dout1_227) AT=130.025n

.meas tran vdout1_228ck250 FIND v(dout1_228) AT=130.025n

.meas tran vdout1_229ck250 FIND v(dout1_229) AT=130.025n

.meas tran vdout1_230ck250 FIND v(dout1_230) AT=130.025n

.meas tran vdout1_231ck250 FIND v(dout1_231) AT=130.025n

.meas tran vdout1_232ck250 FIND v(dout1_232) AT=130.025n

.meas tran vdout1_233ck250 FIND v(dout1_233) AT=130.025n

.meas tran vdout1_234ck250 FIND v(dout1_234) AT=130.025n

.meas tran vdout1_235ck250 FIND v(dout1_235) AT=130.025n

.meas tran vdout1_236ck250 FIND v(dout1_236) AT=130.025n

.meas tran vdout1_237ck250 FIND v(dout1_237) AT=130.025n

.meas tran vdout1_238ck250 FIND v(dout1_238) AT=130.025n

.meas tran vdout1_239ck250 FIND v(dout1_239) AT=130.025n

.meas tran vdout1_240ck250 FIND v(dout1_240) AT=130.025n

.meas tran vdout1_241ck250 FIND v(dout1_241) AT=130.025n

.meas tran vdout1_242ck250 FIND v(dout1_242) AT=130.025n

.meas tran vdout1_243ck250 FIND v(dout1_243) AT=130.025n

.meas tran vdout1_244ck250 FIND v(dout1_244) AT=130.025n

.meas tran vdout1_245ck250 FIND v(dout1_245) AT=130.025n

.meas tran vdout1_246ck250 FIND v(dout1_246) AT=130.025n

.meas tran vdout1_247ck250 FIND v(dout1_247) AT=130.025n

.meas tran vdout1_248ck250 FIND v(dout1_248) AT=130.025n

.meas tran vdout1_249ck250 FIND v(dout1_249) AT=130.025n

.meas tran vdout1_250ck250 FIND v(dout1_250) AT=130.025n

.meas tran vdout1_251ck250 FIND v(dout1_251) AT=130.025n

.meas tran vdout1_252ck250 FIND v(dout1_252) AT=130.025n

.meas tran vdout1_253ck250 FIND v(dout1_253) AT=130.025n

.meas tran vdout1_254ck250 FIND v(dout1_254) AT=130.025n

.meas tran vdout1_255ck250 FIND v(dout1_255) AT=130.025n

.meas tran vdout1_256ck250 FIND v(dout1_256) AT=130.025n

.meas tran vdout1_257ck250 FIND v(dout1_257) AT=130.025n

.meas tran vdout1_258ck250 FIND v(dout1_258) AT=130.025n

.meas tran vdout1_259ck250 FIND v(dout1_259) AT=130.025n

.meas tran vdout1_260ck250 FIND v(dout1_260) AT=130.025n

.meas tran vdout1_261ck250 FIND v(dout1_261) AT=130.025n

.meas tran vdout1_262ck250 FIND v(dout1_262) AT=130.025n

.meas tran vdout1_263ck250 FIND v(dout1_263) AT=130.025n

.meas tran vdout1_264ck250 FIND v(dout1_264) AT=130.025n

.meas tran vdout1_265ck250 FIND v(dout1_265) AT=130.025n

.meas tran vdout1_266ck250 FIND v(dout1_266) AT=130.025n

.meas tran vdout1_267ck250 FIND v(dout1_267) AT=130.025n

.meas tran vdout1_268ck250 FIND v(dout1_268) AT=130.025n

.meas tran vdout1_269ck250 FIND v(dout1_269) AT=130.025n

.meas tran vdout1_270ck250 FIND v(dout1_270) AT=130.025n

.meas tran vdout1_271ck250 FIND v(dout1_271) AT=130.025n

.meas tran vdout1_272ck250 FIND v(dout1_272) AT=130.025n

.meas tran vdout1_273ck250 FIND v(dout1_273) AT=130.025n

.meas tran vdout1_274ck250 FIND v(dout1_274) AT=130.025n

.meas tran vdout1_275ck250 FIND v(dout1_275) AT=130.025n

.meas tran vdout1_276ck250 FIND v(dout1_276) AT=130.025n

.meas tran vdout1_277ck250 FIND v(dout1_277) AT=130.025n

.meas tran vdout1_278ck250 FIND v(dout1_278) AT=130.025n

.meas tran vdout1_279ck250 FIND v(dout1_279) AT=130.025n

.meas tran vdout1_280ck250 FIND v(dout1_280) AT=130.025n

.meas tran vdout1_281ck250 FIND v(dout1_281) AT=130.025n

.meas tran vdout1_282ck250 FIND v(dout1_282) AT=130.025n

.meas tran vdout1_283ck250 FIND v(dout1_283) AT=130.025n

.meas tran vdout1_284ck250 FIND v(dout1_284) AT=130.025n

.meas tran vdout1_285ck250 FIND v(dout1_285) AT=130.025n

.meas tran vdout1_286ck250 FIND v(dout1_286) AT=130.025n

.meas tran vdout1_287ck250 FIND v(dout1_287) AT=130.025n

.meas tran vdout1_288ck250 FIND v(dout1_288) AT=130.025n

.meas tran vdout1_289ck250 FIND v(dout1_289) AT=130.025n

.meas tran vdout1_290ck250 FIND v(dout1_290) AT=130.025n

.meas tran vdout1_291ck250 FIND v(dout1_291) AT=130.025n

.meas tran vdout1_292ck250 FIND v(dout1_292) AT=130.025n

.meas tran vdout1_293ck250 FIND v(dout1_293) AT=130.025n

.meas tran vdout1_294ck250 FIND v(dout1_294) AT=130.025n

.meas tran vdout1_295ck250 FIND v(dout1_295) AT=130.025n

.meas tran vdout1_296ck250 FIND v(dout1_296) AT=130.025n

.meas tran vdout1_297ck250 FIND v(dout1_297) AT=130.025n

.meas tran vdout1_298ck250 FIND v(dout1_298) AT=130.025n

.meas tran vdout1_299ck250 FIND v(dout1_299) AT=130.025n

.meas tran vdout1_300ck250 FIND v(dout1_300) AT=130.025n

.meas tran vdout1_301ck250 FIND v(dout1_301) AT=130.025n

.meas tran vdout1_302ck250 FIND v(dout1_302) AT=130.025n

.meas tran vdout1_303ck250 FIND v(dout1_303) AT=130.025n

.meas tran vdout1_304ck250 FIND v(dout1_304) AT=130.025n

.meas tran vdout1_305ck250 FIND v(dout1_305) AT=130.025n

.meas tran vdout1_306ck250 FIND v(dout1_306) AT=130.025n

.meas tran vdout1_307ck250 FIND v(dout1_307) AT=130.025n

.meas tran vdout1_308ck250 FIND v(dout1_308) AT=130.025n

.meas tran vdout1_309ck250 FIND v(dout1_309) AT=130.025n

.meas tran vdout1_310ck250 FIND v(dout1_310) AT=130.025n

.meas tran vdout1_311ck250 FIND v(dout1_311) AT=130.025n

.meas tran vdout1_312ck250 FIND v(dout1_312) AT=130.025n

.meas tran vdout1_313ck250 FIND v(dout1_313) AT=130.025n

.meas tran vdout1_314ck250 FIND v(dout1_314) AT=130.025n

.meas tran vdout1_315ck250 FIND v(dout1_315) AT=130.025n

.meas tran vdout1_316ck250 FIND v(dout1_316) AT=130.025n

.meas tran vdout1_317ck250 FIND v(dout1_317) AT=130.025n

.meas tran vdout1_318ck250 FIND v(dout1_318) AT=130.025n

.meas tran vdout1_319ck250 FIND v(dout1_319) AT=130.025n

.meas tran vdout1_320ck250 FIND v(dout1_320) AT=130.025n

.meas tran vdout1_321ck250 FIND v(dout1_321) AT=130.025n

.meas tran vdout1_322ck250 FIND v(dout1_322) AT=130.025n

.meas tran vdout1_323ck250 FIND v(dout1_323) AT=130.025n

.meas tran vdout1_324ck250 FIND v(dout1_324) AT=130.025n

.meas tran vdout1_325ck250 FIND v(dout1_325) AT=130.025n

.meas tran vdout1_326ck250 FIND v(dout1_326) AT=130.025n

.meas tran vdout1_327ck250 FIND v(dout1_327) AT=130.025n

.meas tran vdout1_328ck250 FIND v(dout1_328) AT=130.025n

.meas tran vdout1_329ck250 FIND v(dout1_329) AT=130.025n

.meas tran vdout1_330ck250 FIND v(dout1_330) AT=130.025n

.meas tran vdout1_331ck250 FIND v(dout1_331) AT=130.025n

.meas tran vdout1_332ck250 FIND v(dout1_332) AT=130.025n

.meas tran vdout1_333ck250 FIND v(dout1_333) AT=130.025n

.meas tran vdout1_334ck250 FIND v(dout1_334) AT=130.025n

.meas tran vdout1_335ck250 FIND v(dout1_335) AT=130.025n

.meas tran vdout1_336ck250 FIND v(dout1_336) AT=130.025n

.meas tran vdout1_337ck250 FIND v(dout1_337) AT=130.025n

.meas tran vdout1_338ck250 FIND v(dout1_338) AT=130.025n

.meas tran vdout1_339ck250 FIND v(dout1_339) AT=130.025n

.meas tran vdout1_340ck250 FIND v(dout1_340) AT=130.025n

.meas tran vdout1_341ck250 FIND v(dout1_341) AT=130.025n

.meas tran vdout1_342ck250 FIND v(dout1_342) AT=130.025n

.meas tran vdout1_343ck250 FIND v(dout1_343) AT=130.025n

.meas tran vdout1_344ck250 FIND v(dout1_344) AT=130.025n

.meas tran vdout1_345ck250 FIND v(dout1_345) AT=130.025n

.meas tran vdout1_346ck250 FIND v(dout1_346) AT=130.025n

.meas tran vdout1_347ck250 FIND v(dout1_347) AT=130.025n

.meas tran vdout1_348ck250 FIND v(dout1_348) AT=130.025n

.meas tran vdout1_349ck250 FIND v(dout1_349) AT=130.025n

.meas tran vdout1_350ck250 FIND v(dout1_350) AT=130.025n

.meas tran vdout1_351ck250 FIND v(dout1_351) AT=130.025n

.meas tran vdout1_352ck250 FIND v(dout1_352) AT=130.025n

.meas tran vdout1_353ck250 FIND v(dout1_353) AT=130.025n

.meas tran vdout1_354ck250 FIND v(dout1_354) AT=130.025n

.meas tran vdout1_355ck250 FIND v(dout1_355) AT=130.025n

.meas tran vdout1_356ck250 FIND v(dout1_356) AT=130.025n

.meas tran vdout1_357ck250 FIND v(dout1_357) AT=130.025n

.meas tran vdout1_358ck250 FIND v(dout1_358) AT=130.025n

.meas tran vdout1_359ck250 FIND v(dout1_359) AT=130.025n

.meas tran vdout1_360ck250 FIND v(dout1_360) AT=130.025n

.meas tran vdout1_361ck250 FIND v(dout1_361) AT=130.025n

.meas tran vdout1_362ck250 FIND v(dout1_362) AT=130.025n

.meas tran vdout1_363ck250 FIND v(dout1_363) AT=130.025n

.meas tran vdout1_364ck250 FIND v(dout1_364) AT=130.025n

.meas tran vdout1_365ck250 FIND v(dout1_365) AT=130.025n

.meas tran vdout1_366ck250 FIND v(dout1_366) AT=130.025n

.meas tran vdout1_367ck250 FIND v(dout1_367) AT=130.025n

.meas tran vdout1_368ck250 FIND v(dout1_368) AT=130.025n

.meas tran vdout1_369ck250 FIND v(dout1_369) AT=130.025n

.meas tran vdout1_370ck250 FIND v(dout1_370) AT=130.025n

.meas tran vdout1_371ck250 FIND v(dout1_371) AT=130.025n

.meas tran vdout1_372ck250 FIND v(dout1_372) AT=130.025n

.meas tran vdout1_373ck250 FIND v(dout1_373) AT=130.025n

.meas tran vdout1_374ck250 FIND v(dout1_374) AT=130.025n

.meas tran vdout1_375ck250 FIND v(dout1_375) AT=130.025n

.meas tran vdout1_376ck250 FIND v(dout1_376) AT=130.025n

.meas tran vdout1_377ck250 FIND v(dout1_377) AT=130.025n

.meas tran vdout1_378ck250 FIND v(dout1_378) AT=130.025n

.meas tran vdout1_379ck250 FIND v(dout1_379) AT=130.025n

.meas tran vdout1_380ck250 FIND v(dout1_380) AT=130.025n

.meas tran vdout1_381ck250 FIND v(dout1_381) AT=130.025n

.meas tran vdout1_382ck250 FIND v(dout1_382) AT=130.025n

.meas tran vdout1_383ck250 FIND v(dout1_383) AT=130.025n

.meas tran vdout1_384ck250 FIND v(dout1_384) AT=130.025n

.meas tran vdout1_385ck250 FIND v(dout1_385) AT=130.025n

.meas tran vdout1_386ck250 FIND v(dout1_386) AT=130.025n

.meas tran vdout1_387ck250 FIND v(dout1_387) AT=130.025n

.meas tran vdout1_388ck250 FIND v(dout1_388) AT=130.025n

.meas tran vdout1_389ck250 FIND v(dout1_389) AT=130.025n

.meas tran vdout1_390ck250 FIND v(dout1_390) AT=130.025n

.meas tran vdout1_391ck250 FIND v(dout1_391) AT=130.025n

.meas tran vdout1_392ck250 FIND v(dout1_392) AT=130.025n

.meas tran vdout1_393ck250 FIND v(dout1_393) AT=130.025n

.meas tran vdout1_394ck250 FIND v(dout1_394) AT=130.025n

.meas tran vdout1_395ck250 FIND v(dout1_395) AT=130.025n

.meas tran vdout1_396ck250 FIND v(dout1_396) AT=130.025n

.meas tran vdout1_397ck250 FIND v(dout1_397) AT=130.025n

.meas tran vdout1_398ck250 FIND v(dout1_398) AT=130.025n

.meas tran vdout1_399ck250 FIND v(dout1_399) AT=130.025n

.meas tran vdout1_400ck250 FIND v(dout1_400) AT=130.025n

.meas tran vdout1_401ck250 FIND v(dout1_401) AT=130.025n

.meas tran vdout1_402ck250 FIND v(dout1_402) AT=130.025n

.meas tran vdout1_403ck250 FIND v(dout1_403) AT=130.025n

.meas tran vdout1_404ck250 FIND v(dout1_404) AT=130.025n

.meas tran vdout1_405ck250 FIND v(dout1_405) AT=130.025n

.meas tran vdout1_406ck250 FIND v(dout1_406) AT=130.025n

.meas tran vdout1_407ck250 FIND v(dout1_407) AT=130.025n

.meas tran vdout1_408ck250 FIND v(dout1_408) AT=130.025n

.meas tran vdout1_409ck250 FIND v(dout1_409) AT=130.025n

.meas tran vdout1_410ck250 FIND v(dout1_410) AT=130.025n

.meas tran vdout1_411ck250 FIND v(dout1_411) AT=130.025n

.meas tran vdout1_412ck250 FIND v(dout1_412) AT=130.025n

.meas tran vdout1_413ck250 FIND v(dout1_413) AT=130.025n

.meas tran vdout1_414ck250 FIND v(dout1_414) AT=130.025n

.meas tran vdout1_415ck250 FIND v(dout1_415) AT=130.025n

.meas tran vdout1_416ck250 FIND v(dout1_416) AT=130.025n

.meas tran vdout1_417ck250 FIND v(dout1_417) AT=130.025n

.meas tran vdout1_418ck250 FIND v(dout1_418) AT=130.025n

.meas tran vdout1_419ck250 FIND v(dout1_419) AT=130.025n

.meas tran vdout1_420ck250 FIND v(dout1_420) AT=130.025n

.meas tran vdout1_421ck250 FIND v(dout1_421) AT=130.025n

.meas tran vdout1_422ck250 FIND v(dout1_422) AT=130.025n

.meas tran vdout1_423ck250 FIND v(dout1_423) AT=130.025n

.meas tran vdout1_424ck250 FIND v(dout1_424) AT=130.025n

.meas tran vdout1_425ck250 FIND v(dout1_425) AT=130.025n

.meas tran vdout1_426ck250 FIND v(dout1_426) AT=130.025n

.meas tran vdout1_427ck250 FIND v(dout1_427) AT=130.025n

.meas tran vdout1_428ck250 FIND v(dout1_428) AT=130.025n

.meas tran vdout1_429ck250 FIND v(dout1_429) AT=130.025n

.meas tran vdout1_430ck250 FIND v(dout1_430) AT=130.025n

.meas tran vdout1_431ck250 FIND v(dout1_431) AT=130.025n

.meas tran vdout1_432ck250 FIND v(dout1_432) AT=130.025n

.meas tran vdout1_433ck250 FIND v(dout1_433) AT=130.025n

.meas tran vdout1_434ck250 FIND v(dout1_434) AT=130.025n

.meas tran vdout1_435ck250 FIND v(dout1_435) AT=130.025n

.meas tran vdout1_436ck250 FIND v(dout1_436) AT=130.025n

.meas tran vdout1_437ck250 FIND v(dout1_437) AT=130.025n

.meas tran vdout1_438ck250 FIND v(dout1_438) AT=130.025n

.meas tran vdout1_439ck250 FIND v(dout1_439) AT=130.025n

.meas tran vdout1_440ck250 FIND v(dout1_440) AT=130.025n

.meas tran vdout1_441ck250 FIND v(dout1_441) AT=130.025n

.meas tran vdout1_442ck250 FIND v(dout1_442) AT=130.025n

.meas tran vdout1_443ck250 FIND v(dout1_443) AT=130.025n

.meas tran vdout1_444ck250 FIND v(dout1_444) AT=130.025n

.meas tran vdout1_445ck250 FIND v(dout1_445) AT=130.025n

.meas tran vdout1_446ck250 FIND v(dout1_446) AT=130.025n

.meas tran vdout1_447ck250 FIND v(dout1_447) AT=130.025n

.meas tran vdout1_448ck250 FIND v(dout1_448) AT=130.025n

.meas tran vdout1_449ck250 FIND v(dout1_449) AT=130.025n

.meas tran vdout1_450ck250 FIND v(dout1_450) AT=130.025n

.meas tran vdout1_451ck250 FIND v(dout1_451) AT=130.025n

.meas tran vdout1_452ck250 FIND v(dout1_452) AT=130.025n

.meas tran vdout1_453ck250 FIND v(dout1_453) AT=130.025n

.meas tran vdout1_454ck250 FIND v(dout1_454) AT=130.025n

.meas tran vdout1_455ck250 FIND v(dout1_455) AT=130.025n

.meas tran vdout1_456ck250 FIND v(dout1_456) AT=130.025n

.meas tran vdout1_457ck250 FIND v(dout1_457) AT=130.025n

.meas tran vdout1_458ck250 FIND v(dout1_458) AT=130.025n

.meas tran vdout1_459ck250 FIND v(dout1_459) AT=130.025n

.meas tran vdout1_460ck250 FIND v(dout1_460) AT=130.025n

.meas tran vdout1_461ck250 FIND v(dout1_461) AT=130.025n

.meas tran vdout1_462ck250 FIND v(dout1_462) AT=130.025n

.meas tran vdout1_463ck250 FIND v(dout1_463) AT=130.025n

.meas tran vdout1_464ck250 FIND v(dout1_464) AT=130.025n

.meas tran vdout1_465ck250 FIND v(dout1_465) AT=130.025n

.meas tran vdout1_466ck250 FIND v(dout1_466) AT=130.025n

.meas tran vdout1_467ck250 FIND v(dout1_467) AT=130.025n

.meas tran vdout1_468ck250 FIND v(dout1_468) AT=130.025n

.meas tran vdout1_469ck250 FIND v(dout1_469) AT=130.025n

.meas tran vdout1_470ck250 FIND v(dout1_470) AT=130.025n

.meas tran vdout1_471ck250 FIND v(dout1_471) AT=130.025n

.meas tran vdout1_472ck250 FIND v(dout1_472) AT=130.025n

.meas tran vdout1_473ck250 FIND v(dout1_473) AT=130.025n

.meas tran vdout1_474ck250 FIND v(dout1_474) AT=130.025n

.meas tran vdout1_475ck250 FIND v(dout1_475) AT=130.025n

.meas tran vdout1_476ck250 FIND v(dout1_476) AT=130.025n

.meas tran vdout1_477ck250 FIND v(dout1_477) AT=130.025n

.meas tran vdout1_478ck250 FIND v(dout1_478) AT=130.025n

.meas tran vdout1_479ck250 FIND v(dout1_479) AT=130.025n

.meas tran vdout1_480ck250 FIND v(dout1_480) AT=130.025n

.meas tran vdout1_481ck250 FIND v(dout1_481) AT=130.025n

.meas tran vdout1_482ck250 FIND v(dout1_482) AT=130.025n

.meas tran vdout1_483ck250 FIND v(dout1_483) AT=130.025n

.meas tran vdout1_484ck250 FIND v(dout1_484) AT=130.025n

.meas tran vdout1_485ck250 FIND v(dout1_485) AT=130.025n

.meas tran vdout1_486ck250 FIND v(dout1_486) AT=130.025n

.meas tran vdout1_487ck250 FIND v(dout1_487) AT=130.025n

.meas tran vdout1_488ck250 FIND v(dout1_488) AT=130.025n

.meas tran vdout1_489ck250 FIND v(dout1_489) AT=130.025n

.meas tran vdout1_490ck250 FIND v(dout1_490) AT=130.025n

.meas tran vdout1_491ck250 FIND v(dout1_491) AT=130.025n

.meas tran vdout1_492ck250 FIND v(dout1_492) AT=130.025n

.meas tran vdout1_493ck250 FIND v(dout1_493) AT=130.025n

.meas tran vdout1_494ck250 FIND v(dout1_494) AT=130.025n

.meas tran vdout1_495ck250 FIND v(dout1_495) AT=130.025n

.meas tran vdout1_496ck250 FIND v(dout1_496) AT=130.025n

.meas tran vdout1_497ck250 FIND v(dout1_497) AT=130.025n

.meas tran vdout1_498ck250 FIND v(dout1_498) AT=130.025n

.meas tran vdout1_499ck250 FIND v(dout1_499) AT=130.025n

.meas tran vdout1_500ck250 FIND v(dout1_500) AT=130.025n

.meas tran vdout1_501ck250 FIND v(dout1_501) AT=130.025n

.meas tran vdout1_502ck250 FIND v(dout1_502) AT=130.025n

.meas tran vdout1_503ck250 FIND v(dout1_503) AT=130.025n

.meas tran vdout1_504ck250 FIND v(dout1_504) AT=130.025n

.meas tran vdout1_505ck250 FIND v(dout1_505) AT=130.025n

.meas tran vdout1_506ck250 FIND v(dout1_506) AT=130.025n

.meas tran vdout1_507ck250 FIND v(dout1_507) AT=130.025n

.meas tran vdout1_508ck250 FIND v(dout1_508) AT=130.025n

.meas tran vdout1_509ck250 FIND v(dout1_509) AT=130.025n

.meas tran vdout1_510ck250 FIND v(dout1_510) AT=130.025n

.meas tran vdout1_511ck250 FIND v(dout1_511) AT=130.025n

.meas tran vdout1_0ck270 FIND v(dout1_0) AT=140.025n

.meas tran vdout1_1ck270 FIND v(dout1_1) AT=140.025n

.meas tran vdout1_2ck270 FIND v(dout1_2) AT=140.025n

.meas tran vdout1_3ck270 FIND v(dout1_3) AT=140.025n

.meas tran vdout1_4ck270 FIND v(dout1_4) AT=140.025n

.meas tran vdout1_5ck270 FIND v(dout1_5) AT=140.025n

.meas tran vdout1_6ck270 FIND v(dout1_6) AT=140.025n

.meas tran vdout1_7ck270 FIND v(dout1_7) AT=140.025n

.meas tran vdout1_8ck270 FIND v(dout1_8) AT=140.025n

.meas tran vdout1_9ck270 FIND v(dout1_9) AT=140.025n

.meas tran vdout1_10ck270 FIND v(dout1_10) AT=140.025n

.meas tran vdout1_11ck270 FIND v(dout1_11) AT=140.025n

.meas tran vdout1_12ck270 FIND v(dout1_12) AT=140.025n

.meas tran vdout1_13ck270 FIND v(dout1_13) AT=140.025n

.meas tran vdout1_14ck270 FIND v(dout1_14) AT=140.025n

.meas tran vdout1_15ck270 FIND v(dout1_15) AT=140.025n

.meas tran vdout1_16ck270 FIND v(dout1_16) AT=140.025n

.meas tran vdout1_17ck270 FIND v(dout1_17) AT=140.025n

.meas tran vdout1_18ck270 FIND v(dout1_18) AT=140.025n

.meas tran vdout1_19ck270 FIND v(dout1_19) AT=140.025n

.meas tran vdout1_20ck270 FIND v(dout1_20) AT=140.025n

.meas tran vdout1_21ck270 FIND v(dout1_21) AT=140.025n

.meas tran vdout1_22ck270 FIND v(dout1_22) AT=140.025n

.meas tran vdout1_23ck270 FIND v(dout1_23) AT=140.025n

.meas tran vdout1_24ck270 FIND v(dout1_24) AT=140.025n

.meas tran vdout1_25ck270 FIND v(dout1_25) AT=140.025n

.meas tran vdout1_26ck270 FIND v(dout1_26) AT=140.025n

.meas tran vdout1_27ck270 FIND v(dout1_27) AT=140.025n

.meas tran vdout1_28ck270 FIND v(dout1_28) AT=140.025n

.meas tran vdout1_29ck270 FIND v(dout1_29) AT=140.025n

.meas tran vdout1_30ck270 FIND v(dout1_30) AT=140.025n

.meas tran vdout1_31ck270 FIND v(dout1_31) AT=140.025n

.meas tran vdout1_32ck270 FIND v(dout1_32) AT=140.025n

.meas tran vdout1_33ck270 FIND v(dout1_33) AT=140.025n

.meas tran vdout1_34ck270 FIND v(dout1_34) AT=140.025n

.meas tran vdout1_35ck270 FIND v(dout1_35) AT=140.025n

.meas tran vdout1_36ck270 FIND v(dout1_36) AT=140.025n

.meas tran vdout1_37ck270 FIND v(dout1_37) AT=140.025n

.meas tran vdout1_38ck270 FIND v(dout1_38) AT=140.025n

.meas tran vdout1_39ck270 FIND v(dout1_39) AT=140.025n

.meas tran vdout1_40ck270 FIND v(dout1_40) AT=140.025n

.meas tran vdout1_41ck270 FIND v(dout1_41) AT=140.025n

.meas tran vdout1_42ck270 FIND v(dout1_42) AT=140.025n

.meas tran vdout1_43ck270 FIND v(dout1_43) AT=140.025n

.meas tran vdout1_44ck270 FIND v(dout1_44) AT=140.025n

.meas tran vdout1_45ck270 FIND v(dout1_45) AT=140.025n

.meas tran vdout1_46ck270 FIND v(dout1_46) AT=140.025n

.meas tran vdout1_47ck270 FIND v(dout1_47) AT=140.025n

.meas tran vdout1_48ck270 FIND v(dout1_48) AT=140.025n

.meas tran vdout1_49ck270 FIND v(dout1_49) AT=140.025n

.meas tran vdout1_50ck270 FIND v(dout1_50) AT=140.025n

.meas tran vdout1_51ck270 FIND v(dout1_51) AT=140.025n

.meas tran vdout1_52ck270 FIND v(dout1_52) AT=140.025n

.meas tran vdout1_53ck270 FIND v(dout1_53) AT=140.025n

.meas tran vdout1_54ck270 FIND v(dout1_54) AT=140.025n

.meas tran vdout1_55ck270 FIND v(dout1_55) AT=140.025n

.meas tran vdout1_56ck270 FIND v(dout1_56) AT=140.025n

.meas tran vdout1_57ck270 FIND v(dout1_57) AT=140.025n

.meas tran vdout1_58ck270 FIND v(dout1_58) AT=140.025n

.meas tran vdout1_59ck270 FIND v(dout1_59) AT=140.025n

.meas tran vdout1_60ck270 FIND v(dout1_60) AT=140.025n

.meas tran vdout1_61ck270 FIND v(dout1_61) AT=140.025n

.meas tran vdout1_62ck270 FIND v(dout1_62) AT=140.025n

.meas tran vdout1_63ck270 FIND v(dout1_63) AT=140.025n

.meas tran vdout1_64ck270 FIND v(dout1_64) AT=140.025n

.meas tran vdout1_65ck270 FIND v(dout1_65) AT=140.025n

.meas tran vdout1_66ck270 FIND v(dout1_66) AT=140.025n

.meas tran vdout1_67ck270 FIND v(dout1_67) AT=140.025n

.meas tran vdout1_68ck270 FIND v(dout1_68) AT=140.025n

.meas tran vdout1_69ck270 FIND v(dout1_69) AT=140.025n

.meas tran vdout1_70ck270 FIND v(dout1_70) AT=140.025n

.meas tran vdout1_71ck270 FIND v(dout1_71) AT=140.025n

.meas tran vdout1_72ck270 FIND v(dout1_72) AT=140.025n

.meas tran vdout1_73ck270 FIND v(dout1_73) AT=140.025n

.meas tran vdout1_74ck270 FIND v(dout1_74) AT=140.025n

.meas tran vdout1_75ck270 FIND v(dout1_75) AT=140.025n

.meas tran vdout1_76ck270 FIND v(dout1_76) AT=140.025n

.meas tran vdout1_77ck270 FIND v(dout1_77) AT=140.025n

.meas tran vdout1_78ck270 FIND v(dout1_78) AT=140.025n

.meas tran vdout1_79ck270 FIND v(dout1_79) AT=140.025n

.meas tran vdout1_80ck270 FIND v(dout1_80) AT=140.025n

.meas tran vdout1_81ck270 FIND v(dout1_81) AT=140.025n

.meas tran vdout1_82ck270 FIND v(dout1_82) AT=140.025n

.meas tran vdout1_83ck270 FIND v(dout1_83) AT=140.025n

.meas tran vdout1_84ck270 FIND v(dout1_84) AT=140.025n

.meas tran vdout1_85ck270 FIND v(dout1_85) AT=140.025n

.meas tran vdout1_86ck270 FIND v(dout1_86) AT=140.025n

.meas tran vdout1_87ck270 FIND v(dout1_87) AT=140.025n

.meas tran vdout1_88ck270 FIND v(dout1_88) AT=140.025n

.meas tran vdout1_89ck270 FIND v(dout1_89) AT=140.025n

.meas tran vdout1_90ck270 FIND v(dout1_90) AT=140.025n

.meas tran vdout1_91ck270 FIND v(dout1_91) AT=140.025n

.meas tran vdout1_92ck270 FIND v(dout1_92) AT=140.025n

.meas tran vdout1_93ck270 FIND v(dout1_93) AT=140.025n

.meas tran vdout1_94ck270 FIND v(dout1_94) AT=140.025n

.meas tran vdout1_95ck270 FIND v(dout1_95) AT=140.025n

.meas tran vdout1_96ck270 FIND v(dout1_96) AT=140.025n

.meas tran vdout1_97ck270 FIND v(dout1_97) AT=140.025n

.meas tran vdout1_98ck270 FIND v(dout1_98) AT=140.025n

.meas tran vdout1_99ck270 FIND v(dout1_99) AT=140.025n

.meas tran vdout1_100ck270 FIND v(dout1_100) AT=140.025n

.meas tran vdout1_101ck270 FIND v(dout1_101) AT=140.025n

.meas tran vdout1_102ck270 FIND v(dout1_102) AT=140.025n

.meas tran vdout1_103ck270 FIND v(dout1_103) AT=140.025n

.meas tran vdout1_104ck270 FIND v(dout1_104) AT=140.025n

.meas tran vdout1_105ck270 FIND v(dout1_105) AT=140.025n

.meas tran vdout1_106ck270 FIND v(dout1_106) AT=140.025n

.meas tran vdout1_107ck270 FIND v(dout1_107) AT=140.025n

.meas tran vdout1_108ck270 FIND v(dout1_108) AT=140.025n

.meas tran vdout1_109ck270 FIND v(dout1_109) AT=140.025n

.meas tran vdout1_110ck270 FIND v(dout1_110) AT=140.025n

.meas tran vdout1_111ck270 FIND v(dout1_111) AT=140.025n

.meas tran vdout1_112ck270 FIND v(dout1_112) AT=140.025n

.meas tran vdout1_113ck270 FIND v(dout1_113) AT=140.025n

.meas tran vdout1_114ck270 FIND v(dout1_114) AT=140.025n

.meas tran vdout1_115ck270 FIND v(dout1_115) AT=140.025n

.meas tran vdout1_116ck270 FIND v(dout1_116) AT=140.025n

.meas tran vdout1_117ck270 FIND v(dout1_117) AT=140.025n

.meas tran vdout1_118ck270 FIND v(dout1_118) AT=140.025n

.meas tran vdout1_119ck270 FIND v(dout1_119) AT=140.025n

.meas tran vdout1_120ck270 FIND v(dout1_120) AT=140.025n

.meas tran vdout1_121ck270 FIND v(dout1_121) AT=140.025n

.meas tran vdout1_122ck270 FIND v(dout1_122) AT=140.025n

.meas tran vdout1_123ck270 FIND v(dout1_123) AT=140.025n

.meas tran vdout1_124ck270 FIND v(dout1_124) AT=140.025n

.meas tran vdout1_125ck270 FIND v(dout1_125) AT=140.025n

.meas tran vdout1_126ck270 FIND v(dout1_126) AT=140.025n

.meas tran vdout1_127ck270 FIND v(dout1_127) AT=140.025n

.meas tran vdout1_128ck270 FIND v(dout1_128) AT=140.025n

.meas tran vdout1_129ck270 FIND v(dout1_129) AT=140.025n

.meas tran vdout1_130ck270 FIND v(dout1_130) AT=140.025n

.meas tran vdout1_131ck270 FIND v(dout1_131) AT=140.025n

.meas tran vdout1_132ck270 FIND v(dout1_132) AT=140.025n

.meas tran vdout1_133ck270 FIND v(dout1_133) AT=140.025n

.meas tran vdout1_134ck270 FIND v(dout1_134) AT=140.025n

.meas tran vdout1_135ck270 FIND v(dout1_135) AT=140.025n

.meas tran vdout1_136ck270 FIND v(dout1_136) AT=140.025n

.meas tran vdout1_137ck270 FIND v(dout1_137) AT=140.025n

.meas tran vdout1_138ck270 FIND v(dout1_138) AT=140.025n

.meas tran vdout1_139ck270 FIND v(dout1_139) AT=140.025n

.meas tran vdout1_140ck270 FIND v(dout1_140) AT=140.025n

.meas tran vdout1_141ck270 FIND v(dout1_141) AT=140.025n

.meas tran vdout1_142ck270 FIND v(dout1_142) AT=140.025n

.meas tran vdout1_143ck270 FIND v(dout1_143) AT=140.025n

.meas tran vdout1_144ck270 FIND v(dout1_144) AT=140.025n

.meas tran vdout1_145ck270 FIND v(dout1_145) AT=140.025n

.meas tran vdout1_146ck270 FIND v(dout1_146) AT=140.025n

.meas tran vdout1_147ck270 FIND v(dout1_147) AT=140.025n

.meas tran vdout1_148ck270 FIND v(dout1_148) AT=140.025n

.meas tran vdout1_149ck270 FIND v(dout1_149) AT=140.025n

.meas tran vdout1_150ck270 FIND v(dout1_150) AT=140.025n

.meas tran vdout1_151ck270 FIND v(dout1_151) AT=140.025n

.meas tran vdout1_152ck270 FIND v(dout1_152) AT=140.025n

.meas tran vdout1_153ck270 FIND v(dout1_153) AT=140.025n

.meas tran vdout1_154ck270 FIND v(dout1_154) AT=140.025n

.meas tran vdout1_155ck270 FIND v(dout1_155) AT=140.025n

.meas tran vdout1_156ck270 FIND v(dout1_156) AT=140.025n

.meas tran vdout1_157ck270 FIND v(dout1_157) AT=140.025n

.meas tran vdout1_158ck270 FIND v(dout1_158) AT=140.025n

.meas tran vdout1_159ck270 FIND v(dout1_159) AT=140.025n

.meas tran vdout1_160ck270 FIND v(dout1_160) AT=140.025n

.meas tran vdout1_161ck270 FIND v(dout1_161) AT=140.025n

.meas tran vdout1_162ck270 FIND v(dout1_162) AT=140.025n

.meas tran vdout1_163ck270 FIND v(dout1_163) AT=140.025n

.meas tran vdout1_164ck270 FIND v(dout1_164) AT=140.025n

.meas tran vdout1_165ck270 FIND v(dout1_165) AT=140.025n

.meas tran vdout1_166ck270 FIND v(dout1_166) AT=140.025n

.meas tran vdout1_167ck270 FIND v(dout1_167) AT=140.025n

.meas tran vdout1_168ck270 FIND v(dout1_168) AT=140.025n

.meas tran vdout1_169ck270 FIND v(dout1_169) AT=140.025n

.meas tran vdout1_170ck270 FIND v(dout1_170) AT=140.025n

.meas tran vdout1_171ck270 FIND v(dout1_171) AT=140.025n

.meas tran vdout1_172ck270 FIND v(dout1_172) AT=140.025n

.meas tran vdout1_173ck270 FIND v(dout1_173) AT=140.025n

.meas tran vdout1_174ck270 FIND v(dout1_174) AT=140.025n

.meas tran vdout1_175ck270 FIND v(dout1_175) AT=140.025n

.meas tran vdout1_176ck270 FIND v(dout1_176) AT=140.025n

.meas tran vdout1_177ck270 FIND v(dout1_177) AT=140.025n

.meas tran vdout1_178ck270 FIND v(dout1_178) AT=140.025n

.meas tran vdout1_179ck270 FIND v(dout1_179) AT=140.025n

.meas tran vdout1_180ck270 FIND v(dout1_180) AT=140.025n

.meas tran vdout1_181ck270 FIND v(dout1_181) AT=140.025n

.meas tran vdout1_182ck270 FIND v(dout1_182) AT=140.025n

.meas tran vdout1_183ck270 FIND v(dout1_183) AT=140.025n

.meas tran vdout1_184ck270 FIND v(dout1_184) AT=140.025n

.meas tran vdout1_185ck270 FIND v(dout1_185) AT=140.025n

.meas tran vdout1_186ck270 FIND v(dout1_186) AT=140.025n

.meas tran vdout1_187ck270 FIND v(dout1_187) AT=140.025n

.meas tran vdout1_188ck270 FIND v(dout1_188) AT=140.025n

.meas tran vdout1_189ck270 FIND v(dout1_189) AT=140.025n

.meas tran vdout1_190ck270 FIND v(dout1_190) AT=140.025n

.meas tran vdout1_191ck270 FIND v(dout1_191) AT=140.025n

.meas tran vdout1_192ck270 FIND v(dout1_192) AT=140.025n

.meas tran vdout1_193ck270 FIND v(dout1_193) AT=140.025n

.meas tran vdout1_194ck270 FIND v(dout1_194) AT=140.025n

.meas tran vdout1_195ck270 FIND v(dout1_195) AT=140.025n

.meas tran vdout1_196ck270 FIND v(dout1_196) AT=140.025n

.meas tran vdout1_197ck270 FIND v(dout1_197) AT=140.025n

.meas tran vdout1_198ck270 FIND v(dout1_198) AT=140.025n

.meas tran vdout1_199ck270 FIND v(dout1_199) AT=140.025n

.meas tran vdout1_200ck270 FIND v(dout1_200) AT=140.025n

.meas tran vdout1_201ck270 FIND v(dout1_201) AT=140.025n

.meas tran vdout1_202ck270 FIND v(dout1_202) AT=140.025n

.meas tran vdout1_203ck270 FIND v(dout1_203) AT=140.025n

.meas tran vdout1_204ck270 FIND v(dout1_204) AT=140.025n

.meas tran vdout1_205ck270 FIND v(dout1_205) AT=140.025n

.meas tran vdout1_206ck270 FIND v(dout1_206) AT=140.025n

.meas tran vdout1_207ck270 FIND v(dout1_207) AT=140.025n

.meas tran vdout1_208ck270 FIND v(dout1_208) AT=140.025n

.meas tran vdout1_209ck270 FIND v(dout1_209) AT=140.025n

.meas tran vdout1_210ck270 FIND v(dout1_210) AT=140.025n

.meas tran vdout1_211ck270 FIND v(dout1_211) AT=140.025n

.meas tran vdout1_212ck270 FIND v(dout1_212) AT=140.025n

.meas tran vdout1_213ck270 FIND v(dout1_213) AT=140.025n

.meas tran vdout1_214ck270 FIND v(dout1_214) AT=140.025n

.meas tran vdout1_215ck270 FIND v(dout1_215) AT=140.025n

.meas tran vdout1_216ck270 FIND v(dout1_216) AT=140.025n

.meas tran vdout1_217ck270 FIND v(dout1_217) AT=140.025n

.meas tran vdout1_218ck270 FIND v(dout1_218) AT=140.025n

.meas tran vdout1_219ck270 FIND v(dout1_219) AT=140.025n

.meas tran vdout1_220ck270 FIND v(dout1_220) AT=140.025n

.meas tran vdout1_221ck270 FIND v(dout1_221) AT=140.025n

.meas tran vdout1_222ck270 FIND v(dout1_222) AT=140.025n

.meas tran vdout1_223ck270 FIND v(dout1_223) AT=140.025n

.meas tran vdout1_224ck270 FIND v(dout1_224) AT=140.025n

.meas tran vdout1_225ck270 FIND v(dout1_225) AT=140.025n

.meas tran vdout1_226ck270 FIND v(dout1_226) AT=140.025n

.meas tran vdout1_227ck270 FIND v(dout1_227) AT=140.025n

.meas tran vdout1_228ck270 FIND v(dout1_228) AT=140.025n

.meas tran vdout1_229ck270 FIND v(dout1_229) AT=140.025n

.meas tran vdout1_230ck270 FIND v(dout1_230) AT=140.025n

.meas tran vdout1_231ck270 FIND v(dout1_231) AT=140.025n

.meas tran vdout1_232ck270 FIND v(dout1_232) AT=140.025n

.meas tran vdout1_233ck270 FIND v(dout1_233) AT=140.025n

.meas tran vdout1_234ck270 FIND v(dout1_234) AT=140.025n

.meas tran vdout1_235ck270 FIND v(dout1_235) AT=140.025n

.meas tran vdout1_236ck270 FIND v(dout1_236) AT=140.025n

.meas tran vdout1_237ck270 FIND v(dout1_237) AT=140.025n

.meas tran vdout1_238ck270 FIND v(dout1_238) AT=140.025n

.meas tran vdout1_239ck270 FIND v(dout1_239) AT=140.025n

.meas tran vdout1_240ck270 FIND v(dout1_240) AT=140.025n

.meas tran vdout1_241ck270 FIND v(dout1_241) AT=140.025n

.meas tran vdout1_242ck270 FIND v(dout1_242) AT=140.025n

.meas tran vdout1_243ck270 FIND v(dout1_243) AT=140.025n

.meas tran vdout1_244ck270 FIND v(dout1_244) AT=140.025n

.meas tran vdout1_245ck270 FIND v(dout1_245) AT=140.025n

.meas tran vdout1_246ck270 FIND v(dout1_246) AT=140.025n

.meas tran vdout1_247ck270 FIND v(dout1_247) AT=140.025n

.meas tran vdout1_248ck270 FIND v(dout1_248) AT=140.025n

.meas tran vdout1_249ck270 FIND v(dout1_249) AT=140.025n

.meas tran vdout1_250ck270 FIND v(dout1_250) AT=140.025n

.meas tran vdout1_251ck270 FIND v(dout1_251) AT=140.025n

.meas tran vdout1_252ck270 FIND v(dout1_252) AT=140.025n

.meas tran vdout1_253ck270 FIND v(dout1_253) AT=140.025n

.meas tran vdout1_254ck270 FIND v(dout1_254) AT=140.025n

.meas tran vdout1_255ck270 FIND v(dout1_255) AT=140.025n

.meas tran vdout1_256ck270 FIND v(dout1_256) AT=140.025n

.meas tran vdout1_257ck270 FIND v(dout1_257) AT=140.025n

.meas tran vdout1_258ck270 FIND v(dout1_258) AT=140.025n

.meas tran vdout1_259ck270 FIND v(dout1_259) AT=140.025n

.meas tran vdout1_260ck270 FIND v(dout1_260) AT=140.025n

.meas tran vdout1_261ck270 FIND v(dout1_261) AT=140.025n

.meas tran vdout1_262ck270 FIND v(dout1_262) AT=140.025n

.meas tran vdout1_263ck270 FIND v(dout1_263) AT=140.025n

.meas tran vdout1_264ck270 FIND v(dout1_264) AT=140.025n

.meas tran vdout1_265ck270 FIND v(dout1_265) AT=140.025n

.meas tran vdout1_266ck270 FIND v(dout1_266) AT=140.025n

.meas tran vdout1_267ck270 FIND v(dout1_267) AT=140.025n

.meas tran vdout1_268ck270 FIND v(dout1_268) AT=140.025n

.meas tran vdout1_269ck270 FIND v(dout1_269) AT=140.025n

.meas tran vdout1_270ck270 FIND v(dout1_270) AT=140.025n

.meas tran vdout1_271ck270 FIND v(dout1_271) AT=140.025n

.meas tran vdout1_272ck270 FIND v(dout1_272) AT=140.025n

.meas tran vdout1_273ck270 FIND v(dout1_273) AT=140.025n

.meas tran vdout1_274ck270 FIND v(dout1_274) AT=140.025n

.meas tran vdout1_275ck270 FIND v(dout1_275) AT=140.025n

.meas tran vdout1_276ck270 FIND v(dout1_276) AT=140.025n

.meas tran vdout1_277ck270 FIND v(dout1_277) AT=140.025n

.meas tran vdout1_278ck270 FIND v(dout1_278) AT=140.025n

.meas tran vdout1_279ck270 FIND v(dout1_279) AT=140.025n

.meas tran vdout1_280ck270 FIND v(dout1_280) AT=140.025n

.meas tran vdout1_281ck270 FIND v(dout1_281) AT=140.025n

.meas tran vdout1_282ck270 FIND v(dout1_282) AT=140.025n

.meas tran vdout1_283ck270 FIND v(dout1_283) AT=140.025n

.meas tran vdout1_284ck270 FIND v(dout1_284) AT=140.025n

.meas tran vdout1_285ck270 FIND v(dout1_285) AT=140.025n

.meas tran vdout1_286ck270 FIND v(dout1_286) AT=140.025n

.meas tran vdout1_287ck270 FIND v(dout1_287) AT=140.025n

.meas tran vdout1_288ck270 FIND v(dout1_288) AT=140.025n

.meas tran vdout1_289ck270 FIND v(dout1_289) AT=140.025n

.meas tran vdout1_290ck270 FIND v(dout1_290) AT=140.025n

.meas tran vdout1_291ck270 FIND v(dout1_291) AT=140.025n

.meas tran vdout1_292ck270 FIND v(dout1_292) AT=140.025n

.meas tran vdout1_293ck270 FIND v(dout1_293) AT=140.025n

.meas tran vdout1_294ck270 FIND v(dout1_294) AT=140.025n

.meas tran vdout1_295ck270 FIND v(dout1_295) AT=140.025n

.meas tran vdout1_296ck270 FIND v(dout1_296) AT=140.025n

.meas tran vdout1_297ck270 FIND v(dout1_297) AT=140.025n

.meas tran vdout1_298ck270 FIND v(dout1_298) AT=140.025n

.meas tran vdout1_299ck270 FIND v(dout1_299) AT=140.025n

.meas tran vdout1_300ck270 FIND v(dout1_300) AT=140.025n

.meas tran vdout1_301ck270 FIND v(dout1_301) AT=140.025n

.meas tran vdout1_302ck270 FIND v(dout1_302) AT=140.025n

.meas tran vdout1_303ck270 FIND v(dout1_303) AT=140.025n

.meas tran vdout1_304ck270 FIND v(dout1_304) AT=140.025n

.meas tran vdout1_305ck270 FIND v(dout1_305) AT=140.025n

.meas tran vdout1_306ck270 FIND v(dout1_306) AT=140.025n

.meas tran vdout1_307ck270 FIND v(dout1_307) AT=140.025n

.meas tran vdout1_308ck270 FIND v(dout1_308) AT=140.025n

.meas tran vdout1_309ck270 FIND v(dout1_309) AT=140.025n

.meas tran vdout1_310ck270 FIND v(dout1_310) AT=140.025n

.meas tran vdout1_311ck270 FIND v(dout1_311) AT=140.025n

.meas tran vdout1_312ck270 FIND v(dout1_312) AT=140.025n

.meas tran vdout1_313ck270 FIND v(dout1_313) AT=140.025n

.meas tran vdout1_314ck270 FIND v(dout1_314) AT=140.025n

.meas tran vdout1_315ck270 FIND v(dout1_315) AT=140.025n

.meas tran vdout1_316ck270 FIND v(dout1_316) AT=140.025n

.meas tran vdout1_317ck270 FIND v(dout1_317) AT=140.025n

.meas tran vdout1_318ck270 FIND v(dout1_318) AT=140.025n

.meas tran vdout1_319ck270 FIND v(dout1_319) AT=140.025n

.meas tran vdout1_320ck270 FIND v(dout1_320) AT=140.025n

.meas tran vdout1_321ck270 FIND v(dout1_321) AT=140.025n

.meas tran vdout1_322ck270 FIND v(dout1_322) AT=140.025n

.meas tran vdout1_323ck270 FIND v(dout1_323) AT=140.025n

.meas tran vdout1_324ck270 FIND v(dout1_324) AT=140.025n

.meas tran vdout1_325ck270 FIND v(dout1_325) AT=140.025n

.meas tran vdout1_326ck270 FIND v(dout1_326) AT=140.025n

.meas tran vdout1_327ck270 FIND v(dout1_327) AT=140.025n

.meas tran vdout1_328ck270 FIND v(dout1_328) AT=140.025n

.meas tran vdout1_329ck270 FIND v(dout1_329) AT=140.025n

.meas tran vdout1_330ck270 FIND v(dout1_330) AT=140.025n

.meas tran vdout1_331ck270 FIND v(dout1_331) AT=140.025n

.meas tran vdout1_332ck270 FIND v(dout1_332) AT=140.025n

.meas tran vdout1_333ck270 FIND v(dout1_333) AT=140.025n

.meas tran vdout1_334ck270 FIND v(dout1_334) AT=140.025n

.meas tran vdout1_335ck270 FIND v(dout1_335) AT=140.025n

.meas tran vdout1_336ck270 FIND v(dout1_336) AT=140.025n

.meas tran vdout1_337ck270 FIND v(dout1_337) AT=140.025n

.meas tran vdout1_338ck270 FIND v(dout1_338) AT=140.025n

.meas tran vdout1_339ck270 FIND v(dout1_339) AT=140.025n

.meas tran vdout1_340ck270 FIND v(dout1_340) AT=140.025n

.meas tran vdout1_341ck270 FIND v(dout1_341) AT=140.025n

.meas tran vdout1_342ck270 FIND v(dout1_342) AT=140.025n

.meas tran vdout1_343ck270 FIND v(dout1_343) AT=140.025n

.meas tran vdout1_344ck270 FIND v(dout1_344) AT=140.025n

.meas tran vdout1_345ck270 FIND v(dout1_345) AT=140.025n

.meas tran vdout1_346ck270 FIND v(dout1_346) AT=140.025n

.meas tran vdout1_347ck270 FIND v(dout1_347) AT=140.025n

.meas tran vdout1_348ck270 FIND v(dout1_348) AT=140.025n

.meas tran vdout1_349ck270 FIND v(dout1_349) AT=140.025n

.meas tran vdout1_350ck270 FIND v(dout1_350) AT=140.025n

.meas tran vdout1_351ck270 FIND v(dout1_351) AT=140.025n

.meas tran vdout1_352ck270 FIND v(dout1_352) AT=140.025n

.meas tran vdout1_353ck270 FIND v(dout1_353) AT=140.025n

.meas tran vdout1_354ck270 FIND v(dout1_354) AT=140.025n

.meas tran vdout1_355ck270 FIND v(dout1_355) AT=140.025n

.meas tran vdout1_356ck270 FIND v(dout1_356) AT=140.025n

.meas tran vdout1_357ck270 FIND v(dout1_357) AT=140.025n

.meas tran vdout1_358ck270 FIND v(dout1_358) AT=140.025n

.meas tran vdout1_359ck270 FIND v(dout1_359) AT=140.025n

.meas tran vdout1_360ck270 FIND v(dout1_360) AT=140.025n

.meas tran vdout1_361ck270 FIND v(dout1_361) AT=140.025n

.meas tran vdout1_362ck270 FIND v(dout1_362) AT=140.025n

.meas tran vdout1_363ck270 FIND v(dout1_363) AT=140.025n

.meas tran vdout1_364ck270 FIND v(dout1_364) AT=140.025n

.meas tran vdout1_365ck270 FIND v(dout1_365) AT=140.025n

.meas tran vdout1_366ck270 FIND v(dout1_366) AT=140.025n

.meas tran vdout1_367ck270 FIND v(dout1_367) AT=140.025n

.meas tran vdout1_368ck270 FIND v(dout1_368) AT=140.025n

.meas tran vdout1_369ck270 FIND v(dout1_369) AT=140.025n

.meas tran vdout1_370ck270 FIND v(dout1_370) AT=140.025n

.meas tran vdout1_371ck270 FIND v(dout1_371) AT=140.025n

.meas tran vdout1_372ck270 FIND v(dout1_372) AT=140.025n

.meas tran vdout1_373ck270 FIND v(dout1_373) AT=140.025n

.meas tran vdout1_374ck270 FIND v(dout1_374) AT=140.025n

.meas tran vdout1_375ck270 FIND v(dout1_375) AT=140.025n

.meas tran vdout1_376ck270 FIND v(dout1_376) AT=140.025n

.meas tran vdout1_377ck270 FIND v(dout1_377) AT=140.025n

.meas tran vdout1_378ck270 FIND v(dout1_378) AT=140.025n

.meas tran vdout1_379ck270 FIND v(dout1_379) AT=140.025n

.meas tran vdout1_380ck270 FIND v(dout1_380) AT=140.025n

.meas tran vdout1_381ck270 FIND v(dout1_381) AT=140.025n

.meas tran vdout1_382ck270 FIND v(dout1_382) AT=140.025n

.meas tran vdout1_383ck270 FIND v(dout1_383) AT=140.025n

.meas tran vdout1_384ck270 FIND v(dout1_384) AT=140.025n

.meas tran vdout1_385ck270 FIND v(dout1_385) AT=140.025n

.meas tran vdout1_386ck270 FIND v(dout1_386) AT=140.025n

.meas tran vdout1_387ck270 FIND v(dout1_387) AT=140.025n

.meas tran vdout1_388ck270 FIND v(dout1_388) AT=140.025n

.meas tran vdout1_389ck270 FIND v(dout1_389) AT=140.025n

.meas tran vdout1_390ck270 FIND v(dout1_390) AT=140.025n

.meas tran vdout1_391ck270 FIND v(dout1_391) AT=140.025n

.meas tran vdout1_392ck270 FIND v(dout1_392) AT=140.025n

.meas tran vdout1_393ck270 FIND v(dout1_393) AT=140.025n

.meas tran vdout1_394ck270 FIND v(dout1_394) AT=140.025n

.meas tran vdout1_395ck270 FIND v(dout1_395) AT=140.025n

.meas tran vdout1_396ck270 FIND v(dout1_396) AT=140.025n

.meas tran vdout1_397ck270 FIND v(dout1_397) AT=140.025n

.meas tran vdout1_398ck270 FIND v(dout1_398) AT=140.025n

.meas tran vdout1_399ck270 FIND v(dout1_399) AT=140.025n

.meas tran vdout1_400ck270 FIND v(dout1_400) AT=140.025n

.meas tran vdout1_401ck270 FIND v(dout1_401) AT=140.025n

.meas tran vdout1_402ck270 FIND v(dout1_402) AT=140.025n

.meas tran vdout1_403ck270 FIND v(dout1_403) AT=140.025n

.meas tran vdout1_404ck270 FIND v(dout1_404) AT=140.025n

.meas tran vdout1_405ck270 FIND v(dout1_405) AT=140.025n

.meas tran vdout1_406ck270 FIND v(dout1_406) AT=140.025n

.meas tran vdout1_407ck270 FIND v(dout1_407) AT=140.025n

.meas tran vdout1_408ck270 FIND v(dout1_408) AT=140.025n

.meas tran vdout1_409ck270 FIND v(dout1_409) AT=140.025n

.meas tran vdout1_410ck270 FIND v(dout1_410) AT=140.025n

.meas tran vdout1_411ck270 FIND v(dout1_411) AT=140.025n

.meas tran vdout1_412ck270 FIND v(dout1_412) AT=140.025n

.meas tran vdout1_413ck270 FIND v(dout1_413) AT=140.025n

.meas tran vdout1_414ck270 FIND v(dout1_414) AT=140.025n

.meas tran vdout1_415ck270 FIND v(dout1_415) AT=140.025n

.meas tran vdout1_416ck270 FIND v(dout1_416) AT=140.025n

.meas tran vdout1_417ck270 FIND v(dout1_417) AT=140.025n

.meas tran vdout1_418ck270 FIND v(dout1_418) AT=140.025n

.meas tran vdout1_419ck270 FIND v(dout1_419) AT=140.025n

.meas tran vdout1_420ck270 FIND v(dout1_420) AT=140.025n

.meas tran vdout1_421ck270 FIND v(dout1_421) AT=140.025n

.meas tran vdout1_422ck270 FIND v(dout1_422) AT=140.025n

.meas tran vdout1_423ck270 FIND v(dout1_423) AT=140.025n

.meas tran vdout1_424ck270 FIND v(dout1_424) AT=140.025n

.meas tran vdout1_425ck270 FIND v(dout1_425) AT=140.025n

.meas tran vdout1_426ck270 FIND v(dout1_426) AT=140.025n

.meas tran vdout1_427ck270 FIND v(dout1_427) AT=140.025n

.meas tran vdout1_428ck270 FIND v(dout1_428) AT=140.025n

.meas tran vdout1_429ck270 FIND v(dout1_429) AT=140.025n

.meas tran vdout1_430ck270 FIND v(dout1_430) AT=140.025n

.meas tran vdout1_431ck270 FIND v(dout1_431) AT=140.025n

.meas tran vdout1_432ck270 FIND v(dout1_432) AT=140.025n

.meas tran vdout1_433ck270 FIND v(dout1_433) AT=140.025n

.meas tran vdout1_434ck270 FIND v(dout1_434) AT=140.025n

.meas tran vdout1_435ck270 FIND v(dout1_435) AT=140.025n

.meas tran vdout1_436ck270 FIND v(dout1_436) AT=140.025n

.meas tran vdout1_437ck270 FIND v(dout1_437) AT=140.025n

.meas tran vdout1_438ck270 FIND v(dout1_438) AT=140.025n

.meas tran vdout1_439ck270 FIND v(dout1_439) AT=140.025n

.meas tran vdout1_440ck270 FIND v(dout1_440) AT=140.025n

.meas tran vdout1_441ck270 FIND v(dout1_441) AT=140.025n

.meas tran vdout1_442ck270 FIND v(dout1_442) AT=140.025n

.meas tran vdout1_443ck270 FIND v(dout1_443) AT=140.025n

.meas tran vdout1_444ck270 FIND v(dout1_444) AT=140.025n

.meas tran vdout1_445ck270 FIND v(dout1_445) AT=140.025n

.meas tran vdout1_446ck270 FIND v(dout1_446) AT=140.025n

.meas tran vdout1_447ck270 FIND v(dout1_447) AT=140.025n

.meas tran vdout1_448ck270 FIND v(dout1_448) AT=140.025n

.meas tran vdout1_449ck270 FIND v(dout1_449) AT=140.025n

.meas tran vdout1_450ck270 FIND v(dout1_450) AT=140.025n

.meas tran vdout1_451ck270 FIND v(dout1_451) AT=140.025n

.meas tran vdout1_452ck270 FIND v(dout1_452) AT=140.025n

.meas tran vdout1_453ck270 FIND v(dout1_453) AT=140.025n

.meas tran vdout1_454ck270 FIND v(dout1_454) AT=140.025n

.meas tran vdout1_455ck270 FIND v(dout1_455) AT=140.025n

.meas tran vdout1_456ck270 FIND v(dout1_456) AT=140.025n

.meas tran vdout1_457ck270 FIND v(dout1_457) AT=140.025n

.meas tran vdout1_458ck270 FIND v(dout1_458) AT=140.025n

.meas tran vdout1_459ck270 FIND v(dout1_459) AT=140.025n

.meas tran vdout1_460ck270 FIND v(dout1_460) AT=140.025n

.meas tran vdout1_461ck270 FIND v(dout1_461) AT=140.025n

.meas tran vdout1_462ck270 FIND v(dout1_462) AT=140.025n

.meas tran vdout1_463ck270 FIND v(dout1_463) AT=140.025n

.meas tran vdout1_464ck270 FIND v(dout1_464) AT=140.025n

.meas tran vdout1_465ck270 FIND v(dout1_465) AT=140.025n

.meas tran vdout1_466ck270 FIND v(dout1_466) AT=140.025n

.meas tran vdout1_467ck270 FIND v(dout1_467) AT=140.025n

.meas tran vdout1_468ck270 FIND v(dout1_468) AT=140.025n

.meas tran vdout1_469ck270 FIND v(dout1_469) AT=140.025n

.meas tran vdout1_470ck270 FIND v(dout1_470) AT=140.025n

.meas tran vdout1_471ck270 FIND v(dout1_471) AT=140.025n

.meas tran vdout1_472ck270 FIND v(dout1_472) AT=140.025n

.meas tran vdout1_473ck270 FIND v(dout1_473) AT=140.025n

.meas tran vdout1_474ck270 FIND v(dout1_474) AT=140.025n

.meas tran vdout1_475ck270 FIND v(dout1_475) AT=140.025n

.meas tran vdout1_476ck270 FIND v(dout1_476) AT=140.025n

.meas tran vdout1_477ck270 FIND v(dout1_477) AT=140.025n

.meas tran vdout1_478ck270 FIND v(dout1_478) AT=140.025n

.meas tran vdout1_479ck270 FIND v(dout1_479) AT=140.025n

.meas tran vdout1_480ck270 FIND v(dout1_480) AT=140.025n

.meas tran vdout1_481ck270 FIND v(dout1_481) AT=140.025n

.meas tran vdout1_482ck270 FIND v(dout1_482) AT=140.025n

.meas tran vdout1_483ck270 FIND v(dout1_483) AT=140.025n

.meas tran vdout1_484ck270 FIND v(dout1_484) AT=140.025n

.meas tran vdout1_485ck270 FIND v(dout1_485) AT=140.025n

.meas tran vdout1_486ck270 FIND v(dout1_486) AT=140.025n

.meas tran vdout1_487ck270 FIND v(dout1_487) AT=140.025n

.meas tran vdout1_488ck270 FIND v(dout1_488) AT=140.025n

.meas tran vdout1_489ck270 FIND v(dout1_489) AT=140.025n

.meas tran vdout1_490ck270 FIND v(dout1_490) AT=140.025n

.meas tran vdout1_491ck270 FIND v(dout1_491) AT=140.025n

.meas tran vdout1_492ck270 FIND v(dout1_492) AT=140.025n

.meas tran vdout1_493ck270 FIND v(dout1_493) AT=140.025n

.meas tran vdout1_494ck270 FIND v(dout1_494) AT=140.025n

.meas tran vdout1_495ck270 FIND v(dout1_495) AT=140.025n

.meas tran vdout1_496ck270 FIND v(dout1_496) AT=140.025n

.meas tran vdout1_497ck270 FIND v(dout1_497) AT=140.025n

.meas tran vdout1_498ck270 FIND v(dout1_498) AT=140.025n

.meas tran vdout1_499ck270 FIND v(dout1_499) AT=140.025n

.meas tran vdout1_500ck270 FIND v(dout1_500) AT=140.025n

.meas tran vdout1_501ck270 FIND v(dout1_501) AT=140.025n

.meas tran vdout1_502ck270 FIND v(dout1_502) AT=140.025n

.meas tran vdout1_503ck270 FIND v(dout1_503) AT=140.025n

.meas tran vdout1_504ck270 FIND v(dout1_504) AT=140.025n

.meas tran vdout1_505ck270 FIND v(dout1_505) AT=140.025n

.meas tran vdout1_506ck270 FIND v(dout1_506) AT=140.025n

.meas tran vdout1_507ck270 FIND v(dout1_507) AT=140.025n

.meas tran vdout1_508ck270 FIND v(dout1_508) AT=140.025n

.meas tran vdout1_509ck270 FIND v(dout1_509) AT=140.025n

.meas tran vdout1_510ck270 FIND v(dout1_510) AT=140.025n

.meas tran vdout1_511ck270 FIND v(dout1_511) AT=140.025n

.meas tran vdout1_0ck280 FIND v(dout1_0) AT=145.025n

.meas tran vdout1_1ck280 FIND v(dout1_1) AT=145.025n

.meas tran vdout1_2ck280 FIND v(dout1_2) AT=145.025n

.meas tran vdout1_3ck280 FIND v(dout1_3) AT=145.025n

.meas tran vdout1_4ck280 FIND v(dout1_4) AT=145.025n

.meas tran vdout1_5ck280 FIND v(dout1_5) AT=145.025n

.meas tran vdout1_6ck280 FIND v(dout1_6) AT=145.025n

.meas tran vdout1_7ck280 FIND v(dout1_7) AT=145.025n

.meas tran vdout1_8ck280 FIND v(dout1_8) AT=145.025n

.meas tran vdout1_9ck280 FIND v(dout1_9) AT=145.025n

.meas tran vdout1_10ck280 FIND v(dout1_10) AT=145.025n

.meas tran vdout1_11ck280 FIND v(dout1_11) AT=145.025n

.meas tran vdout1_12ck280 FIND v(dout1_12) AT=145.025n

.meas tran vdout1_13ck280 FIND v(dout1_13) AT=145.025n

.meas tran vdout1_14ck280 FIND v(dout1_14) AT=145.025n

.meas tran vdout1_15ck280 FIND v(dout1_15) AT=145.025n

.meas tran vdout1_16ck280 FIND v(dout1_16) AT=145.025n

.meas tran vdout1_17ck280 FIND v(dout1_17) AT=145.025n

.meas tran vdout1_18ck280 FIND v(dout1_18) AT=145.025n

.meas tran vdout1_19ck280 FIND v(dout1_19) AT=145.025n

.meas tran vdout1_20ck280 FIND v(dout1_20) AT=145.025n

.meas tran vdout1_21ck280 FIND v(dout1_21) AT=145.025n

.meas tran vdout1_22ck280 FIND v(dout1_22) AT=145.025n

.meas tran vdout1_23ck280 FIND v(dout1_23) AT=145.025n

.meas tran vdout1_24ck280 FIND v(dout1_24) AT=145.025n

.meas tran vdout1_25ck280 FIND v(dout1_25) AT=145.025n

.meas tran vdout1_26ck280 FIND v(dout1_26) AT=145.025n

.meas tran vdout1_27ck280 FIND v(dout1_27) AT=145.025n

.meas tran vdout1_28ck280 FIND v(dout1_28) AT=145.025n

.meas tran vdout1_29ck280 FIND v(dout1_29) AT=145.025n

.meas tran vdout1_30ck280 FIND v(dout1_30) AT=145.025n

.meas tran vdout1_31ck280 FIND v(dout1_31) AT=145.025n

.meas tran vdout1_32ck280 FIND v(dout1_32) AT=145.025n

.meas tran vdout1_33ck280 FIND v(dout1_33) AT=145.025n

.meas tran vdout1_34ck280 FIND v(dout1_34) AT=145.025n

.meas tran vdout1_35ck280 FIND v(dout1_35) AT=145.025n

.meas tran vdout1_36ck280 FIND v(dout1_36) AT=145.025n

.meas tran vdout1_37ck280 FIND v(dout1_37) AT=145.025n

.meas tran vdout1_38ck280 FIND v(dout1_38) AT=145.025n

.meas tran vdout1_39ck280 FIND v(dout1_39) AT=145.025n

.meas tran vdout1_40ck280 FIND v(dout1_40) AT=145.025n

.meas tran vdout1_41ck280 FIND v(dout1_41) AT=145.025n

.meas tran vdout1_42ck280 FIND v(dout1_42) AT=145.025n

.meas tran vdout1_43ck280 FIND v(dout1_43) AT=145.025n

.meas tran vdout1_44ck280 FIND v(dout1_44) AT=145.025n

.meas tran vdout1_45ck280 FIND v(dout1_45) AT=145.025n

.meas tran vdout1_46ck280 FIND v(dout1_46) AT=145.025n

.meas tran vdout1_47ck280 FIND v(dout1_47) AT=145.025n

.meas tran vdout1_48ck280 FIND v(dout1_48) AT=145.025n

.meas tran vdout1_49ck280 FIND v(dout1_49) AT=145.025n

.meas tran vdout1_50ck280 FIND v(dout1_50) AT=145.025n

.meas tran vdout1_51ck280 FIND v(dout1_51) AT=145.025n

.meas tran vdout1_52ck280 FIND v(dout1_52) AT=145.025n

.meas tran vdout1_53ck280 FIND v(dout1_53) AT=145.025n

.meas tran vdout1_54ck280 FIND v(dout1_54) AT=145.025n

.meas tran vdout1_55ck280 FIND v(dout1_55) AT=145.025n

.meas tran vdout1_56ck280 FIND v(dout1_56) AT=145.025n

.meas tran vdout1_57ck280 FIND v(dout1_57) AT=145.025n

.meas tran vdout1_58ck280 FIND v(dout1_58) AT=145.025n

.meas tran vdout1_59ck280 FIND v(dout1_59) AT=145.025n

.meas tran vdout1_60ck280 FIND v(dout1_60) AT=145.025n

.meas tran vdout1_61ck280 FIND v(dout1_61) AT=145.025n

.meas tran vdout1_62ck280 FIND v(dout1_62) AT=145.025n

.meas tran vdout1_63ck280 FIND v(dout1_63) AT=145.025n

.meas tran vdout1_64ck280 FIND v(dout1_64) AT=145.025n

.meas tran vdout1_65ck280 FIND v(dout1_65) AT=145.025n

.meas tran vdout1_66ck280 FIND v(dout1_66) AT=145.025n

.meas tran vdout1_67ck280 FIND v(dout1_67) AT=145.025n

.meas tran vdout1_68ck280 FIND v(dout1_68) AT=145.025n

.meas tran vdout1_69ck280 FIND v(dout1_69) AT=145.025n

.meas tran vdout1_70ck280 FIND v(dout1_70) AT=145.025n

.meas tran vdout1_71ck280 FIND v(dout1_71) AT=145.025n

.meas tran vdout1_72ck280 FIND v(dout1_72) AT=145.025n

.meas tran vdout1_73ck280 FIND v(dout1_73) AT=145.025n

.meas tran vdout1_74ck280 FIND v(dout1_74) AT=145.025n

.meas tran vdout1_75ck280 FIND v(dout1_75) AT=145.025n

.meas tran vdout1_76ck280 FIND v(dout1_76) AT=145.025n

.meas tran vdout1_77ck280 FIND v(dout1_77) AT=145.025n

.meas tran vdout1_78ck280 FIND v(dout1_78) AT=145.025n

.meas tran vdout1_79ck280 FIND v(dout1_79) AT=145.025n

.meas tran vdout1_80ck280 FIND v(dout1_80) AT=145.025n

.meas tran vdout1_81ck280 FIND v(dout1_81) AT=145.025n

.meas tran vdout1_82ck280 FIND v(dout1_82) AT=145.025n

.meas tran vdout1_83ck280 FIND v(dout1_83) AT=145.025n

.meas tran vdout1_84ck280 FIND v(dout1_84) AT=145.025n

.meas tran vdout1_85ck280 FIND v(dout1_85) AT=145.025n

.meas tran vdout1_86ck280 FIND v(dout1_86) AT=145.025n

.meas tran vdout1_87ck280 FIND v(dout1_87) AT=145.025n

.meas tran vdout1_88ck280 FIND v(dout1_88) AT=145.025n

.meas tran vdout1_89ck280 FIND v(dout1_89) AT=145.025n

.meas tran vdout1_90ck280 FIND v(dout1_90) AT=145.025n

.meas tran vdout1_91ck280 FIND v(dout1_91) AT=145.025n

.meas tran vdout1_92ck280 FIND v(dout1_92) AT=145.025n

.meas tran vdout1_93ck280 FIND v(dout1_93) AT=145.025n

.meas tran vdout1_94ck280 FIND v(dout1_94) AT=145.025n

.meas tran vdout1_95ck280 FIND v(dout1_95) AT=145.025n

.meas tran vdout1_96ck280 FIND v(dout1_96) AT=145.025n

.meas tran vdout1_97ck280 FIND v(dout1_97) AT=145.025n

.meas tran vdout1_98ck280 FIND v(dout1_98) AT=145.025n

.meas tran vdout1_99ck280 FIND v(dout1_99) AT=145.025n

.meas tran vdout1_100ck280 FIND v(dout1_100) AT=145.025n

.meas tran vdout1_101ck280 FIND v(dout1_101) AT=145.025n

.meas tran vdout1_102ck280 FIND v(dout1_102) AT=145.025n

.meas tran vdout1_103ck280 FIND v(dout1_103) AT=145.025n

.meas tran vdout1_104ck280 FIND v(dout1_104) AT=145.025n

.meas tran vdout1_105ck280 FIND v(dout1_105) AT=145.025n

.meas tran vdout1_106ck280 FIND v(dout1_106) AT=145.025n

.meas tran vdout1_107ck280 FIND v(dout1_107) AT=145.025n

.meas tran vdout1_108ck280 FIND v(dout1_108) AT=145.025n

.meas tran vdout1_109ck280 FIND v(dout1_109) AT=145.025n

.meas tran vdout1_110ck280 FIND v(dout1_110) AT=145.025n

.meas tran vdout1_111ck280 FIND v(dout1_111) AT=145.025n

.meas tran vdout1_112ck280 FIND v(dout1_112) AT=145.025n

.meas tran vdout1_113ck280 FIND v(dout1_113) AT=145.025n

.meas tran vdout1_114ck280 FIND v(dout1_114) AT=145.025n

.meas tran vdout1_115ck280 FIND v(dout1_115) AT=145.025n

.meas tran vdout1_116ck280 FIND v(dout1_116) AT=145.025n

.meas tran vdout1_117ck280 FIND v(dout1_117) AT=145.025n

.meas tran vdout1_118ck280 FIND v(dout1_118) AT=145.025n

.meas tran vdout1_119ck280 FIND v(dout1_119) AT=145.025n

.meas tran vdout1_120ck280 FIND v(dout1_120) AT=145.025n

.meas tran vdout1_121ck280 FIND v(dout1_121) AT=145.025n

.meas tran vdout1_122ck280 FIND v(dout1_122) AT=145.025n

.meas tran vdout1_123ck280 FIND v(dout1_123) AT=145.025n

.meas tran vdout1_124ck280 FIND v(dout1_124) AT=145.025n

.meas tran vdout1_125ck280 FIND v(dout1_125) AT=145.025n

.meas tran vdout1_126ck280 FIND v(dout1_126) AT=145.025n

.meas tran vdout1_127ck280 FIND v(dout1_127) AT=145.025n

.meas tran vdout1_128ck280 FIND v(dout1_128) AT=145.025n

.meas tran vdout1_129ck280 FIND v(dout1_129) AT=145.025n

.meas tran vdout1_130ck280 FIND v(dout1_130) AT=145.025n

.meas tran vdout1_131ck280 FIND v(dout1_131) AT=145.025n

.meas tran vdout1_132ck280 FIND v(dout1_132) AT=145.025n

.meas tran vdout1_133ck280 FIND v(dout1_133) AT=145.025n

.meas tran vdout1_134ck280 FIND v(dout1_134) AT=145.025n

.meas tran vdout1_135ck280 FIND v(dout1_135) AT=145.025n

.meas tran vdout1_136ck280 FIND v(dout1_136) AT=145.025n

.meas tran vdout1_137ck280 FIND v(dout1_137) AT=145.025n

.meas tran vdout1_138ck280 FIND v(dout1_138) AT=145.025n

.meas tran vdout1_139ck280 FIND v(dout1_139) AT=145.025n

.meas tran vdout1_140ck280 FIND v(dout1_140) AT=145.025n

.meas tran vdout1_141ck280 FIND v(dout1_141) AT=145.025n

.meas tran vdout1_142ck280 FIND v(dout1_142) AT=145.025n

.meas tran vdout1_143ck280 FIND v(dout1_143) AT=145.025n

.meas tran vdout1_144ck280 FIND v(dout1_144) AT=145.025n

.meas tran vdout1_145ck280 FIND v(dout1_145) AT=145.025n

.meas tran vdout1_146ck280 FIND v(dout1_146) AT=145.025n

.meas tran vdout1_147ck280 FIND v(dout1_147) AT=145.025n

.meas tran vdout1_148ck280 FIND v(dout1_148) AT=145.025n

.meas tran vdout1_149ck280 FIND v(dout1_149) AT=145.025n

.meas tran vdout1_150ck280 FIND v(dout1_150) AT=145.025n

.meas tran vdout1_151ck280 FIND v(dout1_151) AT=145.025n

.meas tran vdout1_152ck280 FIND v(dout1_152) AT=145.025n

.meas tran vdout1_153ck280 FIND v(dout1_153) AT=145.025n

.meas tran vdout1_154ck280 FIND v(dout1_154) AT=145.025n

.meas tran vdout1_155ck280 FIND v(dout1_155) AT=145.025n

.meas tran vdout1_156ck280 FIND v(dout1_156) AT=145.025n

.meas tran vdout1_157ck280 FIND v(dout1_157) AT=145.025n

.meas tran vdout1_158ck280 FIND v(dout1_158) AT=145.025n

.meas tran vdout1_159ck280 FIND v(dout1_159) AT=145.025n

.meas tran vdout1_160ck280 FIND v(dout1_160) AT=145.025n

.meas tran vdout1_161ck280 FIND v(dout1_161) AT=145.025n

.meas tran vdout1_162ck280 FIND v(dout1_162) AT=145.025n

.meas tran vdout1_163ck280 FIND v(dout1_163) AT=145.025n

.meas tran vdout1_164ck280 FIND v(dout1_164) AT=145.025n

.meas tran vdout1_165ck280 FIND v(dout1_165) AT=145.025n

.meas tran vdout1_166ck280 FIND v(dout1_166) AT=145.025n

.meas tran vdout1_167ck280 FIND v(dout1_167) AT=145.025n

.meas tran vdout1_168ck280 FIND v(dout1_168) AT=145.025n

.meas tran vdout1_169ck280 FIND v(dout1_169) AT=145.025n

.meas tran vdout1_170ck280 FIND v(dout1_170) AT=145.025n

.meas tran vdout1_171ck280 FIND v(dout1_171) AT=145.025n

.meas tran vdout1_172ck280 FIND v(dout1_172) AT=145.025n

.meas tran vdout1_173ck280 FIND v(dout1_173) AT=145.025n

.meas tran vdout1_174ck280 FIND v(dout1_174) AT=145.025n

.meas tran vdout1_175ck280 FIND v(dout1_175) AT=145.025n

.meas tran vdout1_176ck280 FIND v(dout1_176) AT=145.025n

.meas tran vdout1_177ck280 FIND v(dout1_177) AT=145.025n

.meas tran vdout1_178ck280 FIND v(dout1_178) AT=145.025n

.meas tran vdout1_179ck280 FIND v(dout1_179) AT=145.025n

.meas tran vdout1_180ck280 FIND v(dout1_180) AT=145.025n

.meas tran vdout1_181ck280 FIND v(dout1_181) AT=145.025n

.meas tran vdout1_182ck280 FIND v(dout1_182) AT=145.025n

.meas tran vdout1_183ck280 FIND v(dout1_183) AT=145.025n

.meas tran vdout1_184ck280 FIND v(dout1_184) AT=145.025n

.meas tran vdout1_185ck280 FIND v(dout1_185) AT=145.025n

.meas tran vdout1_186ck280 FIND v(dout1_186) AT=145.025n

.meas tran vdout1_187ck280 FIND v(dout1_187) AT=145.025n

.meas tran vdout1_188ck280 FIND v(dout1_188) AT=145.025n

.meas tran vdout1_189ck280 FIND v(dout1_189) AT=145.025n

.meas tran vdout1_190ck280 FIND v(dout1_190) AT=145.025n

.meas tran vdout1_191ck280 FIND v(dout1_191) AT=145.025n

.meas tran vdout1_192ck280 FIND v(dout1_192) AT=145.025n

.meas tran vdout1_193ck280 FIND v(dout1_193) AT=145.025n

.meas tran vdout1_194ck280 FIND v(dout1_194) AT=145.025n

.meas tran vdout1_195ck280 FIND v(dout1_195) AT=145.025n

.meas tran vdout1_196ck280 FIND v(dout1_196) AT=145.025n

.meas tran vdout1_197ck280 FIND v(dout1_197) AT=145.025n

.meas tran vdout1_198ck280 FIND v(dout1_198) AT=145.025n

.meas tran vdout1_199ck280 FIND v(dout1_199) AT=145.025n

.meas tran vdout1_200ck280 FIND v(dout1_200) AT=145.025n

.meas tran vdout1_201ck280 FIND v(dout1_201) AT=145.025n

.meas tran vdout1_202ck280 FIND v(dout1_202) AT=145.025n

.meas tran vdout1_203ck280 FIND v(dout1_203) AT=145.025n

.meas tran vdout1_204ck280 FIND v(dout1_204) AT=145.025n

.meas tran vdout1_205ck280 FIND v(dout1_205) AT=145.025n

.meas tran vdout1_206ck280 FIND v(dout1_206) AT=145.025n

.meas tran vdout1_207ck280 FIND v(dout1_207) AT=145.025n

.meas tran vdout1_208ck280 FIND v(dout1_208) AT=145.025n

.meas tran vdout1_209ck280 FIND v(dout1_209) AT=145.025n

.meas tran vdout1_210ck280 FIND v(dout1_210) AT=145.025n

.meas tran vdout1_211ck280 FIND v(dout1_211) AT=145.025n

.meas tran vdout1_212ck280 FIND v(dout1_212) AT=145.025n

.meas tran vdout1_213ck280 FIND v(dout1_213) AT=145.025n

.meas tran vdout1_214ck280 FIND v(dout1_214) AT=145.025n

.meas tran vdout1_215ck280 FIND v(dout1_215) AT=145.025n

.meas tran vdout1_216ck280 FIND v(dout1_216) AT=145.025n

.meas tran vdout1_217ck280 FIND v(dout1_217) AT=145.025n

.meas tran vdout1_218ck280 FIND v(dout1_218) AT=145.025n

.meas tran vdout1_219ck280 FIND v(dout1_219) AT=145.025n

.meas tran vdout1_220ck280 FIND v(dout1_220) AT=145.025n

.meas tran vdout1_221ck280 FIND v(dout1_221) AT=145.025n

.meas tran vdout1_222ck280 FIND v(dout1_222) AT=145.025n

.meas tran vdout1_223ck280 FIND v(dout1_223) AT=145.025n

.meas tran vdout1_224ck280 FIND v(dout1_224) AT=145.025n

.meas tran vdout1_225ck280 FIND v(dout1_225) AT=145.025n

.meas tran vdout1_226ck280 FIND v(dout1_226) AT=145.025n

.meas tran vdout1_227ck280 FIND v(dout1_227) AT=145.025n

.meas tran vdout1_228ck280 FIND v(dout1_228) AT=145.025n

.meas tran vdout1_229ck280 FIND v(dout1_229) AT=145.025n

.meas tran vdout1_230ck280 FIND v(dout1_230) AT=145.025n

.meas tran vdout1_231ck280 FIND v(dout1_231) AT=145.025n

.meas tran vdout1_232ck280 FIND v(dout1_232) AT=145.025n

.meas tran vdout1_233ck280 FIND v(dout1_233) AT=145.025n

.meas tran vdout1_234ck280 FIND v(dout1_234) AT=145.025n

.meas tran vdout1_235ck280 FIND v(dout1_235) AT=145.025n

.meas tran vdout1_236ck280 FIND v(dout1_236) AT=145.025n

.meas tran vdout1_237ck280 FIND v(dout1_237) AT=145.025n

.meas tran vdout1_238ck280 FIND v(dout1_238) AT=145.025n

.meas tran vdout1_239ck280 FIND v(dout1_239) AT=145.025n

.meas tran vdout1_240ck280 FIND v(dout1_240) AT=145.025n

.meas tran vdout1_241ck280 FIND v(dout1_241) AT=145.025n

.meas tran vdout1_242ck280 FIND v(dout1_242) AT=145.025n

.meas tran vdout1_243ck280 FIND v(dout1_243) AT=145.025n

.meas tran vdout1_244ck280 FIND v(dout1_244) AT=145.025n

.meas tran vdout1_245ck280 FIND v(dout1_245) AT=145.025n

.meas tran vdout1_246ck280 FIND v(dout1_246) AT=145.025n

.meas tran vdout1_247ck280 FIND v(dout1_247) AT=145.025n

.meas tran vdout1_248ck280 FIND v(dout1_248) AT=145.025n

.meas tran vdout1_249ck280 FIND v(dout1_249) AT=145.025n

.meas tran vdout1_250ck280 FIND v(dout1_250) AT=145.025n

.meas tran vdout1_251ck280 FIND v(dout1_251) AT=145.025n

.meas tran vdout1_252ck280 FIND v(dout1_252) AT=145.025n

.meas tran vdout1_253ck280 FIND v(dout1_253) AT=145.025n

.meas tran vdout1_254ck280 FIND v(dout1_254) AT=145.025n

.meas tran vdout1_255ck280 FIND v(dout1_255) AT=145.025n

.meas tran vdout1_256ck280 FIND v(dout1_256) AT=145.025n

.meas tran vdout1_257ck280 FIND v(dout1_257) AT=145.025n

.meas tran vdout1_258ck280 FIND v(dout1_258) AT=145.025n

.meas tran vdout1_259ck280 FIND v(dout1_259) AT=145.025n

.meas tran vdout1_260ck280 FIND v(dout1_260) AT=145.025n

.meas tran vdout1_261ck280 FIND v(dout1_261) AT=145.025n

.meas tran vdout1_262ck280 FIND v(dout1_262) AT=145.025n

.meas tran vdout1_263ck280 FIND v(dout1_263) AT=145.025n

.meas tran vdout1_264ck280 FIND v(dout1_264) AT=145.025n

.meas tran vdout1_265ck280 FIND v(dout1_265) AT=145.025n

.meas tran vdout1_266ck280 FIND v(dout1_266) AT=145.025n

.meas tran vdout1_267ck280 FIND v(dout1_267) AT=145.025n

.meas tran vdout1_268ck280 FIND v(dout1_268) AT=145.025n

.meas tran vdout1_269ck280 FIND v(dout1_269) AT=145.025n

.meas tran vdout1_270ck280 FIND v(dout1_270) AT=145.025n

.meas tran vdout1_271ck280 FIND v(dout1_271) AT=145.025n

.meas tran vdout1_272ck280 FIND v(dout1_272) AT=145.025n

.meas tran vdout1_273ck280 FIND v(dout1_273) AT=145.025n

.meas tran vdout1_274ck280 FIND v(dout1_274) AT=145.025n

.meas tran vdout1_275ck280 FIND v(dout1_275) AT=145.025n

.meas tran vdout1_276ck280 FIND v(dout1_276) AT=145.025n

.meas tran vdout1_277ck280 FIND v(dout1_277) AT=145.025n

.meas tran vdout1_278ck280 FIND v(dout1_278) AT=145.025n

.meas tran vdout1_279ck280 FIND v(dout1_279) AT=145.025n

.meas tran vdout1_280ck280 FIND v(dout1_280) AT=145.025n

.meas tran vdout1_281ck280 FIND v(dout1_281) AT=145.025n

.meas tran vdout1_282ck280 FIND v(dout1_282) AT=145.025n

.meas tran vdout1_283ck280 FIND v(dout1_283) AT=145.025n

.meas tran vdout1_284ck280 FIND v(dout1_284) AT=145.025n

.meas tran vdout1_285ck280 FIND v(dout1_285) AT=145.025n

.meas tran vdout1_286ck280 FIND v(dout1_286) AT=145.025n

.meas tran vdout1_287ck280 FIND v(dout1_287) AT=145.025n

.meas tran vdout1_288ck280 FIND v(dout1_288) AT=145.025n

.meas tran vdout1_289ck280 FIND v(dout1_289) AT=145.025n

.meas tran vdout1_290ck280 FIND v(dout1_290) AT=145.025n

.meas tran vdout1_291ck280 FIND v(dout1_291) AT=145.025n

.meas tran vdout1_292ck280 FIND v(dout1_292) AT=145.025n

.meas tran vdout1_293ck280 FIND v(dout1_293) AT=145.025n

.meas tran vdout1_294ck280 FIND v(dout1_294) AT=145.025n

.meas tran vdout1_295ck280 FIND v(dout1_295) AT=145.025n

.meas tran vdout1_296ck280 FIND v(dout1_296) AT=145.025n

.meas tran vdout1_297ck280 FIND v(dout1_297) AT=145.025n

.meas tran vdout1_298ck280 FIND v(dout1_298) AT=145.025n

.meas tran vdout1_299ck280 FIND v(dout1_299) AT=145.025n

.meas tran vdout1_300ck280 FIND v(dout1_300) AT=145.025n

.meas tran vdout1_301ck280 FIND v(dout1_301) AT=145.025n

.meas tran vdout1_302ck280 FIND v(dout1_302) AT=145.025n

.meas tran vdout1_303ck280 FIND v(dout1_303) AT=145.025n

.meas tran vdout1_304ck280 FIND v(dout1_304) AT=145.025n

.meas tran vdout1_305ck280 FIND v(dout1_305) AT=145.025n

.meas tran vdout1_306ck280 FIND v(dout1_306) AT=145.025n

.meas tran vdout1_307ck280 FIND v(dout1_307) AT=145.025n

.meas tran vdout1_308ck280 FIND v(dout1_308) AT=145.025n

.meas tran vdout1_309ck280 FIND v(dout1_309) AT=145.025n

.meas tran vdout1_310ck280 FIND v(dout1_310) AT=145.025n

.meas tran vdout1_311ck280 FIND v(dout1_311) AT=145.025n

.meas tran vdout1_312ck280 FIND v(dout1_312) AT=145.025n

.meas tran vdout1_313ck280 FIND v(dout1_313) AT=145.025n

.meas tran vdout1_314ck280 FIND v(dout1_314) AT=145.025n

.meas tran vdout1_315ck280 FIND v(dout1_315) AT=145.025n

.meas tran vdout1_316ck280 FIND v(dout1_316) AT=145.025n

.meas tran vdout1_317ck280 FIND v(dout1_317) AT=145.025n

.meas tran vdout1_318ck280 FIND v(dout1_318) AT=145.025n

.meas tran vdout1_319ck280 FIND v(dout1_319) AT=145.025n

.meas tran vdout1_320ck280 FIND v(dout1_320) AT=145.025n

.meas tran vdout1_321ck280 FIND v(dout1_321) AT=145.025n

.meas tran vdout1_322ck280 FIND v(dout1_322) AT=145.025n

.meas tran vdout1_323ck280 FIND v(dout1_323) AT=145.025n

.meas tran vdout1_324ck280 FIND v(dout1_324) AT=145.025n

.meas tran vdout1_325ck280 FIND v(dout1_325) AT=145.025n

.meas tran vdout1_326ck280 FIND v(dout1_326) AT=145.025n

.meas tran vdout1_327ck280 FIND v(dout1_327) AT=145.025n

.meas tran vdout1_328ck280 FIND v(dout1_328) AT=145.025n

.meas tran vdout1_329ck280 FIND v(dout1_329) AT=145.025n

.meas tran vdout1_330ck280 FIND v(dout1_330) AT=145.025n

.meas tran vdout1_331ck280 FIND v(dout1_331) AT=145.025n

.meas tran vdout1_332ck280 FIND v(dout1_332) AT=145.025n

.meas tran vdout1_333ck280 FIND v(dout1_333) AT=145.025n

.meas tran vdout1_334ck280 FIND v(dout1_334) AT=145.025n

.meas tran vdout1_335ck280 FIND v(dout1_335) AT=145.025n

.meas tran vdout1_336ck280 FIND v(dout1_336) AT=145.025n

.meas tran vdout1_337ck280 FIND v(dout1_337) AT=145.025n

.meas tran vdout1_338ck280 FIND v(dout1_338) AT=145.025n

.meas tran vdout1_339ck280 FIND v(dout1_339) AT=145.025n

.meas tran vdout1_340ck280 FIND v(dout1_340) AT=145.025n

.meas tran vdout1_341ck280 FIND v(dout1_341) AT=145.025n

.meas tran vdout1_342ck280 FIND v(dout1_342) AT=145.025n

.meas tran vdout1_343ck280 FIND v(dout1_343) AT=145.025n

.meas tran vdout1_344ck280 FIND v(dout1_344) AT=145.025n

.meas tran vdout1_345ck280 FIND v(dout1_345) AT=145.025n

.meas tran vdout1_346ck280 FIND v(dout1_346) AT=145.025n

.meas tran vdout1_347ck280 FIND v(dout1_347) AT=145.025n

.meas tran vdout1_348ck280 FIND v(dout1_348) AT=145.025n

.meas tran vdout1_349ck280 FIND v(dout1_349) AT=145.025n

.meas tran vdout1_350ck280 FIND v(dout1_350) AT=145.025n

.meas tran vdout1_351ck280 FIND v(dout1_351) AT=145.025n

.meas tran vdout1_352ck280 FIND v(dout1_352) AT=145.025n

.meas tran vdout1_353ck280 FIND v(dout1_353) AT=145.025n

.meas tran vdout1_354ck280 FIND v(dout1_354) AT=145.025n

.meas tran vdout1_355ck280 FIND v(dout1_355) AT=145.025n

.meas tran vdout1_356ck280 FIND v(dout1_356) AT=145.025n

.meas tran vdout1_357ck280 FIND v(dout1_357) AT=145.025n

.meas tran vdout1_358ck280 FIND v(dout1_358) AT=145.025n

.meas tran vdout1_359ck280 FIND v(dout1_359) AT=145.025n

.meas tran vdout1_360ck280 FIND v(dout1_360) AT=145.025n

.meas tran vdout1_361ck280 FIND v(dout1_361) AT=145.025n

.meas tran vdout1_362ck280 FIND v(dout1_362) AT=145.025n

.meas tran vdout1_363ck280 FIND v(dout1_363) AT=145.025n

.meas tran vdout1_364ck280 FIND v(dout1_364) AT=145.025n

.meas tran vdout1_365ck280 FIND v(dout1_365) AT=145.025n

.meas tran vdout1_366ck280 FIND v(dout1_366) AT=145.025n

.meas tran vdout1_367ck280 FIND v(dout1_367) AT=145.025n

.meas tran vdout1_368ck280 FIND v(dout1_368) AT=145.025n

.meas tran vdout1_369ck280 FIND v(dout1_369) AT=145.025n

.meas tran vdout1_370ck280 FIND v(dout1_370) AT=145.025n

.meas tran vdout1_371ck280 FIND v(dout1_371) AT=145.025n

.meas tran vdout1_372ck280 FIND v(dout1_372) AT=145.025n

.meas tran vdout1_373ck280 FIND v(dout1_373) AT=145.025n

.meas tran vdout1_374ck280 FIND v(dout1_374) AT=145.025n

.meas tran vdout1_375ck280 FIND v(dout1_375) AT=145.025n

.meas tran vdout1_376ck280 FIND v(dout1_376) AT=145.025n

.meas tran vdout1_377ck280 FIND v(dout1_377) AT=145.025n

.meas tran vdout1_378ck280 FIND v(dout1_378) AT=145.025n

.meas tran vdout1_379ck280 FIND v(dout1_379) AT=145.025n

.meas tran vdout1_380ck280 FIND v(dout1_380) AT=145.025n

.meas tran vdout1_381ck280 FIND v(dout1_381) AT=145.025n

.meas tran vdout1_382ck280 FIND v(dout1_382) AT=145.025n

.meas tran vdout1_383ck280 FIND v(dout1_383) AT=145.025n

.meas tran vdout1_384ck280 FIND v(dout1_384) AT=145.025n

.meas tran vdout1_385ck280 FIND v(dout1_385) AT=145.025n

.meas tran vdout1_386ck280 FIND v(dout1_386) AT=145.025n

.meas tran vdout1_387ck280 FIND v(dout1_387) AT=145.025n

.meas tran vdout1_388ck280 FIND v(dout1_388) AT=145.025n

.meas tran vdout1_389ck280 FIND v(dout1_389) AT=145.025n

.meas tran vdout1_390ck280 FIND v(dout1_390) AT=145.025n

.meas tran vdout1_391ck280 FIND v(dout1_391) AT=145.025n

.meas tran vdout1_392ck280 FIND v(dout1_392) AT=145.025n

.meas tran vdout1_393ck280 FIND v(dout1_393) AT=145.025n

.meas tran vdout1_394ck280 FIND v(dout1_394) AT=145.025n

.meas tran vdout1_395ck280 FIND v(dout1_395) AT=145.025n

.meas tran vdout1_396ck280 FIND v(dout1_396) AT=145.025n

.meas tran vdout1_397ck280 FIND v(dout1_397) AT=145.025n

.meas tran vdout1_398ck280 FIND v(dout1_398) AT=145.025n

.meas tran vdout1_399ck280 FIND v(dout1_399) AT=145.025n

.meas tran vdout1_400ck280 FIND v(dout1_400) AT=145.025n

.meas tran vdout1_401ck280 FIND v(dout1_401) AT=145.025n

.meas tran vdout1_402ck280 FIND v(dout1_402) AT=145.025n

.meas tran vdout1_403ck280 FIND v(dout1_403) AT=145.025n

.meas tran vdout1_404ck280 FIND v(dout1_404) AT=145.025n

.meas tran vdout1_405ck280 FIND v(dout1_405) AT=145.025n

.meas tran vdout1_406ck280 FIND v(dout1_406) AT=145.025n

.meas tran vdout1_407ck280 FIND v(dout1_407) AT=145.025n

.meas tran vdout1_408ck280 FIND v(dout1_408) AT=145.025n

.meas tran vdout1_409ck280 FIND v(dout1_409) AT=145.025n

.meas tran vdout1_410ck280 FIND v(dout1_410) AT=145.025n

.meas tran vdout1_411ck280 FIND v(dout1_411) AT=145.025n

.meas tran vdout1_412ck280 FIND v(dout1_412) AT=145.025n

.meas tran vdout1_413ck280 FIND v(dout1_413) AT=145.025n

.meas tran vdout1_414ck280 FIND v(dout1_414) AT=145.025n

.meas tran vdout1_415ck280 FIND v(dout1_415) AT=145.025n

.meas tran vdout1_416ck280 FIND v(dout1_416) AT=145.025n

.meas tran vdout1_417ck280 FIND v(dout1_417) AT=145.025n

.meas tran vdout1_418ck280 FIND v(dout1_418) AT=145.025n

.meas tran vdout1_419ck280 FIND v(dout1_419) AT=145.025n

.meas tran vdout1_420ck280 FIND v(dout1_420) AT=145.025n

.meas tran vdout1_421ck280 FIND v(dout1_421) AT=145.025n

.meas tran vdout1_422ck280 FIND v(dout1_422) AT=145.025n

.meas tran vdout1_423ck280 FIND v(dout1_423) AT=145.025n

.meas tran vdout1_424ck280 FIND v(dout1_424) AT=145.025n

.meas tran vdout1_425ck280 FIND v(dout1_425) AT=145.025n

.meas tran vdout1_426ck280 FIND v(dout1_426) AT=145.025n

.meas tran vdout1_427ck280 FIND v(dout1_427) AT=145.025n

.meas tran vdout1_428ck280 FIND v(dout1_428) AT=145.025n

.meas tran vdout1_429ck280 FIND v(dout1_429) AT=145.025n

.meas tran vdout1_430ck280 FIND v(dout1_430) AT=145.025n

.meas tran vdout1_431ck280 FIND v(dout1_431) AT=145.025n

.meas tran vdout1_432ck280 FIND v(dout1_432) AT=145.025n

.meas tran vdout1_433ck280 FIND v(dout1_433) AT=145.025n

.meas tran vdout1_434ck280 FIND v(dout1_434) AT=145.025n

.meas tran vdout1_435ck280 FIND v(dout1_435) AT=145.025n

.meas tran vdout1_436ck280 FIND v(dout1_436) AT=145.025n

.meas tran vdout1_437ck280 FIND v(dout1_437) AT=145.025n

.meas tran vdout1_438ck280 FIND v(dout1_438) AT=145.025n

.meas tran vdout1_439ck280 FIND v(dout1_439) AT=145.025n

.meas tran vdout1_440ck280 FIND v(dout1_440) AT=145.025n

.meas tran vdout1_441ck280 FIND v(dout1_441) AT=145.025n

.meas tran vdout1_442ck280 FIND v(dout1_442) AT=145.025n

.meas tran vdout1_443ck280 FIND v(dout1_443) AT=145.025n

.meas tran vdout1_444ck280 FIND v(dout1_444) AT=145.025n

.meas tran vdout1_445ck280 FIND v(dout1_445) AT=145.025n

.meas tran vdout1_446ck280 FIND v(dout1_446) AT=145.025n

.meas tran vdout1_447ck280 FIND v(dout1_447) AT=145.025n

.meas tran vdout1_448ck280 FIND v(dout1_448) AT=145.025n

.meas tran vdout1_449ck280 FIND v(dout1_449) AT=145.025n

.meas tran vdout1_450ck280 FIND v(dout1_450) AT=145.025n

.meas tran vdout1_451ck280 FIND v(dout1_451) AT=145.025n

.meas tran vdout1_452ck280 FIND v(dout1_452) AT=145.025n

.meas tran vdout1_453ck280 FIND v(dout1_453) AT=145.025n

.meas tran vdout1_454ck280 FIND v(dout1_454) AT=145.025n

.meas tran vdout1_455ck280 FIND v(dout1_455) AT=145.025n

.meas tran vdout1_456ck280 FIND v(dout1_456) AT=145.025n

.meas tran vdout1_457ck280 FIND v(dout1_457) AT=145.025n

.meas tran vdout1_458ck280 FIND v(dout1_458) AT=145.025n

.meas tran vdout1_459ck280 FIND v(dout1_459) AT=145.025n

.meas tran vdout1_460ck280 FIND v(dout1_460) AT=145.025n

.meas tran vdout1_461ck280 FIND v(dout1_461) AT=145.025n

.meas tran vdout1_462ck280 FIND v(dout1_462) AT=145.025n

.meas tran vdout1_463ck280 FIND v(dout1_463) AT=145.025n

.meas tran vdout1_464ck280 FIND v(dout1_464) AT=145.025n

.meas tran vdout1_465ck280 FIND v(dout1_465) AT=145.025n

.meas tran vdout1_466ck280 FIND v(dout1_466) AT=145.025n

.meas tran vdout1_467ck280 FIND v(dout1_467) AT=145.025n

.meas tran vdout1_468ck280 FIND v(dout1_468) AT=145.025n

.meas tran vdout1_469ck280 FIND v(dout1_469) AT=145.025n

.meas tran vdout1_470ck280 FIND v(dout1_470) AT=145.025n

.meas tran vdout1_471ck280 FIND v(dout1_471) AT=145.025n

.meas tran vdout1_472ck280 FIND v(dout1_472) AT=145.025n

.meas tran vdout1_473ck280 FIND v(dout1_473) AT=145.025n

.meas tran vdout1_474ck280 FIND v(dout1_474) AT=145.025n

.meas tran vdout1_475ck280 FIND v(dout1_475) AT=145.025n

.meas tran vdout1_476ck280 FIND v(dout1_476) AT=145.025n

.meas tran vdout1_477ck280 FIND v(dout1_477) AT=145.025n

.meas tran vdout1_478ck280 FIND v(dout1_478) AT=145.025n

.meas tran vdout1_479ck280 FIND v(dout1_479) AT=145.025n

.meas tran vdout1_480ck280 FIND v(dout1_480) AT=145.025n

.meas tran vdout1_481ck280 FIND v(dout1_481) AT=145.025n

.meas tran vdout1_482ck280 FIND v(dout1_482) AT=145.025n

.meas tran vdout1_483ck280 FIND v(dout1_483) AT=145.025n

.meas tran vdout1_484ck280 FIND v(dout1_484) AT=145.025n

.meas tran vdout1_485ck280 FIND v(dout1_485) AT=145.025n

.meas tran vdout1_486ck280 FIND v(dout1_486) AT=145.025n

.meas tran vdout1_487ck280 FIND v(dout1_487) AT=145.025n

.meas tran vdout1_488ck280 FIND v(dout1_488) AT=145.025n

.meas tran vdout1_489ck280 FIND v(dout1_489) AT=145.025n

.meas tran vdout1_490ck280 FIND v(dout1_490) AT=145.025n

.meas tran vdout1_491ck280 FIND v(dout1_491) AT=145.025n

.meas tran vdout1_492ck280 FIND v(dout1_492) AT=145.025n

.meas tran vdout1_493ck280 FIND v(dout1_493) AT=145.025n

.meas tran vdout1_494ck280 FIND v(dout1_494) AT=145.025n

.meas tran vdout1_495ck280 FIND v(dout1_495) AT=145.025n

.meas tran vdout1_496ck280 FIND v(dout1_496) AT=145.025n

.meas tran vdout1_497ck280 FIND v(dout1_497) AT=145.025n

.meas tran vdout1_498ck280 FIND v(dout1_498) AT=145.025n

.meas tran vdout1_499ck280 FIND v(dout1_499) AT=145.025n

.meas tran vdout1_500ck280 FIND v(dout1_500) AT=145.025n

.meas tran vdout1_501ck280 FIND v(dout1_501) AT=145.025n

.meas tran vdout1_502ck280 FIND v(dout1_502) AT=145.025n

.meas tran vdout1_503ck280 FIND v(dout1_503) AT=145.025n

.meas tran vdout1_504ck280 FIND v(dout1_504) AT=145.025n

.meas tran vdout1_505ck280 FIND v(dout1_505) AT=145.025n

.meas tran vdout1_506ck280 FIND v(dout1_506) AT=145.025n

.meas tran vdout1_507ck280 FIND v(dout1_507) AT=145.025n

.meas tran vdout1_508ck280 FIND v(dout1_508) AT=145.025n

.meas tran vdout1_509ck280 FIND v(dout1_509) AT=145.025n

.meas tran vdout1_510ck280 FIND v(dout1_510) AT=145.025n

.meas tran vdout1_511ck280 FIND v(dout1_511) AT=145.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_8ck300 FIND v(dout1_8) AT=155.025n

.meas tran vdout1_9ck300 FIND v(dout1_9) AT=155.025n

.meas tran vdout1_10ck300 FIND v(dout1_10) AT=155.025n

.meas tran vdout1_11ck300 FIND v(dout1_11) AT=155.025n

.meas tran vdout1_12ck300 FIND v(dout1_12) AT=155.025n

.meas tran vdout1_13ck300 FIND v(dout1_13) AT=155.025n

.meas tran vdout1_14ck300 FIND v(dout1_14) AT=155.025n

.meas tran vdout1_15ck300 FIND v(dout1_15) AT=155.025n

.meas tran vdout1_16ck300 FIND v(dout1_16) AT=155.025n

.meas tran vdout1_17ck300 FIND v(dout1_17) AT=155.025n

.meas tran vdout1_18ck300 FIND v(dout1_18) AT=155.025n

.meas tran vdout1_19ck300 FIND v(dout1_19) AT=155.025n

.meas tran vdout1_20ck300 FIND v(dout1_20) AT=155.025n

.meas tran vdout1_21ck300 FIND v(dout1_21) AT=155.025n

.meas tran vdout1_22ck300 FIND v(dout1_22) AT=155.025n

.meas tran vdout1_23ck300 FIND v(dout1_23) AT=155.025n

.meas tran vdout1_24ck300 FIND v(dout1_24) AT=155.025n

.meas tran vdout1_25ck300 FIND v(dout1_25) AT=155.025n

.meas tran vdout1_26ck300 FIND v(dout1_26) AT=155.025n

.meas tran vdout1_27ck300 FIND v(dout1_27) AT=155.025n

.meas tran vdout1_28ck300 FIND v(dout1_28) AT=155.025n

.meas tran vdout1_29ck300 FIND v(dout1_29) AT=155.025n

.meas tran vdout1_30ck300 FIND v(dout1_30) AT=155.025n

.meas tran vdout1_31ck300 FIND v(dout1_31) AT=155.025n

.meas tran vdout1_32ck300 FIND v(dout1_32) AT=155.025n

.meas tran vdout1_33ck300 FIND v(dout1_33) AT=155.025n

.meas tran vdout1_34ck300 FIND v(dout1_34) AT=155.025n

.meas tran vdout1_35ck300 FIND v(dout1_35) AT=155.025n

.meas tran vdout1_36ck300 FIND v(dout1_36) AT=155.025n

.meas tran vdout1_37ck300 FIND v(dout1_37) AT=155.025n

.meas tran vdout1_38ck300 FIND v(dout1_38) AT=155.025n

.meas tran vdout1_39ck300 FIND v(dout1_39) AT=155.025n

.meas tran vdout1_40ck300 FIND v(dout1_40) AT=155.025n

.meas tran vdout1_41ck300 FIND v(dout1_41) AT=155.025n

.meas tran vdout1_42ck300 FIND v(dout1_42) AT=155.025n

.meas tran vdout1_43ck300 FIND v(dout1_43) AT=155.025n

.meas tran vdout1_44ck300 FIND v(dout1_44) AT=155.025n

.meas tran vdout1_45ck300 FIND v(dout1_45) AT=155.025n

.meas tran vdout1_46ck300 FIND v(dout1_46) AT=155.025n

.meas tran vdout1_47ck300 FIND v(dout1_47) AT=155.025n

.meas tran vdout1_48ck300 FIND v(dout1_48) AT=155.025n

.meas tran vdout1_49ck300 FIND v(dout1_49) AT=155.025n

.meas tran vdout1_50ck300 FIND v(dout1_50) AT=155.025n

.meas tran vdout1_51ck300 FIND v(dout1_51) AT=155.025n

.meas tran vdout1_52ck300 FIND v(dout1_52) AT=155.025n

.meas tran vdout1_53ck300 FIND v(dout1_53) AT=155.025n

.meas tran vdout1_54ck300 FIND v(dout1_54) AT=155.025n

.meas tran vdout1_55ck300 FIND v(dout1_55) AT=155.025n

.meas tran vdout1_56ck300 FIND v(dout1_56) AT=155.025n

.meas tran vdout1_57ck300 FIND v(dout1_57) AT=155.025n

.meas tran vdout1_58ck300 FIND v(dout1_58) AT=155.025n

.meas tran vdout1_59ck300 FIND v(dout1_59) AT=155.025n

.meas tran vdout1_60ck300 FIND v(dout1_60) AT=155.025n

.meas tran vdout1_61ck300 FIND v(dout1_61) AT=155.025n

.meas tran vdout1_62ck300 FIND v(dout1_62) AT=155.025n

.meas tran vdout1_63ck300 FIND v(dout1_63) AT=155.025n

.meas tran vdout1_64ck300 FIND v(dout1_64) AT=155.025n

.meas tran vdout1_65ck300 FIND v(dout1_65) AT=155.025n

.meas tran vdout1_66ck300 FIND v(dout1_66) AT=155.025n

.meas tran vdout1_67ck300 FIND v(dout1_67) AT=155.025n

.meas tran vdout1_68ck300 FIND v(dout1_68) AT=155.025n

.meas tran vdout1_69ck300 FIND v(dout1_69) AT=155.025n

.meas tran vdout1_70ck300 FIND v(dout1_70) AT=155.025n

.meas tran vdout1_71ck300 FIND v(dout1_71) AT=155.025n

.meas tran vdout1_72ck300 FIND v(dout1_72) AT=155.025n

.meas tran vdout1_73ck300 FIND v(dout1_73) AT=155.025n

.meas tran vdout1_74ck300 FIND v(dout1_74) AT=155.025n

.meas tran vdout1_75ck300 FIND v(dout1_75) AT=155.025n

.meas tran vdout1_76ck300 FIND v(dout1_76) AT=155.025n

.meas tran vdout1_77ck300 FIND v(dout1_77) AT=155.025n

.meas tran vdout1_78ck300 FIND v(dout1_78) AT=155.025n

.meas tran vdout1_79ck300 FIND v(dout1_79) AT=155.025n

.meas tran vdout1_80ck300 FIND v(dout1_80) AT=155.025n

.meas tran vdout1_81ck300 FIND v(dout1_81) AT=155.025n

.meas tran vdout1_82ck300 FIND v(dout1_82) AT=155.025n

.meas tran vdout1_83ck300 FIND v(dout1_83) AT=155.025n

.meas tran vdout1_84ck300 FIND v(dout1_84) AT=155.025n

.meas tran vdout1_85ck300 FIND v(dout1_85) AT=155.025n

.meas tran vdout1_86ck300 FIND v(dout1_86) AT=155.025n

.meas tran vdout1_87ck300 FIND v(dout1_87) AT=155.025n

.meas tran vdout1_88ck300 FIND v(dout1_88) AT=155.025n

.meas tran vdout1_89ck300 FIND v(dout1_89) AT=155.025n

.meas tran vdout1_90ck300 FIND v(dout1_90) AT=155.025n

.meas tran vdout1_91ck300 FIND v(dout1_91) AT=155.025n

.meas tran vdout1_92ck300 FIND v(dout1_92) AT=155.025n

.meas tran vdout1_93ck300 FIND v(dout1_93) AT=155.025n

.meas tran vdout1_94ck300 FIND v(dout1_94) AT=155.025n

.meas tran vdout1_95ck300 FIND v(dout1_95) AT=155.025n

.meas tran vdout1_96ck300 FIND v(dout1_96) AT=155.025n

.meas tran vdout1_97ck300 FIND v(dout1_97) AT=155.025n

.meas tran vdout1_98ck300 FIND v(dout1_98) AT=155.025n

.meas tran vdout1_99ck300 FIND v(dout1_99) AT=155.025n

.meas tran vdout1_100ck300 FIND v(dout1_100) AT=155.025n

.meas tran vdout1_101ck300 FIND v(dout1_101) AT=155.025n

.meas tran vdout1_102ck300 FIND v(dout1_102) AT=155.025n

.meas tran vdout1_103ck300 FIND v(dout1_103) AT=155.025n

.meas tran vdout1_104ck300 FIND v(dout1_104) AT=155.025n

.meas tran vdout1_105ck300 FIND v(dout1_105) AT=155.025n

.meas tran vdout1_106ck300 FIND v(dout1_106) AT=155.025n

.meas tran vdout1_107ck300 FIND v(dout1_107) AT=155.025n

.meas tran vdout1_108ck300 FIND v(dout1_108) AT=155.025n

.meas tran vdout1_109ck300 FIND v(dout1_109) AT=155.025n

.meas tran vdout1_110ck300 FIND v(dout1_110) AT=155.025n

.meas tran vdout1_111ck300 FIND v(dout1_111) AT=155.025n

.meas tran vdout1_112ck300 FIND v(dout1_112) AT=155.025n

.meas tran vdout1_113ck300 FIND v(dout1_113) AT=155.025n

.meas tran vdout1_114ck300 FIND v(dout1_114) AT=155.025n

.meas tran vdout1_115ck300 FIND v(dout1_115) AT=155.025n

.meas tran vdout1_116ck300 FIND v(dout1_116) AT=155.025n

.meas tran vdout1_117ck300 FIND v(dout1_117) AT=155.025n

.meas tran vdout1_118ck300 FIND v(dout1_118) AT=155.025n

.meas tran vdout1_119ck300 FIND v(dout1_119) AT=155.025n

.meas tran vdout1_120ck300 FIND v(dout1_120) AT=155.025n

.meas tran vdout1_121ck300 FIND v(dout1_121) AT=155.025n

.meas tran vdout1_122ck300 FIND v(dout1_122) AT=155.025n

.meas tran vdout1_123ck300 FIND v(dout1_123) AT=155.025n

.meas tran vdout1_124ck300 FIND v(dout1_124) AT=155.025n

.meas tran vdout1_125ck300 FIND v(dout1_125) AT=155.025n

.meas tran vdout1_126ck300 FIND v(dout1_126) AT=155.025n

.meas tran vdout1_127ck300 FIND v(dout1_127) AT=155.025n

.meas tran vdout1_128ck300 FIND v(dout1_128) AT=155.025n

.meas tran vdout1_129ck300 FIND v(dout1_129) AT=155.025n

.meas tran vdout1_130ck300 FIND v(dout1_130) AT=155.025n

.meas tran vdout1_131ck300 FIND v(dout1_131) AT=155.025n

.meas tran vdout1_132ck300 FIND v(dout1_132) AT=155.025n

.meas tran vdout1_133ck300 FIND v(dout1_133) AT=155.025n

.meas tran vdout1_134ck300 FIND v(dout1_134) AT=155.025n

.meas tran vdout1_135ck300 FIND v(dout1_135) AT=155.025n

.meas tran vdout1_136ck300 FIND v(dout1_136) AT=155.025n

.meas tran vdout1_137ck300 FIND v(dout1_137) AT=155.025n

.meas tran vdout1_138ck300 FIND v(dout1_138) AT=155.025n

.meas tran vdout1_139ck300 FIND v(dout1_139) AT=155.025n

.meas tran vdout1_140ck300 FIND v(dout1_140) AT=155.025n

.meas tran vdout1_141ck300 FIND v(dout1_141) AT=155.025n

.meas tran vdout1_142ck300 FIND v(dout1_142) AT=155.025n

.meas tran vdout1_143ck300 FIND v(dout1_143) AT=155.025n

.meas tran vdout1_144ck300 FIND v(dout1_144) AT=155.025n

.meas tran vdout1_145ck300 FIND v(dout1_145) AT=155.025n

.meas tran vdout1_146ck300 FIND v(dout1_146) AT=155.025n

.meas tran vdout1_147ck300 FIND v(dout1_147) AT=155.025n

.meas tran vdout1_148ck300 FIND v(dout1_148) AT=155.025n

.meas tran vdout1_149ck300 FIND v(dout1_149) AT=155.025n

.meas tran vdout1_150ck300 FIND v(dout1_150) AT=155.025n

.meas tran vdout1_151ck300 FIND v(dout1_151) AT=155.025n

.meas tran vdout1_152ck300 FIND v(dout1_152) AT=155.025n

.meas tran vdout1_153ck300 FIND v(dout1_153) AT=155.025n

.meas tran vdout1_154ck300 FIND v(dout1_154) AT=155.025n

.meas tran vdout1_155ck300 FIND v(dout1_155) AT=155.025n

.meas tran vdout1_156ck300 FIND v(dout1_156) AT=155.025n

.meas tran vdout1_157ck300 FIND v(dout1_157) AT=155.025n

.meas tran vdout1_158ck300 FIND v(dout1_158) AT=155.025n

.meas tran vdout1_159ck300 FIND v(dout1_159) AT=155.025n

.meas tran vdout1_160ck300 FIND v(dout1_160) AT=155.025n

.meas tran vdout1_161ck300 FIND v(dout1_161) AT=155.025n

.meas tran vdout1_162ck300 FIND v(dout1_162) AT=155.025n

.meas tran vdout1_163ck300 FIND v(dout1_163) AT=155.025n

.meas tran vdout1_164ck300 FIND v(dout1_164) AT=155.025n

.meas tran vdout1_165ck300 FIND v(dout1_165) AT=155.025n

.meas tran vdout1_166ck300 FIND v(dout1_166) AT=155.025n

.meas tran vdout1_167ck300 FIND v(dout1_167) AT=155.025n

.meas tran vdout1_168ck300 FIND v(dout1_168) AT=155.025n

.meas tran vdout1_169ck300 FIND v(dout1_169) AT=155.025n

.meas tran vdout1_170ck300 FIND v(dout1_170) AT=155.025n

.meas tran vdout1_171ck300 FIND v(dout1_171) AT=155.025n

.meas tran vdout1_172ck300 FIND v(dout1_172) AT=155.025n

.meas tran vdout1_173ck300 FIND v(dout1_173) AT=155.025n

.meas tran vdout1_174ck300 FIND v(dout1_174) AT=155.025n

.meas tran vdout1_175ck300 FIND v(dout1_175) AT=155.025n

.meas tran vdout1_176ck300 FIND v(dout1_176) AT=155.025n

.meas tran vdout1_177ck300 FIND v(dout1_177) AT=155.025n

.meas tran vdout1_178ck300 FIND v(dout1_178) AT=155.025n

.meas tran vdout1_179ck300 FIND v(dout1_179) AT=155.025n

.meas tran vdout1_180ck300 FIND v(dout1_180) AT=155.025n

.meas tran vdout1_181ck300 FIND v(dout1_181) AT=155.025n

.meas tran vdout1_182ck300 FIND v(dout1_182) AT=155.025n

.meas tran vdout1_183ck300 FIND v(dout1_183) AT=155.025n

.meas tran vdout1_184ck300 FIND v(dout1_184) AT=155.025n

.meas tran vdout1_185ck300 FIND v(dout1_185) AT=155.025n

.meas tran vdout1_186ck300 FIND v(dout1_186) AT=155.025n

.meas tran vdout1_187ck300 FIND v(dout1_187) AT=155.025n

.meas tran vdout1_188ck300 FIND v(dout1_188) AT=155.025n

.meas tran vdout1_189ck300 FIND v(dout1_189) AT=155.025n

.meas tran vdout1_190ck300 FIND v(dout1_190) AT=155.025n

.meas tran vdout1_191ck300 FIND v(dout1_191) AT=155.025n

.meas tran vdout1_192ck300 FIND v(dout1_192) AT=155.025n

.meas tran vdout1_193ck300 FIND v(dout1_193) AT=155.025n

.meas tran vdout1_194ck300 FIND v(dout1_194) AT=155.025n

.meas tran vdout1_195ck300 FIND v(dout1_195) AT=155.025n

.meas tran vdout1_196ck300 FIND v(dout1_196) AT=155.025n

.meas tran vdout1_197ck300 FIND v(dout1_197) AT=155.025n

.meas tran vdout1_198ck300 FIND v(dout1_198) AT=155.025n

.meas tran vdout1_199ck300 FIND v(dout1_199) AT=155.025n

.meas tran vdout1_200ck300 FIND v(dout1_200) AT=155.025n

.meas tran vdout1_201ck300 FIND v(dout1_201) AT=155.025n

.meas tran vdout1_202ck300 FIND v(dout1_202) AT=155.025n

.meas tran vdout1_203ck300 FIND v(dout1_203) AT=155.025n

.meas tran vdout1_204ck300 FIND v(dout1_204) AT=155.025n

.meas tran vdout1_205ck300 FIND v(dout1_205) AT=155.025n

.meas tran vdout1_206ck300 FIND v(dout1_206) AT=155.025n

.meas tran vdout1_207ck300 FIND v(dout1_207) AT=155.025n

.meas tran vdout1_208ck300 FIND v(dout1_208) AT=155.025n

.meas tran vdout1_209ck300 FIND v(dout1_209) AT=155.025n

.meas tran vdout1_210ck300 FIND v(dout1_210) AT=155.025n

.meas tran vdout1_211ck300 FIND v(dout1_211) AT=155.025n

.meas tran vdout1_212ck300 FIND v(dout1_212) AT=155.025n

.meas tran vdout1_213ck300 FIND v(dout1_213) AT=155.025n

.meas tran vdout1_214ck300 FIND v(dout1_214) AT=155.025n

.meas tran vdout1_215ck300 FIND v(dout1_215) AT=155.025n

.meas tran vdout1_216ck300 FIND v(dout1_216) AT=155.025n

.meas tran vdout1_217ck300 FIND v(dout1_217) AT=155.025n

.meas tran vdout1_218ck300 FIND v(dout1_218) AT=155.025n

.meas tran vdout1_219ck300 FIND v(dout1_219) AT=155.025n

.meas tran vdout1_220ck300 FIND v(dout1_220) AT=155.025n

.meas tran vdout1_221ck300 FIND v(dout1_221) AT=155.025n

.meas tran vdout1_222ck300 FIND v(dout1_222) AT=155.025n

.meas tran vdout1_223ck300 FIND v(dout1_223) AT=155.025n

.meas tran vdout1_224ck300 FIND v(dout1_224) AT=155.025n

.meas tran vdout1_225ck300 FIND v(dout1_225) AT=155.025n

.meas tran vdout1_226ck300 FIND v(dout1_226) AT=155.025n

.meas tran vdout1_227ck300 FIND v(dout1_227) AT=155.025n

.meas tran vdout1_228ck300 FIND v(dout1_228) AT=155.025n

.meas tran vdout1_229ck300 FIND v(dout1_229) AT=155.025n

.meas tran vdout1_230ck300 FIND v(dout1_230) AT=155.025n

.meas tran vdout1_231ck300 FIND v(dout1_231) AT=155.025n

.meas tran vdout1_232ck300 FIND v(dout1_232) AT=155.025n

.meas tran vdout1_233ck300 FIND v(dout1_233) AT=155.025n

.meas tran vdout1_234ck300 FIND v(dout1_234) AT=155.025n

.meas tran vdout1_235ck300 FIND v(dout1_235) AT=155.025n

.meas tran vdout1_236ck300 FIND v(dout1_236) AT=155.025n

.meas tran vdout1_237ck300 FIND v(dout1_237) AT=155.025n

.meas tran vdout1_238ck300 FIND v(dout1_238) AT=155.025n

.meas tran vdout1_239ck300 FIND v(dout1_239) AT=155.025n

.meas tran vdout1_240ck300 FIND v(dout1_240) AT=155.025n

.meas tran vdout1_241ck300 FIND v(dout1_241) AT=155.025n

.meas tran vdout1_242ck300 FIND v(dout1_242) AT=155.025n

.meas tran vdout1_243ck300 FIND v(dout1_243) AT=155.025n

.meas tran vdout1_244ck300 FIND v(dout1_244) AT=155.025n

.meas tran vdout1_245ck300 FIND v(dout1_245) AT=155.025n

.meas tran vdout1_246ck300 FIND v(dout1_246) AT=155.025n

.meas tran vdout1_247ck300 FIND v(dout1_247) AT=155.025n

.meas tran vdout1_248ck300 FIND v(dout1_248) AT=155.025n

.meas tran vdout1_249ck300 FIND v(dout1_249) AT=155.025n

.meas tran vdout1_250ck300 FIND v(dout1_250) AT=155.025n

.meas tran vdout1_251ck300 FIND v(dout1_251) AT=155.025n

.meas tran vdout1_252ck300 FIND v(dout1_252) AT=155.025n

.meas tran vdout1_253ck300 FIND v(dout1_253) AT=155.025n

.meas tran vdout1_254ck300 FIND v(dout1_254) AT=155.025n

.meas tran vdout1_255ck300 FIND v(dout1_255) AT=155.025n

.meas tran vdout1_256ck300 FIND v(dout1_256) AT=155.025n

.meas tran vdout1_257ck300 FIND v(dout1_257) AT=155.025n

.meas tran vdout1_258ck300 FIND v(dout1_258) AT=155.025n

.meas tran vdout1_259ck300 FIND v(dout1_259) AT=155.025n

.meas tran vdout1_260ck300 FIND v(dout1_260) AT=155.025n

.meas tran vdout1_261ck300 FIND v(dout1_261) AT=155.025n

.meas tran vdout1_262ck300 FIND v(dout1_262) AT=155.025n

.meas tran vdout1_263ck300 FIND v(dout1_263) AT=155.025n

.meas tran vdout1_264ck300 FIND v(dout1_264) AT=155.025n

.meas tran vdout1_265ck300 FIND v(dout1_265) AT=155.025n

.meas tran vdout1_266ck300 FIND v(dout1_266) AT=155.025n

.meas tran vdout1_267ck300 FIND v(dout1_267) AT=155.025n

.meas tran vdout1_268ck300 FIND v(dout1_268) AT=155.025n

.meas tran vdout1_269ck300 FIND v(dout1_269) AT=155.025n

.meas tran vdout1_270ck300 FIND v(dout1_270) AT=155.025n

.meas tran vdout1_271ck300 FIND v(dout1_271) AT=155.025n

.meas tran vdout1_272ck300 FIND v(dout1_272) AT=155.025n

.meas tran vdout1_273ck300 FIND v(dout1_273) AT=155.025n

.meas tran vdout1_274ck300 FIND v(dout1_274) AT=155.025n

.meas tran vdout1_275ck300 FIND v(dout1_275) AT=155.025n

.meas tran vdout1_276ck300 FIND v(dout1_276) AT=155.025n

.meas tran vdout1_277ck300 FIND v(dout1_277) AT=155.025n

.meas tran vdout1_278ck300 FIND v(dout1_278) AT=155.025n

.meas tran vdout1_279ck300 FIND v(dout1_279) AT=155.025n

.meas tran vdout1_280ck300 FIND v(dout1_280) AT=155.025n

.meas tran vdout1_281ck300 FIND v(dout1_281) AT=155.025n

.meas tran vdout1_282ck300 FIND v(dout1_282) AT=155.025n

.meas tran vdout1_283ck300 FIND v(dout1_283) AT=155.025n

.meas tran vdout1_284ck300 FIND v(dout1_284) AT=155.025n

.meas tran vdout1_285ck300 FIND v(dout1_285) AT=155.025n

.meas tran vdout1_286ck300 FIND v(dout1_286) AT=155.025n

.meas tran vdout1_287ck300 FIND v(dout1_287) AT=155.025n

.meas tran vdout1_288ck300 FIND v(dout1_288) AT=155.025n

.meas tran vdout1_289ck300 FIND v(dout1_289) AT=155.025n

.meas tran vdout1_290ck300 FIND v(dout1_290) AT=155.025n

.meas tran vdout1_291ck300 FIND v(dout1_291) AT=155.025n

.meas tran vdout1_292ck300 FIND v(dout1_292) AT=155.025n

.meas tran vdout1_293ck300 FIND v(dout1_293) AT=155.025n

.meas tran vdout1_294ck300 FIND v(dout1_294) AT=155.025n

.meas tran vdout1_295ck300 FIND v(dout1_295) AT=155.025n

.meas tran vdout1_296ck300 FIND v(dout1_296) AT=155.025n

.meas tran vdout1_297ck300 FIND v(dout1_297) AT=155.025n

.meas tran vdout1_298ck300 FIND v(dout1_298) AT=155.025n

.meas tran vdout1_299ck300 FIND v(dout1_299) AT=155.025n

.meas tran vdout1_300ck300 FIND v(dout1_300) AT=155.025n

.meas tran vdout1_301ck300 FIND v(dout1_301) AT=155.025n

.meas tran vdout1_302ck300 FIND v(dout1_302) AT=155.025n

.meas tran vdout1_303ck300 FIND v(dout1_303) AT=155.025n

.meas tran vdout1_304ck300 FIND v(dout1_304) AT=155.025n

.meas tran vdout1_305ck300 FIND v(dout1_305) AT=155.025n

.meas tran vdout1_306ck300 FIND v(dout1_306) AT=155.025n

.meas tran vdout1_307ck300 FIND v(dout1_307) AT=155.025n

.meas tran vdout1_308ck300 FIND v(dout1_308) AT=155.025n

.meas tran vdout1_309ck300 FIND v(dout1_309) AT=155.025n

.meas tran vdout1_310ck300 FIND v(dout1_310) AT=155.025n

.meas tran vdout1_311ck300 FIND v(dout1_311) AT=155.025n

.meas tran vdout1_312ck300 FIND v(dout1_312) AT=155.025n

.meas tran vdout1_313ck300 FIND v(dout1_313) AT=155.025n

.meas tran vdout1_314ck300 FIND v(dout1_314) AT=155.025n

.meas tran vdout1_315ck300 FIND v(dout1_315) AT=155.025n

.meas tran vdout1_316ck300 FIND v(dout1_316) AT=155.025n

.meas tran vdout1_317ck300 FIND v(dout1_317) AT=155.025n

.meas tran vdout1_318ck300 FIND v(dout1_318) AT=155.025n

.meas tran vdout1_319ck300 FIND v(dout1_319) AT=155.025n

.meas tran vdout1_320ck300 FIND v(dout1_320) AT=155.025n

.meas tran vdout1_321ck300 FIND v(dout1_321) AT=155.025n

.meas tran vdout1_322ck300 FIND v(dout1_322) AT=155.025n

.meas tran vdout1_323ck300 FIND v(dout1_323) AT=155.025n

.meas tran vdout1_324ck300 FIND v(dout1_324) AT=155.025n

.meas tran vdout1_325ck300 FIND v(dout1_325) AT=155.025n

.meas tran vdout1_326ck300 FIND v(dout1_326) AT=155.025n

.meas tran vdout1_327ck300 FIND v(dout1_327) AT=155.025n

.meas tran vdout1_328ck300 FIND v(dout1_328) AT=155.025n

.meas tran vdout1_329ck300 FIND v(dout1_329) AT=155.025n

.meas tran vdout1_330ck300 FIND v(dout1_330) AT=155.025n

.meas tran vdout1_331ck300 FIND v(dout1_331) AT=155.025n

.meas tran vdout1_332ck300 FIND v(dout1_332) AT=155.025n

.meas tran vdout1_333ck300 FIND v(dout1_333) AT=155.025n

.meas tran vdout1_334ck300 FIND v(dout1_334) AT=155.025n

.meas tran vdout1_335ck300 FIND v(dout1_335) AT=155.025n

.meas tran vdout1_336ck300 FIND v(dout1_336) AT=155.025n

.meas tran vdout1_337ck300 FIND v(dout1_337) AT=155.025n

.meas tran vdout1_338ck300 FIND v(dout1_338) AT=155.025n

.meas tran vdout1_339ck300 FIND v(dout1_339) AT=155.025n

.meas tran vdout1_340ck300 FIND v(dout1_340) AT=155.025n

.meas tran vdout1_341ck300 FIND v(dout1_341) AT=155.025n

.meas tran vdout1_342ck300 FIND v(dout1_342) AT=155.025n

.meas tran vdout1_343ck300 FIND v(dout1_343) AT=155.025n

.meas tran vdout1_344ck300 FIND v(dout1_344) AT=155.025n

.meas tran vdout1_345ck300 FIND v(dout1_345) AT=155.025n

.meas tran vdout1_346ck300 FIND v(dout1_346) AT=155.025n

.meas tran vdout1_347ck300 FIND v(dout1_347) AT=155.025n

.meas tran vdout1_348ck300 FIND v(dout1_348) AT=155.025n

.meas tran vdout1_349ck300 FIND v(dout1_349) AT=155.025n

.meas tran vdout1_350ck300 FIND v(dout1_350) AT=155.025n

.meas tran vdout1_351ck300 FIND v(dout1_351) AT=155.025n

.meas tran vdout1_352ck300 FIND v(dout1_352) AT=155.025n

.meas tran vdout1_353ck300 FIND v(dout1_353) AT=155.025n

.meas tran vdout1_354ck300 FIND v(dout1_354) AT=155.025n

.meas tran vdout1_355ck300 FIND v(dout1_355) AT=155.025n

.meas tran vdout1_356ck300 FIND v(dout1_356) AT=155.025n

.meas tran vdout1_357ck300 FIND v(dout1_357) AT=155.025n

.meas tran vdout1_358ck300 FIND v(dout1_358) AT=155.025n

.meas tran vdout1_359ck300 FIND v(dout1_359) AT=155.025n

.meas tran vdout1_360ck300 FIND v(dout1_360) AT=155.025n

.meas tran vdout1_361ck300 FIND v(dout1_361) AT=155.025n

.meas tran vdout1_362ck300 FIND v(dout1_362) AT=155.025n

.meas tran vdout1_363ck300 FIND v(dout1_363) AT=155.025n

.meas tran vdout1_364ck300 FIND v(dout1_364) AT=155.025n

.meas tran vdout1_365ck300 FIND v(dout1_365) AT=155.025n

.meas tran vdout1_366ck300 FIND v(dout1_366) AT=155.025n

.meas tran vdout1_367ck300 FIND v(dout1_367) AT=155.025n

.meas tran vdout1_368ck300 FIND v(dout1_368) AT=155.025n

.meas tran vdout1_369ck300 FIND v(dout1_369) AT=155.025n

.meas tran vdout1_370ck300 FIND v(dout1_370) AT=155.025n

.meas tran vdout1_371ck300 FIND v(dout1_371) AT=155.025n

.meas tran vdout1_372ck300 FIND v(dout1_372) AT=155.025n

.meas tran vdout1_373ck300 FIND v(dout1_373) AT=155.025n

.meas tran vdout1_374ck300 FIND v(dout1_374) AT=155.025n

.meas tran vdout1_375ck300 FIND v(dout1_375) AT=155.025n

.meas tran vdout1_376ck300 FIND v(dout1_376) AT=155.025n

.meas tran vdout1_377ck300 FIND v(dout1_377) AT=155.025n

.meas tran vdout1_378ck300 FIND v(dout1_378) AT=155.025n

.meas tran vdout1_379ck300 FIND v(dout1_379) AT=155.025n

.meas tran vdout1_380ck300 FIND v(dout1_380) AT=155.025n

.meas tran vdout1_381ck300 FIND v(dout1_381) AT=155.025n

.meas tran vdout1_382ck300 FIND v(dout1_382) AT=155.025n

.meas tran vdout1_383ck300 FIND v(dout1_383) AT=155.025n

.meas tran vdout1_384ck300 FIND v(dout1_384) AT=155.025n

.meas tran vdout1_385ck300 FIND v(dout1_385) AT=155.025n

.meas tran vdout1_386ck300 FIND v(dout1_386) AT=155.025n

.meas tran vdout1_387ck300 FIND v(dout1_387) AT=155.025n

.meas tran vdout1_388ck300 FIND v(dout1_388) AT=155.025n

.meas tran vdout1_389ck300 FIND v(dout1_389) AT=155.025n

.meas tran vdout1_390ck300 FIND v(dout1_390) AT=155.025n

.meas tran vdout1_391ck300 FIND v(dout1_391) AT=155.025n

.meas tran vdout1_392ck300 FIND v(dout1_392) AT=155.025n

.meas tran vdout1_393ck300 FIND v(dout1_393) AT=155.025n

.meas tran vdout1_394ck300 FIND v(dout1_394) AT=155.025n

.meas tran vdout1_395ck300 FIND v(dout1_395) AT=155.025n

.meas tran vdout1_396ck300 FIND v(dout1_396) AT=155.025n

.meas tran vdout1_397ck300 FIND v(dout1_397) AT=155.025n

.meas tran vdout1_398ck300 FIND v(dout1_398) AT=155.025n

.meas tran vdout1_399ck300 FIND v(dout1_399) AT=155.025n

.meas tran vdout1_400ck300 FIND v(dout1_400) AT=155.025n

.meas tran vdout1_401ck300 FIND v(dout1_401) AT=155.025n

.meas tran vdout1_402ck300 FIND v(dout1_402) AT=155.025n

.meas tran vdout1_403ck300 FIND v(dout1_403) AT=155.025n

.meas tran vdout1_404ck300 FIND v(dout1_404) AT=155.025n

.meas tran vdout1_405ck300 FIND v(dout1_405) AT=155.025n

.meas tran vdout1_406ck300 FIND v(dout1_406) AT=155.025n

.meas tran vdout1_407ck300 FIND v(dout1_407) AT=155.025n

.meas tran vdout1_408ck300 FIND v(dout1_408) AT=155.025n

.meas tran vdout1_409ck300 FIND v(dout1_409) AT=155.025n

.meas tran vdout1_410ck300 FIND v(dout1_410) AT=155.025n

.meas tran vdout1_411ck300 FIND v(dout1_411) AT=155.025n

.meas tran vdout1_412ck300 FIND v(dout1_412) AT=155.025n

.meas tran vdout1_413ck300 FIND v(dout1_413) AT=155.025n

.meas tran vdout1_414ck300 FIND v(dout1_414) AT=155.025n

.meas tran vdout1_415ck300 FIND v(dout1_415) AT=155.025n

.meas tran vdout1_416ck300 FIND v(dout1_416) AT=155.025n

.meas tran vdout1_417ck300 FIND v(dout1_417) AT=155.025n

.meas tran vdout1_418ck300 FIND v(dout1_418) AT=155.025n

.meas tran vdout1_419ck300 FIND v(dout1_419) AT=155.025n

.meas tran vdout1_420ck300 FIND v(dout1_420) AT=155.025n

.meas tran vdout1_421ck300 FIND v(dout1_421) AT=155.025n

.meas tran vdout1_422ck300 FIND v(dout1_422) AT=155.025n

.meas tran vdout1_423ck300 FIND v(dout1_423) AT=155.025n

.meas tran vdout1_424ck300 FIND v(dout1_424) AT=155.025n

.meas tran vdout1_425ck300 FIND v(dout1_425) AT=155.025n

.meas tran vdout1_426ck300 FIND v(dout1_426) AT=155.025n

.meas tran vdout1_427ck300 FIND v(dout1_427) AT=155.025n

.meas tran vdout1_428ck300 FIND v(dout1_428) AT=155.025n

.meas tran vdout1_429ck300 FIND v(dout1_429) AT=155.025n

.meas tran vdout1_430ck300 FIND v(dout1_430) AT=155.025n

.meas tran vdout1_431ck300 FIND v(dout1_431) AT=155.025n

.meas tran vdout1_432ck300 FIND v(dout1_432) AT=155.025n

.meas tran vdout1_433ck300 FIND v(dout1_433) AT=155.025n

.meas tran vdout1_434ck300 FIND v(dout1_434) AT=155.025n

.meas tran vdout1_435ck300 FIND v(dout1_435) AT=155.025n

.meas tran vdout1_436ck300 FIND v(dout1_436) AT=155.025n

.meas tran vdout1_437ck300 FIND v(dout1_437) AT=155.025n

.meas tran vdout1_438ck300 FIND v(dout1_438) AT=155.025n

.meas tran vdout1_439ck300 FIND v(dout1_439) AT=155.025n

.meas tran vdout1_440ck300 FIND v(dout1_440) AT=155.025n

.meas tran vdout1_441ck300 FIND v(dout1_441) AT=155.025n

.meas tran vdout1_442ck300 FIND v(dout1_442) AT=155.025n

.meas tran vdout1_443ck300 FIND v(dout1_443) AT=155.025n

.meas tran vdout1_444ck300 FIND v(dout1_444) AT=155.025n

.meas tran vdout1_445ck300 FIND v(dout1_445) AT=155.025n

.meas tran vdout1_446ck300 FIND v(dout1_446) AT=155.025n

.meas tran vdout1_447ck300 FIND v(dout1_447) AT=155.025n

.meas tran vdout1_448ck300 FIND v(dout1_448) AT=155.025n

.meas tran vdout1_449ck300 FIND v(dout1_449) AT=155.025n

.meas tran vdout1_450ck300 FIND v(dout1_450) AT=155.025n

.meas tran vdout1_451ck300 FIND v(dout1_451) AT=155.025n

.meas tran vdout1_452ck300 FIND v(dout1_452) AT=155.025n

.meas tran vdout1_453ck300 FIND v(dout1_453) AT=155.025n

.meas tran vdout1_454ck300 FIND v(dout1_454) AT=155.025n

.meas tran vdout1_455ck300 FIND v(dout1_455) AT=155.025n

.meas tran vdout1_456ck300 FIND v(dout1_456) AT=155.025n

.meas tran vdout1_457ck300 FIND v(dout1_457) AT=155.025n

.meas tran vdout1_458ck300 FIND v(dout1_458) AT=155.025n

.meas tran vdout1_459ck300 FIND v(dout1_459) AT=155.025n

.meas tran vdout1_460ck300 FIND v(dout1_460) AT=155.025n

.meas tran vdout1_461ck300 FIND v(dout1_461) AT=155.025n

.meas tran vdout1_462ck300 FIND v(dout1_462) AT=155.025n

.meas tran vdout1_463ck300 FIND v(dout1_463) AT=155.025n

.meas tran vdout1_464ck300 FIND v(dout1_464) AT=155.025n

.meas tran vdout1_465ck300 FIND v(dout1_465) AT=155.025n

.meas tran vdout1_466ck300 FIND v(dout1_466) AT=155.025n

.meas tran vdout1_467ck300 FIND v(dout1_467) AT=155.025n

.meas tran vdout1_468ck300 FIND v(dout1_468) AT=155.025n

.meas tran vdout1_469ck300 FIND v(dout1_469) AT=155.025n

.meas tran vdout1_470ck300 FIND v(dout1_470) AT=155.025n

.meas tran vdout1_471ck300 FIND v(dout1_471) AT=155.025n

.meas tran vdout1_472ck300 FIND v(dout1_472) AT=155.025n

.meas tran vdout1_473ck300 FIND v(dout1_473) AT=155.025n

.meas tran vdout1_474ck300 FIND v(dout1_474) AT=155.025n

.meas tran vdout1_475ck300 FIND v(dout1_475) AT=155.025n

.meas tran vdout1_476ck300 FIND v(dout1_476) AT=155.025n

.meas tran vdout1_477ck300 FIND v(dout1_477) AT=155.025n

.meas tran vdout1_478ck300 FIND v(dout1_478) AT=155.025n

.meas tran vdout1_479ck300 FIND v(dout1_479) AT=155.025n

.meas tran vdout1_480ck300 FIND v(dout1_480) AT=155.025n

.meas tran vdout1_481ck300 FIND v(dout1_481) AT=155.025n

.meas tran vdout1_482ck300 FIND v(dout1_482) AT=155.025n

.meas tran vdout1_483ck300 FIND v(dout1_483) AT=155.025n

.meas tran vdout1_484ck300 FIND v(dout1_484) AT=155.025n

.meas tran vdout1_485ck300 FIND v(dout1_485) AT=155.025n

.meas tran vdout1_486ck300 FIND v(dout1_486) AT=155.025n

.meas tran vdout1_487ck300 FIND v(dout1_487) AT=155.025n

.meas tran vdout1_488ck300 FIND v(dout1_488) AT=155.025n

.meas tran vdout1_489ck300 FIND v(dout1_489) AT=155.025n

.meas tran vdout1_490ck300 FIND v(dout1_490) AT=155.025n

.meas tran vdout1_491ck300 FIND v(dout1_491) AT=155.025n

.meas tran vdout1_492ck300 FIND v(dout1_492) AT=155.025n

.meas tran vdout1_493ck300 FIND v(dout1_493) AT=155.025n

.meas tran vdout1_494ck300 FIND v(dout1_494) AT=155.025n

.meas tran vdout1_495ck300 FIND v(dout1_495) AT=155.025n

.meas tran vdout1_496ck300 FIND v(dout1_496) AT=155.025n

.meas tran vdout1_497ck300 FIND v(dout1_497) AT=155.025n

.meas tran vdout1_498ck300 FIND v(dout1_498) AT=155.025n

.meas tran vdout1_499ck300 FIND v(dout1_499) AT=155.025n

.meas tran vdout1_500ck300 FIND v(dout1_500) AT=155.025n

.meas tran vdout1_501ck300 FIND v(dout1_501) AT=155.025n

.meas tran vdout1_502ck300 FIND v(dout1_502) AT=155.025n

.meas tran vdout1_503ck300 FIND v(dout1_503) AT=155.025n

.meas tran vdout1_504ck300 FIND v(dout1_504) AT=155.025n

.meas tran vdout1_505ck300 FIND v(dout1_505) AT=155.025n

.meas tran vdout1_506ck300 FIND v(dout1_506) AT=155.025n

.meas tran vdout1_507ck300 FIND v(dout1_507) AT=155.025n

.meas tran vdout1_508ck300 FIND v(dout1_508) AT=155.025n

.meas tran vdout1_509ck300 FIND v(dout1_509) AT=155.025n

.meas tran vdout1_510ck300 FIND v(dout1_510) AT=155.025n

.meas tran vdout1_511ck300 FIND v(dout1_511) AT=155.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_23ck310 FIND v(dout1_23) AT=160.025n

.meas tran vdout1_24ck310 FIND v(dout1_24) AT=160.025n

.meas tran vdout1_25ck310 FIND v(dout1_25) AT=160.025n

.meas tran vdout1_26ck310 FIND v(dout1_26) AT=160.025n

.meas tran vdout1_27ck310 FIND v(dout1_27) AT=160.025n

.meas tran vdout1_28ck310 FIND v(dout1_28) AT=160.025n

.meas tran vdout1_29ck310 FIND v(dout1_29) AT=160.025n

.meas tran vdout1_30ck310 FIND v(dout1_30) AT=160.025n

.meas tran vdout1_31ck310 FIND v(dout1_31) AT=160.025n

.meas tran vdout1_32ck310 FIND v(dout1_32) AT=160.025n

.meas tran vdout1_33ck310 FIND v(dout1_33) AT=160.025n

.meas tran vdout1_34ck310 FIND v(dout1_34) AT=160.025n

.meas tran vdout1_35ck310 FIND v(dout1_35) AT=160.025n

.meas tran vdout1_36ck310 FIND v(dout1_36) AT=160.025n

.meas tran vdout1_37ck310 FIND v(dout1_37) AT=160.025n

.meas tran vdout1_38ck310 FIND v(dout1_38) AT=160.025n

.meas tran vdout1_39ck310 FIND v(dout1_39) AT=160.025n

.meas tran vdout1_40ck310 FIND v(dout1_40) AT=160.025n

.meas tran vdout1_41ck310 FIND v(dout1_41) AT=160.025n

.meas tran vdout1_42ck310 FIND v(dout1_42) AT=160.025n

.meas tran vdout1_43ck310 FIND v(dout1_43) AT=160.025n

.meas tran vdout1_44ck310 FIND v(dout1_44) AT=160.025n

.meas tran vdout1_45ck310 FIND v(dout1_45) AT=160.025n

.meas tran vdout1_46ck310 FIND v(dout1_46) AT=160.025n

.meas tran vdout1_47ck310 FIND v(dout1_47) AT=160.025n

.meas tran vdout1_48ck310 FIND v(dout1_48) AT=160.025n

.meas tran vdout1_49ck310 FIND v(dout1_49) AT=160.025n

.meas tran vdout1_50ck310 FIND v(dout1_50) AT=160.025n

.meas tran vdout1_51ck310 FIND v(dout1_51) AT=160.025n

.meas tran vdout1_52ck310 FIND v(dout1_52) AT=160.025n

.meas tran vdout1_53ck310 FIND v(dout1_53) AT=160.025n

.meas tran vdout1_54ck310 FIND v(dout1_54) AT=160.025n

.meas tran vdout1_55ck310 FIND v(dout1_55) AT=160.025n

.meas tran vdout1_56ck310 FIND v(dout1_56) AT=160.025n

.meas tran vdout1_57ck310 FIND v(dout1_57) AT=160.025n

.meas tran vdout1_58ck310 FIND v(dout1_58) AT=160.025n

.meas tran vdout1_59ck310 FIND v(dout1_59) AT=160.025n

.meas tran vdout1_60ck310 FIND v(dout1_60) AT=160.025n

.meas tran vdout1_61ck310 FIND v(dout1_61) AT=160.025n

.meas tran vdout1_62ck310 FIND v(dout1_62) AT=160.025n

.meas tran vdout1_63ck310 FIND v(dout1_63) AT=160.025n

.meas tran vdout1_64ck310 FIND v(dout1_64) AT=160.025n

.meas tran vdout1_65ck310 FIND v(dout1_65) AT=160.025n

.meas tran vdout1_66ck310 FIND v(dout1_66) AT=160.025n

.meas tran vdout1_67ck310 FIND v(dout1_67) AT=160.025n

.meas tran vdout1_68ck310 FIND v(dout1_68) AT=160.025n

.meas tran vdout1_69ck310 FIND v(dout1_69) AT=160.025n

.meas tran vdout1_70ck310 FIND v(dout1_70) AT=160.025n

.meas tran vdout1_71ck310 FIND v(dout1_71) AT=160.025n

.meas tran vdout1_72ck310 FIND v(dout1_72) AT=160.025n

.meas tran vdout1_73ck310 FIND v(dout1_73) AT=160.025n

.meas tran vdout1_74ck310 FIND v(dout1_74) AT=160.025n

.meas tran vdout1_75ck310 FIND v(dout1_75) AT=160.025n

.meas tran vdout1_76ck310 FIND v(dout1_76) AT=160.025n

.meas tran vdout1_77ck310 FIND v(dout1_77) AT=160.025n

.meas tran vdout1_78ck310 FIND v(dout1_78) AT=160.025n

.meas tran vdout1_79ck310 FIND v(dout1_79) AT=160.025n

.meas tran vdout1_80ck310 FIND v(dout1_80) AT=160.025n

.meas tran vdout1_81ck310 FIND v(dout1_81) AT=160.025n

.meas tran vdout1_82ck310 FIND v(dout1_82) AT=160.025n

.meas tran vdout1_83ck310 FIND v(dout1_83) AT=160.025n

.meas tran vdout1_84ck310 FIND v(dout1_84) AT=160.025n

.meas tran vdout1_85ck310 FIND v(dout1_85) AT=160.025n

.meas tran vdout1_86ck310 FIND v(dout1_86) AT=160.025n

.meas tran vdout1_87ck310 FIND v(dout1_87) AT=160.025n

.meas tran vdout1_88ck310 FIND v(dout1_88) AT=160.025n

.meas tran vdout1_89ck310 FIND v(dout1_89) AT=160.025n

.meas tran vdout1_90ck310 FIND v(dout1_90) AT=160.025n

.meas tran vdout1_91ck310 FIND v(dout1_91) AT=160.025n

.meas tran vdout1_92ck310 FIND v(dout1_92) AT=160.025n

.meas tran vdout1_93ck310 FIND v(dout1_93) AT=160.025n

.meas tran vdout1_94ck310 FIND v(dout1_94) AT=160.025n

.meas tran vdout1_95ck310 FIND v(dout1_95) AT=160.025n

.meas tran vdout1_96ck310 FIND v(dout1_96) AT=160.025n

.meas tran vdout1_97ck310 FIND v(dout1_97) AT=160.025n

.meas tran vdout1_98ck310 FIND v(dout1_98) AT=160.025n

.meas tran vdout1_99ck310 FIND v(dout1_99) AT=160.025n

.meas tran vdout1_100ck310 FIND v(dout1_100) AT=160.025n

.meas tran vdout1_101ck310 FIND v(dout1_101) AT=160.025n

.meas tran vdout1_102ck310 FIND v(dout1_102) AT=160.025n

.meas tran vdout1_103ck310 FIND v(dout1_103) AT=160.025n

.meas tran vdout1_104ck310 FIND v(dout1_104) AT=160.025n

.meas tran vdout1_105ck310 FIND v(dout1_105) AT=160.025n

.meas tran vdout1_106ck310 FIND v(dout1_106) AT=160.025n

.meas tran vdout1_107ck310 FIND v(dout1_107) AT=160.025n

.meas tran vdout1_108ck310 FIND v(dout1_108) AT=160.025n

.meas tran vdout1_109ck310 FIND v(dout1_109) AT=160.025n

.meas tran vdout1_110ck310 FIND v(dout1_110) AT=160.025n

.meas tran vdout1_111ck310 FIND v(dout1_111) AT=160.025n

.meas tran vdout1_112ck310 FIND v(dout1_112) AT=160.025n

.meas tran vdout1_113ck310 FIND v(dout1_113) AT=160.025n

.meas tran vdout1_114ck310 FIND v(dout1_114) AT=160.025n

.meas tran vdout1_115ck310 FIND v(dout1_115) AT=160.025n

.meas tran vdout1_116ck310 FIND v(dout1_116) AT=160.025n

.meas tran vdout1_117ck310 FIND v(dout1_117) AT=160.025n

.meas tran vdout1_118ck310 FIND v(dout1_118) AT=160.025n

.meas tran vdout1_119ck310 FIND v(dout1_119) AT=160.025n

.meas tran vdout1_120ck310 FIND v(dout1_120) AT=160.025n

.meas tran vdout1_121ck310 FIND v(dout1_121) AT=160.025n

.meas tran vdout1_122ck310 FIND v(dout1_122) AT=160.025n

.meas tran vdout1_123ck310 FIND v(dout1_123) AT=160.025n

.meas tran vdout1_124ck310 FIND v(dout1_124) AT=160.025n

.meas tran vdout1_125ck310 FIND v(dout1_125) AT=160.025n

.meas tran vdout1_126ck310 FIND v(dout1_126) AT=160.025n

.meas tran vdout1_127ck310 FIND v(dout1_127) AT=160.025n

.meas tran vdout1_128ck310 FIND v(dout1_128) AT=160.025n

.meas tran vdout1_129ck310 FIND v(dout1_129) AT=160.025n

.meas tran vdout1_130ck310 FIND v(dout1_130) AT=160.025n

.meas tran vdout1_131ck310 FIND v(dout1_131) AT=160.025n

.meas tran vdout1_132ck310 FIND v(dout1_132) AT=160.025n

.meas tran vdout1_133ck310 FIND v(dout1_133) AT=160.025n

.meas tran vdout1_134ck310 FIND v(dout1_134) AT=160.025n

.meas tran vdout1_135ck310 FIND v(dout1_135) AT=160.025n

.meas tran vdout1_136ck310 FIND v(dout1_136) AT=160.025n

.meas tran vdout1_137ck310 FIND v(dout1_137) AT=160.025n

.meas tran vdout1_138ck310 FIND v(dout1_138) AT=160.025n

.meas tran vdout1_139ck310 FIND v(dout1_139) AT=160.025n

.meas tran vdout1_140ck310 FIND v(dout1_140) AT=160.025n

.meas tran vdout1_141ck310 FIND v(dout1_141) AT=160.025n

.meas tran vdout1_142ck310 FIND v(dout1_142) AT=160.025n

.meas tran vdout1_143ck310 FIND v(dout1_143) AT=160.025n

.meas tran vdout1_144ck310 FIND v(dout1_144) AT=160.025n

.meas tran vdout1_145ck310 FIND v(dout1_145) AT=160.025n

.meas tran vdout1_146ck310 FIND v(dout1_146) AT=160.025n

.meas tran vdout1_147ck310 FIND v(dout1_147) AT=160.025n

.meas tran vdout1_148ck310 FIND v(dout1_148) AT=160.025n

.meas tran vdout1_149ck310 FIND v(dout1_149) AT=160.025n

.meas tran vdout1_150ck310 FIND v(dout1_150) AT=160.025n

.meas tran vdout1_151ck310 FIND v(dout1_151) AT=160.025n

.meas tran vdout1_152ck310 FIND v(dout1_152) AT=160.025n

.meas tran vdout1_153ck310 FIND v(dout1_153) AT=160.025n

.meas tran vdout1_154ck310 FIND v(dout1_154) AT=160.025n

.meas tran vdout1_155ck310 FIND v(dout1_155) AT=160.025n

.meas tran vdout1_156ck310 FIND v(dout1_156) AT=160.025n

.meas tran vdout1_157ck310 FIND v(dout1_157) AT=160.025n

.meas tran vdout1_158ck310 FIND v(dout1_158) AT=160.025n

.meas tran vdout1_159ck310 FIND v(dout1_159) AT=160.025n

.meas tran vdout1_160ck310 FIND v(dout1_160) AT=160.025n

.meas tran vdout1_161ck310 FIND v(dout1_161) AT=160.025n

.meas tran vdout1_162ck310 FIND v(dout1_162) AT=160.025n

.meas tran vdout1_163ck310 FIND v(dout1_163) AT=160.025n

.meas tran vdout1_164ck310 FIND v(dout1_164) AT=160.025n

.meas tran vdout1_165ck310 FIND v(dout1_165) AT=160.025n

.meas tran vdout1_166ck310 FIND v(dout1_166) AT=160.025n

.meas tran vdout1_167ck310 FIND v(dout1_167) AT=160.025n

.meas tran vdout1_168ck310 FIND v(dout1_168) AT=160.025n

.meas tran vdout1_169ck310 FIND v(dout1_169) AT=160.025n

.meas tran vdout1_170ck310 FIND v(dout1_170) AT=160.025n

.meas tran vdout1_171ck310 FIND v(dout1_171) AT=160.025n

.meas tran vdout1_172ck310 FIND v(dout1_172) AT=160.025n

.meas tran vdout1_173ck310 FIND v(dout1_173) AT=160.025n

.meas tran vdout1_174ck310 FIND v(dout1_174) AT=160.025n

.meas tran vdout1_175ck310 FIND v(dout1_175) AT=160.025n

.meas tran vdout1_176ck310 FIND v(dout1_176) AT=160.025n

.meas tran vdout1_177ck310 FIND v(dout1_177) AT=160.025n

.meas tran vdout1_178ck310 FIND v(dout1_178) AT=160.025n

.meas tran vdout1_179ck310 FIND v(dout1_179) AT=160.025n

.meas tran vdout1_180ck310 FIND v(dout1_180) AT=160.025n

.meas tran vdout1_181ck310 FIND v(dout1_181) AT=160.025n

.meas tran vdout1_182ck310 FIND v(dout1_182) AT=160.025n

.meas tran vdout1_183ck310 FIND v(dout1_183) AT=160.025n

.meas tran vdout1_184ck310 FIND v(dout1_184) AT=160.025n

.meas tran vdout1_185ck310 FIND v(dout1_185) AT=160.025n

.meas tran vdout1_186ck310 FIND v(dout1_186) AT=160.025n

.meas tran vdout1_187ck310 FIND v(dout1_187) AT=160.025n

.meas tran vdout1_188ck310 FIND v(dout1_188) AT=160.025n

.meas tran vdout1_189ck310 FIND v(dout1_189) AT=160.025n

.meas tran vdout1_190ck310 FIND v(dout1_190) AT=160.025n

.meas tran vdout1_191ck310 FIND v(dout1_191) AT=160.025n

.meas tran vdout1_192ck310 FIND v(dout1_192) AT=160.025n

.meas tran vdout1_193ck310 FIND v(dout1_193) AT=160.025n

.meas tran vdout1_194ck310 FIND v(dout1_194) AT=160.025n

.meas tran vdout1_195ck310 FIND v(dout1_195) AT=160.025n

.meas tran vdout1_196ck310 FIND v(dout1_196) AT=160.025n

.meas tran vdout1_197ck310 FIND v(dout1_197) AT=160.025n

.meas tran vdout1_198ck310 FIND v(dout1_198) AT=160.025n

.meas tran vdout1_199ck310 FIND v(dout1_199) AT=160.025n

.meas tran vdout1_200ck310 FIND v(dout1_200) AT=160.025n

.meas tran vdout1_201ck310 FIND v(dout1_201) AT=160.025n

.meas tran vdout1_202ck310 FIND v(dout1_202) AT=160.025n

.meas tran vdout1_203ck310 FIND v(dout1_203) AT=160.025n

.meas tran vdout1_204ck310 FIND v(dout1_204) AT=160.025n

.meas tran vdout1_205ck310 FIND v(dout1_205) AT=160.025n

.meas tran vdout1_206ck310 FIND v(dout1_206) AT=160.025n

.meas tran vdout1_207ck310 FIND v(dout1_207) AT=160.025n

.meas tran vdout1_208ck310 FIND v(dout1_208) AT=160.025n

.meas tran vdout1_209ck310 FIND v(dout1_209) AT=160.025n

.meas tran vdout1_210ck310 FIND v(dout1_210) AT=160.025n

.meas tran vdout1_211ck310 FIND v(dout1_211) AT=160.025n

.meas tran vdout1_212ck310 FIND v(dout1_212) AT=160.025n

.meas tran vdout1_213ck310 FIND v(dout1_213) AT=160.025n

.meas tran vdout1_214ck310 FIND v(dout1_214) AT=160.025n

.meas tran vdout1_215ck310 FIND v(dout1_215) AT=160.025n

.meas tran vdout1_216ck310 FIND v(dout1_216) AT=160.025n

.meas tran vdout1_217ck310 FIND v(dout1_217) AT=160.025n

.meas tran vdout1_218ck310 FIND v(dout1_218) AT=160.025n

.meas tran vdout1_219ck310 FIND v(dout1_219) AT=160.025n

.meas tran vdout1_220ck310 FIND v(dout1_220) AT=160.025n

.meas tran vdout1_221ck310 FIND v(dout1_221) AT=160.025n

.meas tran vdout1_222ck310 FIND v(dout1_222) AT=160.025n

.meas tran vdout1_223ck310 FIND v(dout1_223) AT=160.025n

.meas tran vdout1_224ck310 FIND v(dout1_224) AT=160.025n

.meas tran vdout1_225ck310 FIND v(dout1_225) AT=160.025n

.meas tran vdout1_226ck310 FIND v(dout1_226) AT=160.025n

.meas tran vdout1_227ck310 FIND v(dout1_227) AT=160.025n

.meas tran vdout1_228ck310 FIND v(dout1_228) AT=160.025n

.meas tran vdout1_229ck310 FIND v(dout1_229) AT=160.025n

.meas tran vdout1_230ck310 FIND v(dout1_230) AT=160.025n

.meas tran vdout1_231ck310 FIND v(dout1_231) AT=160.025n

.meas tran vdout1_232ck310 FIND v(dout1_232) AT=160.025n

.meas tran vdout1_233ck310 FIND v(dout1_233) AT=160.025n

.meas tran vdout1_234ck310 FIND v(dout1_234) AT=160.025n

.meas tran vdout1_235ck310 FIND v(dout1_235) AT=160.025n

.meas tran vdout1_236ck310 FIND v(dout1_236) AT=160.025n

.meas tran vdout1_237ck310 FIND v(dout1_237) AT=160.025n

.meas tran vdout1_238ck310 FIND v(dout1_238) AT=160.025n

.meas tran vdout1_239ck310 FIND v(dout1_239) AT=160.025n

.meas tran vdout1_240ck310 FIND v(dout1_240) AT=160.025n

.meas tran vdout1_241ck310 FIND v(dout1_241) AT=160.025n

.meas tran vdout1_242ck310 FIND v(dout1_242) AT=160.025n

.meas tran vdout1_243ck310 FIND v(dout1_243) AT=160.025n

.meas tran vdout1_244ck310 FIND v(dout1_244) AT=160.025n

.meas tran vdout1_245ck310 FIND v(dout1_245) AT=160.025n

.meas tran vdout1_246ck310 FIND v(dout1_246) AT=160.025n

.meas tran vdout1_247ck310 FIND v(dout1_247) AT=160.025n

.meas tran vdout1_248ck310 FIND v(dout1_248) AT=160.025n

.meas tran vdout1_249ck310 FIND v(dout1_249) AT=160.025n

.meas tran vdout1_250ck310 FIND v(dout1_250) AT=160.025n

.meas tran vdout1_251ck310 FIND v(dout1_251) AT=160.025n

.meas tran vdout1_252ck310 FIND v(dout1_252) AT=160.025n

.meas tran vdout1_253ck310 FIND v(dout1_253) AT=160.025n

.meas tran vdout1_254ck310 FIND v(dout1_254) AT=160.025n

.meas tran vdout1_255ck310 FIND v(dout1_255) AT=160.025n

.meas tran vdout1_256ck310 FIND v(dout1_256) AT=160.025n

.meas tran vdout1_257ck310 FIND v(dout1_257) AT=160.025n

.meas tran vdout1_258ck310 FIND v(dout1_258) AT=160.025n

.meas tran vdout1_259ck310 FIND v(dout1_259) AT=160.025n

.meas tran vdout1_260ck310 FIND v(dout1_260) AT=160.025n

.meas tran vdout1_261ck310 FIND v(dout1_261) AT=160.025n

.meas tran vdout1_262ck310 FIND v(dout1_262) AT=160.025n

.meas tran vdout1_263ck310 FIND v(dout1_263) AT=160.025n

.meas tran vdout1_264ck310 FIND v(dout1_264) AT=160.025n

.meas tran vdout1_265ck310 FIND v(dout1_265) AT=160.025n

.meas tran vdout1_266ck310 FIND v(dout1_266) AT=160.025n

.meas tran vdout1_267ck310 FIND v(dout1_267) AT=160.025n

.meas tran vdout1_268ck310 FIND v(dout1_268) AT=160.025n

.meas tran vdout1_269ck310 FIND v(dout1_269) AT=160.025n

.meas tran vdout1_270ck310 FIND v(dout1_270) AT=160.025n

.meas tran vdout1_271ck310 FIND v(dout1_271) AT=160.025n

.meas tran vdout1_272ck310 FIND v(dout1_272) AT=160.025n

.meas tran vdout1_273ck310 FIND v(dout1_273) AT=160.025n

.meas tran vdout1_274ck310 FIND v(dout1_274) AT=160.025n

.meas tran vdout1_275ck310 FIND v(dout1_275) AT=160.025n

.meas tran vdout1_276ck310 FIND v(dout1_276) AT=160.025n

.meas tran vdout1_277ck310 FIND v(dout1_277) AT=160.025n

.meas tran vdout1_278ck310 FIND v(dout1_278) AT=160.025n

.meas tran vdout1_279ck310 FIND v(dout1_279) AT=160.025n

.meas tran vdout1_280ck310 FIND v(dout1_280) AT=160.025n

.meas tran vdout1_281ck310 FIND v(dout1_281) AT=160.025n

.meas tran vdout1_282ck310 FIND v(dout1_282) AT=160.025n

.meas tran vdout1_283ck310 FIND v(dout1_283) AT=160.025n

.meas tran vdout1_284ck310 FIND v(dout1_284) AT=160.025n

.meas tran vdout1_285ck310 FIND v(dout1_285) AT=160.025n

.meas tran vdout1_286ck310 FIND v(dout1_286) AT=160.025n

.meas tran vdout1_287ck310 FIND v(dout1_287) AT=160.025n

.meas tran vdout1_288ck310 FIND v(dout1_288) AT=160.025n

.meas tran vdout1_289ck310 FIND v(dout1_289) AT=160.025n

.meas tran vdout1_290ck310 FIND v(dout1_290) AT=160.025n

.meas tran vdout1_291ck310 FIND v(dout1_291) AT=160.025n

.meas tran vdout1_292ck310 FIND v(dout1_292) AT=160.025n

.meas tran vdout1_293ck310 FIND v(dout1_293) AT=160.025n

.meas tran vdout1_294ck310 FIND v(dout1_294) AT=160.025n

.meas tran vdout1_295ck310 FIND v(dout1_295) AT=160.025n

.meas tran vdout1_296ck310 FIND v(dout1_296) AT=160.025n

.meas tran vdout1_297ck310 FIND v(dout1_297) AT=160.025n

.meas tran vdout1_298ck310 FIND v(dout1_298) AT=160.025n

.meas tran vdout1_299ck310 FIND v(dout1_299) AT=160.025n

.meas tran vdout1_300ck310 FIND v(dout1_300) AT=160.025n

.meas tran vdout1_301ck310 FIND v(dout1_301) AT=160.025n

.meas tran vdout1_302ck310 FIND v(dout1_302) AT=160.025n

.meas tran vdout1_303ck310 FIND v(dout1_303) AT=160.025n

.meas tran vdout1_304ck310 FIND v(dout1_304) AT=160.025n

.meas tran vdout1_305ck310 FIND v(dout1_305) AT=160.025n

.meas tran vdout1_306ck310 FIND v(dout1_306) AT=160.025n

.meas tran vdout1_307ck310 FIND v(dout1_307) AT=160.025n

.meas tran vdout1_308ck310 FIND v(dout1_308) AT=160.025n

.meas tran vdout1_309ck310 FIND v(dout1_309) AT=160.025n

.meas tran vdout1_310ck310 FIND v(dout1_310) AT=160.025n

.meas tran vdout1_311ck310 FIND v(dout1_311) AT=160.025n

.meas tran vdout1_312ck310 FIND v(dout1_312) AT=160.025n

.meas tran vdout1_313ck310 FIND v(dout1_313) AT=160.025n

.meas tran vdout1_314ck310 FIND v(dout1_314) AT=160.025n

.meas tran vdout1_315ck310 FIND v(dout1_315) AT=160.025n

.meas tran vdout1_316ck310 FIND v(dout1_316) AT=160.025n

.meas tran vdout1_317ck310 FIND v(dout1_317) AT=160.025n

.meas tran vdout1_318ck310 FIND v(dout1_318) AT=160.025n

.meas tran vdout1_319ck310 FIND v(dout1_319) AT=160.025n

.meas tran vdout1_320ck310 FIND v(dout1_320) AT=160.025n

.meas tran vdout1_321ck310 FIND v(dout1_321) AT=160.025n

.meas tran vdout1_322ck310 FIND v(dout1_322) AT=160.025n

.meas tran vdout1_323ck310 FIND v(dout1_323) AT=160.025n

.meas tran vdout1_324ck310 FIND v(dout1_324) AT=160.025n

.meas tran vdout1_325ck310 FIND v(dout1_325) AT=160.025n

.meas tran vdout1_326ck310 FIND v(dout1_326) AT=160.025n

.meas tran vdout1_327ck310 FIND v(dout1_327) AT=160.025n

.meas tran vdout1_328ck310 FIND v(dout1_328) AT=160.025n

.meas tran vdout1_329ck310 FIND v(dout1_329) AT=160.025n

.meas tran vdout1_330ck310 FIND v(dout1_330) AT=160.025n

.meas tran vdout1_331ck310 FIND v(dout1_331) AT=160.025n

.meas tran vdout1_332ck310 FIND v(dout1_332) AT=160.025n

.meas tran vdout1_333ck310 FIND v(dout1_333) AT=160.025n

.meas tran vdout1_334ck310 FIND v(dout1_334) AT=160.025n

.meas tran vdout1_335ck310 FIND v(dout1_335) AT=160.025n

.meas tran vdout1_336ck310 FIND v(dout1_336) AT=160.025n

.meas tran vdout1_337ck310 FIND v(dout1_337) AT=160.025n

.meas tran vdout1_338ck310 FIND v(dout1_338) AT=160.025n

.meas tran vdout1_339ck310 FIND v(dout1_339) AT=160.025n

.meas tran vdout1_340ck310 FIND v(dout1_340) AT=160.025n

.meas tran vdout1_341ck310 FIND v(dout1_341) AT=160.025n

.meas tran vdout1_342ck310 FIND v(dout1_342) AT=160.025n

.meas tran vdout1_343ck310 FIND v(dout1_343) AT=160.025n

.meas tran vdout1_344ck310 FIND v(dout1_344) AT=160.025n

.meas tran vdout1_345ck310 FIND v(dout1_345) AT=160.025n

.meas tran vdout1_346ck310 FIND v(dout1_346) AT=160.025n

.meas tran vdout1_347ck310 FIND v(dout1_347) AT=160.025n

.meas tran vdout1_348ck310 FIND v(dout1_348) AT=160.025n

.meas tran vdout1_349ck310 FIND v(dout1_349) AT=160.025n

.meas tran vdout1_350ck310 FIND v(dout1_350) AT=160.025n

.meas tran vdout1_351ck310 FIND v(dout1_351) AT=160.025n

.meas tran vdout1_352ck310 FIND v(dout1_352) AT=160.025n

.meas tran vdout1_353ck310 FIND v(dout1_353) AT=160.025n

.meas tran vdout1_354ck310 FIND v(dout1_354) AT=160.025n

.meas tran vdout1_355ck310 FIND v(dout1_355) AT=160.025n

.meas tran vdout1_356ck310 FIND v(dout1_356) AT=160.025n

.meas tran vdout1_357ck310 FIND v(dout1_357) AT=160.025n

.meas tran vdout1_358ck310 FIND v(dout1_358) AT=160.025n

.meas tran vdout1_359ck310 FIND v(dout1_359) AT=160.025n

.meas tran vdout1_360ck310 FIND v(dout1_360) AT=160.025n

.meas tran vdout1_361ck310 FIND v(dout1_361) AT=160.025n

.meas tran vdout1_362ck310 FIND v(dout1_362) AT=160.025n

.meas tran vdout1_363ck310 FIND v(dout1_363) AT=160.025n

.meas tran vdout1_364ck310 FIND v(dout1_364) AT=160.025n

.meas tran vdout1_365ck310 FIND v(dout1_365) AT=160.025n

.meas tran vdout1_366ck310 FIND v(dout1_366) AT=160.025n

.meas tran vdout1_367ck310 FIND v(dout1_367) AT=160.025n

.meas tran vdout1_368ck310 FIND v(dout1_368) AT=160.025n

.meas tran vdout1_369ck310 FIND v(dout1_369) AT=160.025n

.meas tran vdout1_370ck310 FIND v(dout1_370) AT=160.025n

.meas tran vdout1_371ck310 FIND v(dout1_371) AT=160.025n

.meas tran vdout1_372ck310 FIND v(dout1_372) AT=160.025n

.meas tran vdout1_373ck310 FIND v(dout1_373) AT=160.025n

.meas tran vdout1_374ck310 FIND v(dout1_374) AT=160.025n

.meas tran vdout1_375ck310 FIND v(dout1_375) AT=160.025n

.meas tran vdout1_376ck310 FIND v(dout1_376) AT=160.025n

.meas tran vdout1_377ck310 FIND v(dout1_377) AT=160.025n

.meas tran vdout1_378ck310 FIND v(dout1_378) AT=160.025n

.meas tran vdout1_379ck310 FIND v(dout1_379) AT=160.025n

.meas tran vdout1_380ck310 FIND v(dout1_380) AT=160.025n

.meas tran vdout1_381ck310 FIND v(dout1_381) AT=160.025n

.meas tran vdout1_382ck310 FIND v(dout1_382) AT=160.025n

.meas tran vdout1_383ck310 FIND v(dout1_383) AT=160.025n

.meas tran vdout1_384ck310 FIND v(dout1_384) AT=160.025n

.meas tran vdout1_385ck310 FIND v(dout1_385) AT=160.025n

.meas tran vdout1_386ck310 FIND v(dout1_386) AT=160.025n

.meas tran vdout1_387ck310 FIND v(dout1_387) AT=160.025n

.meas tran vdout1_388ck310 FIND v(dout1_388) AT=160.025n

.meas tran vdout1_389ck310 FIND v(dout1_389) AT=160.025n

.meas tran vdout1_390ck310 FIND v(dout1_390) AT=160.025n

.meas tran vdout1_391ck310 FIND v(dout1_391) AT=160.025n

.meas tran vdout1_392ck310 FIND v(dout1_392) AT=160.025n

.meas tran vdout1_393ck310 FIND v(dout1_393) AT=160.025n

.meas tran vdout1_394ck310 FIND v(dout1_394) AT=160.025n

.meas tran vdout1_395ck310 FIND v(dout1_395) AT=160.025n

.meas tran vdout1_396ck310 FIND v(dout1_396) AT=160.025n

.meas tran vdout1_397ck310 FIND v(dout1_397) AT=160.025n

.meas tran vdout1_398ck310 FIND v(dout1_398) AT=160.025n

.meas tran vdout1_399ck310 FIND v(dout1_399) AT=160.025n

.meas tran vdout1_400ck310 FIND v(dout1_400) AT=160.025n

.meas tran vdout1_401ck310 FIND v(dout1_401) AT=160.025n

.meas tran vdout1_402ck310 FIND v(dout1_402) AT=160.025n

.meas tran vdout1_403ck310 FIND v(dout1_403) AT=160.025n

.meas tran vdout1_404ck310 FIND v(dout1_404) AT=160.025n

.meas tran vdout1_405ck310 FIND v(dout1_405) AT=160.025n

.meas tran vdout1_406ck310 FIND v(dout1_406) AT=160.025n

.meas tran vdout1_407ck310 FIND v(dout1_407) AT=160.025n

.meas tran vdout1_408ck310 FIND v(dout1_408) AT=160.025n

.meas tran vdout1_409ck310 FIND v(dout1_409) AT=160.025n

.meas tran vdout1_410ck310 FIND v(dout1_410) AT=160.025n

.meas tran vdout1_411ck310 FIND v(dout1_411) AT=160.025n

.meas tran vdout1_412ck310 FIND v(dout1_412) AT=160.025n

.meas tran vdout1_413ck310 FIND v(dout1_413) AT=160.025n

.meas tran vdout1_414ck310 FIND v(dout1_414) AT=160.025n

.meas tran vdout1_415ck310 FIND v(dout1_415) AT=160.025n

.meas tran vdout1_416ck310 FIND v(dout1_416) AT=160.025n

.meas tran vdout1_417ck310 FIND v(dout1_417) AT=160.025n

.meas tran vdout1_418ck310 FIND v(dout1_418) AT=160.025n

.meas tran vdout1_419ck310 FIND v(dout1_419) AT=160.025n

.meas tran vdout1_420ck310 FIND v(dout1_420) AT=160.025n

.meas tran vdout1_421ck310 FIND v(dout1_421) AT=160.025n

.meas tran vdout1_422ck310 FIND v(dout1_422) AT=160.025n

.meas tran vdout1_423ck310 FIND v(dout1_423) AT=160.025n

.meas tran vdout1_424ck310 FIND v(dout1_424) AT=160.025n

.meas tran vdout1_425ck310 FIND v(dout1_425) AT=160.025n

.meas tran vdout1_426ck310 FIND v(dout1_426) AT=160.025n

.meas tran vdout1_427ck310 FIND v(dout1_427) AT=160.025n

.meas tran vdout1_428ck310 FIND v(dout1_428) AT=160.025n

.meas tran vdout1_429ck310 FIND v(dout1_429) AT=160.025n

.meas tran vdout1_430ck310 FIND v(dout1_430) AT=160.025n

.meas tran vdout1_431ck310 FIND v(dout1_431) AT=160.025n

.meas tran vdout1_432ck310 FIND v(dout1_432) AT=160.025n

.meas tran vdout1_433ck310 FIND v(dout1_433) AT=160.025n

.meas tran vdout1_434ck310 FIND v(dout1_434) AT=160.025n

.meas tran vdout1_435ck310 FIND v(dout1_435) AT=160.025n

.meas tran vdout1_436ck310 FIND v(dout1_436) AT=160.025n

.meas tran vdout1_437ck310 FIND v(dout1_437) AT=160.025n

.meas tran vdout1_438ck310 FIND v(dout1_438) AT=160.025n

.meas tran vdout1_439ck310 FIND v(dout1_439) AT=160.025n

.meas tran vdout1_440ck310 FIND v(dout1_440) AT=160.025n

.meas tran vdout1_441ck310 FIND v(dout1_441) AT=160.025n

.meas tran vdout1_442ck310 FIND v(dout1_442) AT=160.025n

.meas tran vdout1_443ck310 FIND v(dout1_443) AT=160.025n

.meas tran vdout1_444ck310 FIND v(dout1_444) AT=160.025n

.meas tran vdout1_445ck310 FIND v(dout1_445) AT=160.025n

.meas tran vdout1_446ck310 FIND v(dout1_446) AT=160.025n

.meas tran vdout1_447ck310 FIND v(dout1_447) AT=160.025n

.meas tran vdout1_448ck310 FIND v(dout1_448) AT=160.025n

.meas tran vdout1_449ck310 FIND v(dout1_449) AT=160.025n

.meas tran vdout1_450ck310 FIND v(dout1_450) AT=160.025n

.meas tran vdout1_451ck310 FIND v(dout1_451) AT=160.025n

.meas tran vdout1_452ck310 FIND v(dout1_452) AT=160.025n

.meas tran vdout1_453ck310 FIND v(dout1_453) AT=160.025n

.meas tran vdout1_454ck310 FIND v(dout1_454) AT=160.025n

.meas tran vdout1_455ck310 FIND v(dout1_455) AT=160.025n

.meas tran vdout1_456ck310 FIND v(dout1_456) AT=160.025n

.meas tran vdout1_457ck310 FIND v(dout1_457) AT=160.025n

.meas tran vdout1_458ck310 FIND v(dout1_458) AT=160.025n

.meas tran vdout1_459ck310 FIND v(dout1_459) AT=160.025n

.meas tran vdout1_460ck310 FIND v(dout1_460) AT=160.025n

.meas tran vdout1_461ck310 FIND v(dout1_461) AT=160.025n

.meas tran vdout1_462ck310 FIND v(dout1_462) AT=160.025n

.meas tran vdout1_463ck310 FIND v(dout1_463) AT=160.025n

.meas tran vdout1_464ck310 FIND v(dout1_464) AT=160.025n

.meas tran vdout1_465ck310 FIND v(dout1_465) AT=160.025n

.meas tran vdout1_466ck310 FIND v(dout1_466) AT=160.025n

.meas tran vdout1_467ck310 FIND v(dout1_467) AT=160.025n

.meas tran vdout1_468ck310 FIND v(dout1_468) AT=160.025n

.meas tran vdout1_469ck310 FIND v(dout1_469) AT=160.025n

.meas tran vdout1_470ck310 FIND v(dout1_470) AT=160.025n

.meas tran vdout1_471ck310 FIND v(dout1_471) AT=160.025n

.meas tran vdout1_472ck310 FIND v(dout1_472) AT=160.025n

.meas tran vdout1_473ck310 FIND v(dout1_473) AT=160.025n

.meas tran vdout1_474ck310 FIND v(dout1_474) AT=160.025n

.meas tran vdout1_475ck310 FIND v(dout1_475) AT=160.025n

.meas tran vdout1_476ck310 FIND v(dout1_476) AT=160.025n

.meas tran vdout1_477ck310 FIND v(dout1_477) AT=160.025n

.meas tran vdout1_478ck310 FIND v(dout1_478) AT=160.025n

.meas tran vdout1_479ck310 FIND v(dout1_479) AT=160.025n

.meas tran vdout1_480ck310 FIND v(dout1_480) AT=160.025n

.meas tran vdout1_481ck310 FIND v(dout1_481) AT=160.025n

.meas tran vdout1_482ck310 FIND v(dout1_482) AT=160.025n

.meas tran vdout1_483ck310 FIND v(dout1_483) AT=160.025n

.meas tran vdout1_484ck310 FIND v(dout1_484) AT=160.025n

.meas tran vdout1_485ck310 FIND v(dout1_485) AT=160.025n

.meas tran vdout1_486ck310 FIND v(dout1_486) AT=160.025n

.meas tran vdout1_487ck310 FIND v(dout1_487) AT=160.025n

.meas tran vdout1_488ck310 FIND v(dout1_488) AT=160.025n

.meas tran vdout1_489ck310 FIND v(dout1_489) AT=160.025n

.meas tran vdout1_490ck310 FIND v(dout1_490) AT=160.025n

.meas tran vdout1_491ck310 FIND v(dout1_491) AT=160.025n

.meas tran vdout1_492ck310 FIND v(dout1_492) AT=160.025n

.meas tran vdout1_493ck310 FIND v(dout1_493) AT=160.025n

.meas tran vdout1_494ck310 FIND v(dout1_494) AT=160.025n

.meas tran vdout1_495ck310 FIND v(dout1_495) AT=160.025n

.meas tran vdout1_496ck310 FIND v(dout1_496) AT=160.025n

.meas tran vdout1_497ck310 FIND v(dout1_497) AT=160.025n

.meas tran vdout1_498ck310 FIND v(dout1_498) AT=160.025n

.meas tran vdout1_499ck310 FIND v(dout1_499) AT=160.025n

.meas tran vdout1_500ck310 FIND v(dout1_500) AT=160.025n

.meas tran vdout1_501ck310 FIND v(dout1_501) AT=160.025n

.meas tran vdout1_502ck310 FIND v(dout1_502) AT=160.025n

.meas tran vdout1_503ck310 FIND v(dout1_503) AT=160.025n

.meas tran vdout1_504ck310 FIND v(dout1_504) AT=160.025n

.meas tran vdout1_505ck310 FIND v(dout1_505) AT=160.025n

.meas tran vdout1_506ck310 FIND v(dout1_506) AT=160.025n

.meas tran vdout1_507ck310 FIND v(dout1_507) AT=160.025n

.meas tran vdout1_508ck310 FIND v(dout1_508) AT=160.025n

.meas tran vdout1_509ck310 FIND v(dout1_509) AT=160.025n

.meas tran vdout1_510ck310 FIND v(dout1_510) AT=160.025n

.meas tran vdout1_511ck310 FIND v(dout1_511) AT=160.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_23ck360 FIND v(dout1_23) AT=185.025n

.meas tran vdout1_24ck360 FIND v(dout1_24) AT=185.025n

.meas tran vdout1_25ck360 FIND v(dout1_25) AT=185.025n

.meas tran vdout1_26ck360 FIND v(dout1_26) AT=185.025n

.meas tran vdout1_27ck360 FIND v(dout1_27) AT=185.025n

.meas tran vdout1_28ck360 FIND v(dout1_28) AT=185.025n

.meas tran vdout1_29ck360 FIND v(dout1_29) AT=185.025n

.meas tran vdout1_30ck360 FIND v(dout1_30) AT=185.025n

.meas tran vdout1_31ck360 FIND v(dout1_31) AT=185.025n

.meas tran vdout1_32ck360 FIND v(dout1_32) AT=185.025n

.meas tran vdout1_33ck360 FIND v(dout1_33) AT=185.025n

.meas tran vdout1_34ck360 FIND v(dout1_34) AT=185.025n

.meas tran vdout1_35ck360 FIND v(dout1_35) AT=185.025n

.meas tran vdout1_36ck360 FIND v(dout1_36) AT=185.025n

.meas tran vdout1_37ck360 FIND v(dout1_37) AT=185.025n

.meas tran vdout1_38ck360 FIND v(dout1_38) AT=185.025n

.meas tran vdout1_39ck360 FIND v(dout1_39) AT=185.025n

.meas tran vdout1_40ck360 FIND v(dout1_40) AT=185.025n

.meas tran vdout1_41ck360 FIND v(dout1_41) AT=185.025n

.meas tran vdout1_42ck360 FIND v(dout1_42) AT=185.025n

.meas tran vdout1_43ck360 FIND v(dout1_43) AT=185.025n

.meas tran vdout1_44ck360 FIND v(dout1_44) AT=185.025n

.meas tran vdout1_45ck360 FIND v(dout1_45) AT=185.025n

.meas tran vdout1_46ck360 FIND v(dout1_46) AT=185.025n

.meas tran vdout1_47ck360 FIND v(dout1_47) AT=185.025n

.meas tran vdout1_48ck360 FIND v(dout1_48) AT=185.025n

.meas tran vdout1_49ck360 FIND v(dout1_49) AT=185.025n

.meas tran vdout1_50ck360 FIND v(dout1_50) AT=185.025n

.meas tran vdout1_51ck360 FIND v(dout1_51) AT=185.025n

.meas tran vdout1_52ck360 FIND v(dout1_52) AT=185.025n

.meas tran vdout1_53ck360 FIND v(dout1_53) AT=185.025n

.meas tran vdout1_54ck360 FIND v(dout1_54) AT=185.025n

.meas tran vdout1_55ck360 FIND v(dout1_55) AT=185.025n

.meas tran vdout1_56ck360 FIND v(dout1_56) AT=185.025n

.meas tran vdout1_57ck360 FIND v(dout1_57) AT=185.025n

.meas tran vdout1_58ck360 FIND v(dout1_58) AT=185.025n

.meas tran vdout1_59ck360 FIND v(dout1_59) AT=185.025n

.meas tran vdout1_60ck360 FIND v(dout1_60) AT=185.025n

.meas tran vdout1_61ck360 FIND v(dout1_61) AT=185.025n

.meas tran vdout1_62ck360 FIND v(dout1_62) AT=185.025n

.meas tran vdout1_63ck360 FIND v(dout1_63) AT=185.025n

.meas tran vdout1_64ck360 FIND v(dout1_64) AT=185.025n

.meas tran vdout1_65ck360 FIND v(dout1_65) AT=185.025n

.meas tran vdout1_66ck360 FIND v(dout1_66) AT=185.025n

.meas tran vdout1_67ck360 FIND v(dout1_67) AT=185.025n

.meas tran vdout1_68ck360 FIND v(dout1_68) AT=185.025n

.meas tran vdout1_69ck360 FIND v(dout1_69) AT=185.025n

.meas tran vdout1_70ck360 FIND v(dout1_70) AT=185.025n

.meas tran vdout1_71ck360 FIND v(dout1_71) AT=185.025n

.meas tran vdout1_72ck360 FIND v(dout1_72) AT=185.025n

.meas tran vdout1_73ck360 FIND v(dout1_73) AT=185.025n

.meas tran vdout1_74ck360 FIND v(dout1_74) AT=185.025n

.meas tran vdout1_75ck360 FIND v(dout1_75) AT=185.025n

.meas tran vdout1_76ck360 FIND v(dout1_76) AT=185.025n

.meas tran vdout1_77ck360 FIND v(dout1_77) AT=185.025n

.meas tran vdout1_78ck360 FIND v(dout1_78) AT=185.025n

.meas tran vdout1_79ck360 FIND v(dout1_79) AT=185.025n

.meas tran vdout1_80ck360 FIND v(dout1_80) AT=185.025n

.meas tran vdout1_81ck360 FIND v(dout1_81) AT=185.025n

.meas tran vdout1_82ck360 FIND v(dout1_82) AT=185.025n

.meas tran vdout1_83ck360 FIND v(dout1_83) AT=185.025n

.meas tran vdout1_84ck360 FIND v(dout1_84) AT=185.025n

.meas tran vdout1_85ck360 FIND v(dout1_85) AT=185.025n

.meas tran vdout1_86ck360 FIND v(dout1_86) AT=185.025n

.meas tran vdout1_87ck360 FIND v(dout1_87) AT=185.025n

.meas tran vdout1_88ck360 FIND v(dout1_88) AT=185.025n

.meas tran vdout1_89ck360 FIND v(dout1_89) AT=185.025n

.meas tran vdout1_90ck360 FIND v(dout1_90) AT=185.025n

.meas tran vdout1_91ck360 FIND v(dout1_91) AT=185.025n

.meas tran vdout1_92ck360 FIND v(dout1_92) AT=185.025n

.meas tran vdout1_93ck360 FIND v(dout1_93) AT=185.025n

.meas tran vdout1_94ck360 FIND v(dout1_94) AT=185.025n

.meas tran vdout1_95ck360 FIND v(dout1_95) AT=185.025n

.meas tran vdout1_96ck360 FIND v(dout1_96) AT=185.025n

.meas tran vdout1_97ck360 FIND v(dout1_97) AT=185.025n

.meas tran vdout1_98ck360 FIND v(dout1_98) AT=185.025n

.meas tran vdout1_99ck360 FIND v(dout1_99) AT=185.025n

.meas tran vdout1_100ck360 FIND v(dout1_100) AT=185.025n

.meas tran vdout1_101ck360 FIND v(dout1_101) AT=185.025n

.meas tran vdout1_102ck360 FIND v(dout1_102) AT=185.025n

.meas tran vdout1_103ck360 FIND v(dout1_103) AT=185.025n

.meas tran vdout1_104ck360 FIND v(dout1_104) AT=185.025n

.meas tran vdout1_105ck360 FIND v(dout1_105) AT=185.025n

.meas tran vdout1_106ck360 FIND v(dout1_106) AT=185.025n

.meas tran vdout1_107ck360 FIND v(dout1_107) AT=185.025n

.meas tran vdout1_108ck360 FIND v(dout1_108) AT=185.025n

.meas tran vdout1_109ck360 FIND v(dout1_109) AT=185.025n

.meas tran vdout1_110ck360 FIND v(dout1_110) AT=185.025n

.meas tran vdout1_111ck360 FIND v(dout1_111) AT=185.025n

.meas tran vdout1_112ck360 FIND v(dout1_112) AT=185.025n

.meas tran vdout1_113ck360 FIND v(dout1_113) AT=185.025n

.meas tran vdout1_114ck360 FIND v(dout1_114) AT=185.025n

.meas tran vdout1_115ck360 FIND v(dout1_115) AT=185.025n

.meas tran vdout1_116ck360 FIND v(dout1_116) AT=185.025n

.meas tran vdout1_117ck360 FIND v(dout1_117) AT=185.025n

.meas tran vdout1_118ck360 FIND v(dout1_118) AT=185.025n

.meas tran vdout1_119ck360 FIND v(dout1_119) AT=185.025n

.meas tran vdout1_120ck360 FIND v(dout1_120) AT=185.025n

.meas tran vdout1_121ck360 FIND v(dout1_121) AT=185.025n

.meas tran vdout1_122ck360 FIND v(dout1_122) AT=185.025n

.meas tran vdout1_123ck360 FIND v(dout1_123) AT=185.025n

.meas tran vdout1_124ck360 FIND v(dout1_124) AT=185.025n

.meas tran vdout1_125ck360 FIND v(dout1_125) AT=185.025n

.meas tran vdout1_126ck360 FIND v(dout1_126) AT=185.025n

.meas tran vdout1_127ck360 FIND v(dout1_127) AT=185.025n

.meas tran vdout1_128ck360 FIND v(dout1_128) AT=185.025n

.meas tran vdout1_129ck360 FIND v(dout1_129) AT=185.025n

.meas tran vdout1_130ck360 FIND v(dout1_130) AT=185.025n

.meas tran vdout1_131ck360 FIND v(dout1_131) AT=185.025n

.meas tran vdout1_132ck360 FIND v(dout1_132) AT=185.025n

.meas tran vdout1_133ck360 FIND v(dout1_133) AT=185.025n

.meas tran vdout1_134ck360 FIND v(dout1_134) AT=185.025n

.meas tran vdout1_135ck360 FIND v(dout1_135) AT=185.025n

.meas tran vdout1_136ck360 FIND v(dout1_136) AT=185.025n

.meas tran vdout1_137ck360 FIND v(dout1_137) AT=185.025n

.meas tran vdout1_138ck360 FIND v(dout1_138) AT=185.025n

.meas tran vdout1_139ck360 FIND v(dout1_139) AT=185.025n

.meas tran vdout1_140ck360 FIND v(dout1_140) AT=185.025n

.meas tran vdout1_141ck360 FIND v(dout1_141) AT=185.025n

.meas tran vdout1_142ck360 FIND v(dout1_142) AT=185.025n

.meas tran vdout1_143ck360 FIND v(dout1_143) AT=185.025n

.meas tran vdout1_144ck360 FIND v(dout1_144) AT=185.025n

.meas tran vdout1_145ck360 FIND v(dout1_145) AT=185.025n

.meas tran vdout1_146ck360 FIND v(dout1_146) AT=185.025n

.meas tran vdout1_147ck360 FIND v(dout1_147) AT=185.025n

.meas tran vdout1_148ck360 FIND v(dout1_148) AT=185.025n

.meas tran vdout1_149ck360 FIND v(dout1_149) AT=185.025n

.meas tran vdout1_150ck360 FIND v(dout1_150) AT=185.025n

.meas tran vdout1_151ck360 FIND v(dout1_151) AT=185.025n

.meas tran vdout1_152ck360 FIND v(dout1_152) AT=185.025n

.meas tran vdout1_153ck360 FIND v(dout1_153) AT=185.025n

.meas tran vdout1_154ck360 FIND v(dout1_154) AT=185.025n

.meas tran vdout1_155ck360 FIND v(dout1_155) AT=185.025n

.meas tran vdout1_156ck360 FIND v(dout1_156) AT=185.025n

.meas tran vdout1_157ck360 FIND v(dout1_157) AT=185.025n

.meas tran vdout1_158ck360 FIND v(dout1_158) AT=185.025n

.meas tran vdout1_159ck360 FIND v(dout1_159) AT=185.025n

.meas tran vdout1_160ck360 FIND v(dout1_160) AT=185.025n

.meas tran vdout1_161ck360 FIND v(dout1_161) AT=185.025n

.meas tran vdout1_162ck360 FIND v(dout1_162) AT=185.025n

.meas tran vdout1_163ck360 FIND v(dout1_163) AT=185.025n

.meas tran vdout1_164ck360 FIND v(dout1_164) AT=185.025n

.meas tran vdout1_165ck360 FIND v(dout1_165) AT=185.025n

.meas tran vdout1_166ck360 FIND v(dout1_166) AT=185.025n

.meas tran vdout1_167ck360 FIND v(dout1_167) AT=185.025n

.meas tran vdout1_168ck360 FIND v(dout1_168) AT=185.025n

.meas tran vdout1_169ck360 FIND v(dout1_169) AT=185.025n

.meas tran vdout1_170ck360 FIND v(dout1_170) AT=185.025n

.meas tran vdout1_171ck360 FIND v(dout1_171) AT=185.025n

.meas tran vdout1_172ck360 FIND v(dout1_172) AT=185.025n

.meas tran vdout1_173ck360 FIND v(dout1_173) AT=185.025n

.meas tran vdout1_174ck360 FIND v(dout1_174) AT=185.025n

.meas tran vdout1_175ck360 FIND v(dout1_175) AT=185.025n

.meas tran vdout1_176ck360 FIND v(dout1_176) AT=185.025n

.meas tran vdout1_177ck360 FIND v(dout1_177) AT=185.025n

.meas tran vdout1_178ck360 FIND v(dout1_178) AT=185.025n

.meas tran vdout1_179ck360 FIND v(dout1_179) AT=185.025n

.meas tran vdout1_180ck360 FIND v(dout1_180) AT=185.025n

.meas tran vdout1_181ck360 FIND v(dout1_181) AT=185.025n

.meas tran vdout1_182ck360 FIND v(dout1_182) AT=185.025n

.meas tran vdout1_183ck360 FIND v(dout1_183) AT=185.025n

.meas tran vdout1_184ck360 FIND v(dout1_184) AT=185.025n

.meas tran vdout1_185ck360 FIND v(dout1_185) AT=185.025n

.meas tran vdout1_186ck360 FIND v(dout1_186) AT=185.025n

.meas tran vdout1_187ck360 FIND v(dout1_187) AT=185.025n

.meas tran vdout1_188ck360 FIND v(dout1_188) AT=185.025n

.meas tran vdout1_189ck360 FIND v(dout1_189) AT=185.025n

.meas tran vdout1_190ck360 FIND v(dout1_190) AT=185.025n

.meas tran vdout1_191ck360 FIND v(dout1_191) AT=185.025n

.meas tran vdout1_192ck360 FIND v(dout1_192) AT=185.025n

.meas tran vdout1_193ck360 FIND v(dout1_193) AT=185.025n

.meas tran vdout1_194ck360 FIND v(dout1_194) AT=185.025n

.meas tran vdout1_195ck360 FIND v(dout1_195) AT=185.025n

.meas tran vdout1_196ck360 FIND v(dout1_196) AT=185.025n

.meas tran vdout1_197ck360 FIND v(dout1_197) AT=185.025n

.meas tran vdout1_198ck360 FIND v(dout1_198) AT=185.025n

.meas tran vdout1_199ck360 FIND v(dout1_199) AT=185.025n

.meas tran vdout1_200ck360 FIND v(dout1_200) AT=185.025n

.meas tran vdout1_201ck360 FIND v(dout1_201) AT=185.025n

.meas tran vdout1_202ck360 FIND v(dout1_202) AT=185.025n

.meas tran vdout1_203ck360 FIND v(dout1_203) AT=185.025n

.meas tran vdout1_204ck360 FIND v(dout1_204) AT=185.025n

.meas tran vdout1_205ck360 FIND v(dout1_205) AT=185.025n

.meas tran vdout1_206ck360 FIND v(dout1_206) AT=185.025n

.meas tran vdout1_207ck360 FIND v(dout1_207) AT=185.025n

.meas tran vdout1_208ck360 FIND v(dout1_208) AT=185.025n

.meas tran vdout1_209ck360 FIND v(dout1_209) AT=185.025n

.meas tran vdout1_210ck360 FIND v(dout1_210) AT=185.025n

.meas tran vdout1_211ck360 FIND v(dout1_211) AT=185.025n

.meas tran vdout1_212ck360 FIND v(dout1_212) AT=185.025n

.meas tran vdout1_213ck360 FIND v(dout1_213) AT=185.025n

.meas tran vdout1_214ck360 FIND v(dout1_214) AT=185.025n

.meas tran vdout1_215ck360 FIND v(dout1_215) AT=185.025n

.meas tran vdout1_216ck360 FIND v(dout1_216) AT=185.025n

.meas tran vdout1_217ck360 FIND v(dout1_217) AT=185.025n

.meas tran vdout1_218ck360 FIND v(dout1_218) AT=185.025n

.meas tran vdout1_219ck360 FIND v(dout1_219) AT=185.025n

.meas tran vdout1_220ck360 FIND v(dout1_220) AT=185.025n

.meas tran vdout1_221ck360 FIND v(dout1_221) AT=185.025n

.meas tran vdout1_222ck360 FIND v(dout1_222) AT=185.025n

.meas tran vdout1_223ck360 FIND v(dout1_223) AT=185.025n

.meas tran vdout1_224ck360 FIND v(dout1_224) AT=185.025n

.meas tran vdout1_225ck360 FIND v(dout1_225) AT=185.025n

.meas tran vdout1_226ck360 FIND v(dout1_226) AT=185.025n

.meas tran vdout1_227ck360 FIND v(dout1_227) AT=185.025n

.meas tran vdout1_228ck360 FIND v(dout1_228) AT=185.025n

.meas tran vdout1_229ck360 FIND v(dout1_229) AT=185.025n

.meas tran vdout1_230ck360 FIND v(dout1_230) AT=185.025n

.meas tran vdout1_231ck360 FIND v(dout1_231) AT=185.025n

.meas tran vdout1_232ck360 FIND v(dout1_232) AT=185.025n

.meas tran vdout1_233ck360 FIND v(dout1_233) AT=185.025n

.meas tran vdout1_234ck360 FIND v(dout1_234) AT=185.025n

.meas tran vdout1_235ck360 FIND v(dout1_235) AT=185.025n

.meas tran vdout1_236ck360 FIND v(dout1_236) AT=185.025n

.meas tran vdout1_237ck360 FIND v(dout1_237) AT=185.025n

.meas tran vdout1_238ck360 FIND v(dout1_238) AT=185.025n

.meas tran vdout1_239ck360 FIND v(dout1_239) AT=185.025n

.meas tran vdout1_240ck360 FIND v(dout1_240) AT=185.025n

.meas tran vdout1_241ck360 FIND v(dout1_241) AT=185.025n

.meas tran vdout1_242ck360 FIND v(dout1_242) AT=185.025n

.meas tran vdout1_243ck360 FIND v(dout1_243) AT=185.025n

.meas tran vdout1_244ck360 FIND v(dout1_244) AT=185.025n

.meas tran vdout1_245ck360 FIND v(dout1_245) AT=185.025n

.meas tran vdout1_246ck360 FIND v(dout1_246) AT=185.025n

.meas tran vdout1_247ck360 FIND v(dout1_247) AT=185.025n

.meas tran vdout1_248ck360 FIND v(dout1_248) AT=185.025n

.meas tran vdout1_249ck360 FIND v(dout1_249) AT=185.025n

.meas tran vdout1_250ck360 FIND v(dout1_250) AT=185.025n

.meas tran vdout1_251ck360 FIND v(dout1_251) AT=185.025n

.meas tran vdout1_252ck360 FIND v(dout1_252) AT=185.025n

.meas tran vdout1_253ck360 FIND v(dout1_253) AT=185.025n

.meas tran vdout1_254ck360 FIND v(dout1_254) AT=185.025n

.meas tran vdout1_255ck360 FIND v(dout1_255) AT=185.025n

.meas tran vdout1_256ck360 FIND v(dout1_256) AT=185.025n

.meas tran vdout1_257ck360 FIND v(dout1_257) AT=185.025n

.meas tran vdout1_258ck360 FIND v(dout1_258) AT=185.025n

.meas tran vdout1_259ck360 FIND v(dout1_259) AT=185.025n

.meas tran vdout1_260ck360 FIND v(dout1_260) AT=185.025n

.meas tran vdout1_261ck360 FIND v(dout1_261) AT=185.025n

.meas tran vdout1_262ck360 FIND v(dout1_262) AT=185.025n

.meas tran vdout1_263ck360 FIND v(dout1_263) AT=185.025n

.meas tran vdout1_264ck360 FIND v(dout1_264) AT=185.025n

.meas tran vdout1_265ck360 FIND v(dout1_265) AT=185.025n

.meas tran vdout1_266ck360 FIND v(dout1_266) AT=185.025n

.meas tran vdout1_267ck360 FIND v(dout1_267) AT=185.025n

.meas tran vdout1_268ck360 FIND v(dout1_268) AT=185.025n

.meas tran vdout1_269ck360 FIND v(dout1_269) AT=185.025n

.meas tran vdout1_270ck360 FIND v(dout1_270) AT=185.025n

.meas tran vdout1_271ck360 FIND v(dout1_271) AT=185.025n

.meas tran vdout1_272ck360 FIND v(dout1_272) AT=185.025n

.meas tran vdout1_273ck360 FIND v(dout1_273) AT=185.025n

.meas tran vdout1_274ck360 FIND v(dout1_274) AT=185.025n

.meas tran vdout1_275ck360 FIND v(dout1_275) AT=185.025n

.meas tran vdout1_276ck360 FIND v(dout1_276) AT=185.025n

.meas tran vdout1_277ck360 FIND v(dout1_277) AT=185.025n

.meas tran vdout1_278ck360 FIND v(dout1_278) AT=185.025n

.meas tran vdout1_279ck360 FIND v(dout1_279) AT=185.025n

.meas tran vdout1_280ck360 FIND v(dout1_280) AT=185.025n

.meas tran vdout1_281ck360 FIND v(dout1_281) AT=185.025n

.meas tran vdout1_282ck360 FIND v(dout1_282) AT=185.025n

.meas tran vdout1_283ck360 FIND v(dout1_283) AT=185.025n

.meas tran vdout1_284ck360 FIND v(dout1_284) AT=185.025n

.meas tran vdout1_285ck360 FIND v(dout1_285) AT=185.025n

.meas tran vdout1_286ck360 FIND v(dout1_286) AT=185.025n

.meas tran vdout1_287ck360 FIND v(dout1_287) AT=185.025n

.meas tran vdout1_288ck360 FIND v(dout1_288) AT=185.025n

.meas tran vdout1_289ck360 FIND v(dout1_289) AT=185.025n

.meas tran vdout1_290ck360 FIND v(dout1_290) AT=185.025n

.meas tran vdout1_291ck360 FIND v(dout1_291) AT=185.025n

.meas tran vdout1_292ck360 FIND v(dout1_292) AT=185.025n

.meas tran vdout1_293ck360 FIND v(dout1_293) AT=185.025n

.meas tran vdout1_294ck360 FIND v(dout1_294) AT=185.025n

.meas tran vdout1_295ck360 FIND v(dout1_295) AT=185.025n

.meas tran vdout1_296ck360 FIND v(dout1_296) AT=185.025n

.meas tran vdout1_297ck360 FIND v(dout1_297) AT=185.025n

.meas tran vdout1_298ck360 FIND v(dout1_298) AT=185.025n

.meas tran vdout1_299ck360 FIND v(dout1_299) AT=185.025n

.meas tran vdout1_300ck360 FIND v(dout1_300) AT=185.025n

.meas tran vdout1_301ck360 FIND v(dout1_301) AT=185.025n

.meas tran vdout1_302ck360 FIND v(dout1_302) AT=185.025n

.meas tran vdout1_303ck360 FIND v(dout1_303) AT=185.025n

.meas tran vdout1_304ck360 FIND v(dout1_304) AT=185.025n

.meas tran vdout1_305ck360 FIND v(dout1_305) AT=185.025n

.meas tran vdout1_306ck360 FIND v(dout1_306) AT=185.025n

.meas tran vdout1_307ck360 FIND v(dout1_307) AT=185.025n

.meas tran vdout1_308ck360 FIND v(dout1_308) AT=185.025n

.meas tran vdout1_309ck360 FIND v(dout1_309) AT=185.025n

.meas tran vdout1_310ck360 FIND v(dout1_310) AT=185.025n

.meas tran vdout1_311ck360 FIND v(dout1_311) AT=185.025n

.meas tran vdout1_312ck360 FIND v(dout1_312) AT=185.025n

.meas tran vdout1_313ck360 FIND v(dout1_313) AT=185.025n

.meas tran vdout1_314ck360 FIND v(dout1_314) AT=185.025n

.meas tran vdout1_315ck360 FIND v(dout1_315) AT=185.025n

.meas tran vdout1_316ck360 FIND v(dout1_316) AT=185.025n

.meas tran vdout1_317ck360 FIND v(dout1_317) AT=185.025n

.meas tran vdout1_318ck360 FIND v(dout1_318) AT=185.025n

.meas tran vdout1_319ck360 FIND v(dout1_319) AT=185.025n

.meas tran vdout1_320ck360 FIND v(dout1_320) AT=185.025n

.meas tran vdout1_321ck360 FIND v(dout1_321) AT=185.025n

.meas tran vdout1_322ck360 FIND v(dout1_322) AT=185.025n

.meas tran vdout1_323ck360 FIND v(dout1_323) AT=185.025n

.meas tran vdout1_324ck360 FIND v(dout1_324) AT=185.025n

.meas tran vdout1_325ck360 FIND v(dout1_325) AT=185.025n

.meas tran vdout1_326ck360 FIND v(dout1_326) AT=185.025n

.meas tran vdout1_327ck360 FIND v(dout1_327) AT=185.025n

.meas tran vdout1_328ck360 FIND v(dout1_328) AT=185.025n

.meas tran vdout1_329ck360 FIND v(dout1_329) AT=185.025n

.meas tran vdout1_330ck360 FIND v(dout1_330) AT=185.025n

.meas tran vdout1_331ck360 FIND v(dout1_331) AT=185.025n

.meas tran vdout1_332ck360 FIND v(dout1_332) AT=185.025n

.meas tran vdout1_333ck360 FIND v(dout1_333) AT=185.025n

.meas tran vdout1_334ck360 FIND v(dout1_334) AT=185.025n

.meas tran vdout1_335ck360 FIND v(dout1_335) AT=185.025n

.meas tran vdout1_336ck360 FIND v(dout1_336) AT=185.025n

.meas tran vdout1_337ck360 FIND v(dout1_337) AT=185.025n

.meas tran vdout1_338ck360 FIND v(dout1_338) AT=185.025n

.meas tran vdout1_339ck360 FIND v(dout1_339) AT=185.025n

.meas tran vdout1_340ck360 FIND v(dout1_340) AT=185.025n

.meas tran vdout1_341ck360 FIND v(dout1_341) AT=185.025n

.meas tran vdout1_342ck360 FIND v(dout1_342) AT=185.025n

.meas tran vdout1_343ck360 FIND v(dout1_343) AT=185.025n

.meas tran vdout1_344ck360 FIND v(dout1_344) AT=185.025n

.meas tran vdout1_345ck360 FIND v(dout1_345) AT=185.025n

.meas tran vdout1_346ck360 FIND v(dout1_346) AT=185.025n

.meas tran vdout1_347ck360 FIND v(dout1_347) AT=185.025n

.meas tran vdout1_348ck360 FIND v(dout1_348) AT=185.025n

.meas tran vdout1_349ck360 FIND v(dout1_349) AT=185.025n

.meas tran vdout1_350ck360 FIND v(dout1_350) AT=185.025n

.meas tran vdout1_351ck360 FIND v(dout1_351) AT=185.025n

.meas tran vdout1_352ck360 FIND v(dout1_352) AT=185.025n

.meas tran vdout1_353ck360 FIND v(dout1_353) AT=185.025n

.meas tran vdout1_354ck360 FIND v(dout1_354) AT=185.025n

.meas tran vdout1_355ck360 FIND v(dout1_355) AT=185.025n

.meas tran vdout1_356ck360 FIND v(dout1_356) AT=185.025n

.meas tran vdout1_357ck360 FIND v(dout1_357) AT=185.025n

.meas tran vdout1_358ck360 FIND v(dout1_358) AT=185.025n

.meas tran vdout1_359ck360 FIND v(dout1_359) AT=185.025n

.meas tran vdout1_360ck360 FIND v(dout1_360) AT=185.025n

.meas tran vdout1_361ck360 FIND v(dout1_361) AT=185.025n

.meas tran vdout1_362ck360 FIND v(dout1_362) AT=185.025n

.meas tran vdout1_363ck360 FIND v(dout1_363) AT=185.025n

.meas tran vdout1_364ck360 FIND v(dout1_364) AT=185.025n

.meas tran vdout1_365ck360 FIND v(dout1_365) AT=185.025n

.meas tran vdout1_366ck360 FIND v(dout1_366) AT=185.025n

.meas tran vdout1_367ck360 FIND v(dout1_367) AT=185.025n

.meas tran vdout1_368ck360 FIND v(dout1_368) AT=185.025n

.meas tran vdout1_369ck360 FIND v(dout1_369) AT=185.025n

.meas tran vdout1_370ck360 FIND v(dout1_370) AT=185.025n

.meas tran vdout1_371ck360 FIND v(dout1_371) AT=185.025n

.meas tran vdout1_372ck360 FIND v(dout1_372) AT=185.025n

.meas tran vdout1_373ck360 FIND v(dout1_373) AT=185.025n

.meas tran vdout1_374ck360 FIND v(dout1_374) AT=185.025n

.meas tran vdout1_375ck360 FIND v(dout1_375) AT=185.025n

.meas tran vdout1_376ck360 FIND v(dout1_376) AT=185.025n

.meas tran vdout1_377ck360 FIND v(dout1_377) AT=185.025n

.meas tran vdout1_378ck360 FIND v(dout1_378) AT=185.025n

.meas tran vdout1_379ck360 FIND v(dout1_379) AT=185.025n

.meas tran vdout1_380ck360 FIND v(dout1_380) AT=185.025n

.meas tran vdout1_381ck360 FIND v(dout1_381) AT=185.025n

.meas tran vdout1_382ck360 FIND v(dout1_382) AT=185.025n

.meas tran vdout1_383ck360 FIND v(dout1_383) AT=185.025n

.meas tran vdout1_384ck360 FIND v(dout1_384) AT=185.025n

.meas tran vdout1_385ck360 FIND v(dout1_385) AT=185.025n

.meas tran vdout1_386ck360 FIND v(dout1_386) AT=185.025n

.meas tran vdout1_387ck360 FIND v(dout1_387) AT=185.025n

.meas tran vdout1_388ck360 FIND v(dout1_388) AT=185.025n

.meas tran vdout1_389ck360 FIND v(dout1_389) AT=185.025n

.meas tran vdout1_390ck360 FIND v(dout1_390) AT=185.025n

.meas tran vdout1_391ck360 FIND v(dout1_391) AT=185.025n

.meas tran vdout1_392ck360 FIND v(dout1_392) AT=185.025n

.meas tran vdout1_393ck360 FIND v(dout1_393) AT=185.025n

.meas tran vdout1_394ck360 FIND v(dout1_394) AT=185.025n

.meas tran vdout1_395ck360 FIND v(dout1_395) AT=185.025n

.meas tran vdout1_396ck360 FIND v(dout1_396) AT=185.025n

.meas tran vdout1_397ck360 FIND v(dout1_397) AT=185.025n

.meas tran vdout1_398ck360 FIND v(dout1_398) AT=185.025n

.meas tran vdout1_399ck360 FIND v(dout1_399) AT=185.025n

.meas tran vdout1_400ck360 FIND v(dout1_400) AT=185.025n

.meas tran vdout1_401ck360 FIND v(dout1_401) AT=185.025n

.meas tran vdout1_402ck360 FIND v(dout1_402) AT=185.025n

.meas tran vdout1_403ck360 FIND v(dout1_403) AT=185.025n

.meas tran vdout1_404ck360 FIND v(dout1_404) AT=185.025n

.meas tran vdout1_405ck360 FIND v(dout1_405) AT=185.025n

.meas tran vdout1_406ck360 FIND v(dout1_406) AT=185.025n

.meas tran vdout1_407ck360 FIND v(dout1_407) AT=185.025n

.meas tran vdout1_408ck360 FIND v(dout1_408) AT=185.025n

.meas tran vdout1_409ck360 FIND v(dout1_409) AT=185.025n

.meas tran vdout1_410ck360 FIND v(dout1_410) AT=185.025n

.meas tran vdout1_411ck360 FIND v(dout1_411) AT=185.025n

.meas tran vdout1_412ck360 FIND v(dout1_412) AT=185.025n

.meas tran vdout1_413ck360 FIND v(dout1_413) AT=185.025n

.meas tran vdout1_414ck360 FIND v(dout1_414) AT=185.025n

.meas tran vdout1_415ck360 FIND v(dout1_415) AT=185.025n

.meas tran vdout1_416ck360 FIND v(dout1_416) AT=185.025n

.meas tran vdout1_417ck360 FIND v(dout1_417) AT=185.025n

.meas tran vdout1_418ck360 FIND v(dout1_418) AT=185.025n

.meas tran vdout1_419ck360 FIND v(dout1_419) AT=185.025n

.meas tran vdout1_420ck360 FIND v(dout1_420) AT=185.025n

.meas tran vdout1_421ck360 FIND v(dout1_421) AT=185.025n

.meas tran vdout1_422ck360 FIND v(dout1_422) AT=185.025n

.meas tran vdout1_423ck360 FIND v(dout1_423) AT=185.025n

.meas tran vdout1_424ck360 FIND v(dout1_424) AT=185.025n

.meas tran vdout1_425ck360 FIND v(dout1_425) AT=185.025n

.meas tran vdout1_426ck360 FIND v(dout1_426) AT=185.025n

.meas tran vdout1_427ck360 FIND v(dout1_427) AT=185.025n

.meas tran vdout1_428ck360 FIND v(dout1_428) AT=185.025n

.meas tran vdout1_429ck360 FIND v(dout1_429) AT=185.025n

.meas tran vdout1_430ck360 FIND v(dout1_430) AT=185.025n

.meas tran vdout1_431ck360 FIND v(dout1_431) AT=185.025n

.meas tran vdout1_432ck360 FIND v(dout1_432) AT=185.025n

.meas tran vdout1_433ck360 FIND v(dout1_433) AT=185.025n

.meas tran vdout1_434ck360 FIND v(dout1_434) AT=185.025n

.meas tran vdout1_435ck360 FIND v(dout1_435) AT=185.025n

.meas tran vdout1_436ck360 FIND v(dout1_436) AT=185.025n

.meas tran vdout1_437ck360 FIND v(dout1_437) AT=185.025n

.meas tran vdout1_438ck360 FIND v(dout1_438) AT=185.025n

.meas tran vdout1_439ck360 FIND v(dout1_439) AT=185.025n

.meas tran vdout1_440ck360 FIND v(dout1_440) AT=185.025n

.meas tran vdout1_441ck360 FIND v(dout1_441) AT=185.025n

.meas tran vdout1_442ck360 FIND v(dout1_442) AT=185.025n

.meas tran vdout1_443ck360 FIND v(dout1_443) AT=185.025n

.meas tran vdout1_444ck360 FIND v(dout1_444) AT=185.025n

.meas tran vdout1_445ck360 FIND v(dout1_445) AT=185.025n

.meas tran vdout1_446ck360 FIND v(dout1_446) AT=185.025n

.meas tran vdout1_447ck360 FIND v(dout1_447) AT=185.025n

.meas tran vdout1_448ck360 FIND v(dout1_448) AT=185.025n

.meas tran vdout1_449ck360 FIND v(dout1_449) AT=185.025n

.meas tran vdout1_450ck360 FIND v(dout1_450) AT=185.025n

.meas tran vdout1_451ck360 FIND v(dout1_451) AT=185.025n

.meas tran vdout1_452ck360 FIND v(dout1_452) AT=185.025n

.meas tran vdout1_453ck360 FIND v(dout1_453) AT=185.025n

.meas tran vdout1_454ck360 FIND v(dout1_454) AT=185.025n

.meas tran vdout1_455ck360 FIND v(dout1_455) AT=185.025n

.meas tran vdout1_456ck360 FIND v(dout1_456) AT=185.025n

.meas tran vdout1_457ck360 FIND v(dout1_457) AT=185.025n

.meas tran vdout1_458ck360 FIND v(dout1_458) AT=185.025n

.meas tran vdout1_459ck360 FIND v(dout1_459) AT=185.025n

.meas tran vdout1_460ck360 FIND v(dout1_460) AT=185.025n

.meas tran vdout1_461ck360 FIND v(dout1_461) AT=185.025n

.meas tran vdout1_462ck360 FIND v(dout1_462) AT=185.025n

.meas tran vdout1_463ck360 FIND v(dout1_463) AT=185.025n

.meas tran vdout1_464ck360 FIND v(dout1_464) AT=185.025n

.meas tran vdout1_465ck360 FIND v(dout1_465) AT=185.025n

.meas tran vdout1_466ck360 FIND v(dout1_466) AT=185.025n

.meas tran vdout1_467ck360 FIND v(dout1_467) AT=185.025n

.meas tran vdout1_468ck360 FIND v(dout1_468) AT=185.025n

.meas tran vdout1_469ck360 FIND v(dout1_469) AT=185.025n

.meas tran vdout1_470ck360 FIND v(dout1_470) AT=185.025n

.meas tran vdout1_471ck360 FIND v(dout1_471) AT=185.025n

.meas tran vdout1_472ck360 FIND v(dout1_472) AT=185.025n

.meas tran vdout1_473ck360 FIND v(dout1_473) AT=185.025n

.meas tran vdout1_474ck360 FIND v(dout1_474) AT=185.025n

.meas tran vdout1_475ck360 FIND v(dout1_475) AT=185.025n

.meas tran vdout1_476ck360 FIND v(dout1_476) AT=185.025n

.meas tran vdout1_477ck360 FIND v(dout1_477) AT=185.025n

.meas tran vdout1_478ck360 FIND v(dout1_478) AT=185.025n

.meas tran vdout1_479ck360 FIND v(dout1_479) AT=185.025n

.meas tran vdout1_480ck360 FIND v(dout1_480) AT=185.025n

.meas tran vdout1_481ck360 FIND v(dout1_481) AT=185.025n

.meas tran vdout1_482ck360 FIND v(dout1_482) AT=185.025n

.meas tran vdout1_483ck360 FIND v(dout1_483) AT=185.025n

.meas tran vdout1_484ck360 FIND v(dout1_484) AT=185.025n

.meas tran vdout1_485ck360 FIND v(dout1_485) AT=185.025n

.meas tran vdout1_486ck360 FIND v(dout1_486) AT=185.025n

.meas tran vdout1_487ck360 FIND v(dout1_487) AT=185.025n

.meas tran vdout1_488ck360 FIND v(dout1_488) AT=185.025n

.meas tran vdout1_489ck360 FIND v(dout1_489) AT=185.025n

.meas tran vdout1_490ck360 FIND v(dout1_490) AT=185.025n

.meas tran vdout1_491ck360 FIND v(dout1_491) AT=185.025n

.meas tran vdout1_492ck360 FIND v(dout1_492) AT=185.025n

.meas tran vdout1_493ck360 FIND v(dout1_493) AT=185.025n

.meas tran vdout1_494ck360 FIND v(dout1_494) AT=185.025n

.meas tran vdout1_495ck360 FIND v(dout1_495) AT=185.025n

.meas tran vdout1_496ck360 FIND v(dout1_496) AT=185.025n

.meas tran vdout1_497ck360 FIND v(dout1_497) AT=185.025n

.meas tran vdout1_498ck360 FIND v(dout1_498) AT=185.025n

.meas tran vdout1_499ck360 FIND v(dout1_499) AT=185.025n

.meas tran vdout1_500ck360 FIND v(dout1_500) AT=185.025n

.meas tran vdout1_501ck360 FIND v(dout1_501) AT=185.025n

.meas tran vdout1_502ck360 FIND v(dout1_502) AT=185.025n

.meas tran vdout1_503ck360 FIND v(dout1_503) AT=185.025n

.meas tran vdout1_504ck360 FIND v(dout1_504) AT=185.025n

.meas tran vdout1_505ck360 FIND v(dout1_505) AT=185.025n

.meas tran vdout1_506ck360 FIND v(dout1_506) AT=185.025n

.meas tran vdout1_507ck360 FIND v(dout1_507) AT=185.025n

.meas tran vdout1_508ck360 FIND v(dout1_508) AT=185.025n

.meas tran vdout1_509ck360 FIND v(dout1_509) AT=185.025n

.meas tran vdout1_510ck360 FIND v(dout1_510) AT=185.025n

.meas tran vdout1_511ck360 FIND v(dout1_511) AT=185.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_19ck400 FIND v(dout1_19) AT=205.025n

.meas tran vdout1_20ck400 FIND v(dout1_20) AT=205.025n

.meas tran vdout1_21ck400 FIND v(dout1_21) AT=205.025n

.meas tran vdout1_22ck400 FIND v(dout1_22) AT=205.025n

.meas tran vdout1_23ck400 FIND v(dout1_23) AT=205.025n

.meas tran vdout1_24ck400 FIND v(dout1_24) AT=205.025n

.meas tran vdout1_25ck400 FIND v(dout1_25) AT=205.025n

.meas tran vdout1_26ck400 FIND v(dout1_26) AT=205.025n

.meas tran vdout1_27ck400 FIND v(dout1_27) AT=205.025n

.meas tran vdout1_28ck400 FIND v(dout1_28) AT=205.025n

.meas tran vdout1_29ck400 FIND v(dout1_29) AT=205.025n

.meas tran vdout1_30ck400 FIND v(dout1_30) AT=205.025n

.meas tran vdout1_31ck400 FIND v(dout1_31) AT=205.025n

.meas tran vdout1_32ck400 FIND v(dout1_32) AT=205.025n

.meas tran vdout1_33ck400 FIND v(dout1_33) AT=205.025n

.meas tran vdout1_34ck400 FIND v(dout1_34) AT=205.025n

.meas tran vdout1_35ck400 FIND v(dout1_35) AT=205.025n

.meas tran vdout1_36ck400 FIND v(dout1_36) AT=205.025n

.meas tran vdout1_37ck400 FIND v(dout1_37) AT=205.025n

.meas tran vdout1_38ck400 FIND v(dout1_38) AT=205.025n

.meas tran vdout1_39ck400 FIND v(dout1_39) AT=205.025n

.meas tran vdout1_40ck400 FIND v(dout1_40) AT=205.025n

.meas tran vdout1_41ck400 FIND v(dout1_41) AT=205.025n

.meas tran vdout1_42ck400 FIND v(dout1_42) AT=205.025n

.meas tran vdout1_43ck400 FIND v(dout1_43) AT=205.025n

.meas tran vdout1_44ck400 FIND v(dout1_44) AT=205.025n

.meas tran vdout1_45ck400 FIND v(dout1_45) AT=205.025n

.meas tran vdout1_46ck400 FIND v(dout1_46) AT=205.025n

.meas tran vdout1_47ck400 FIND v(dout1_47) AT=205.025n

.meas tran vdout1_48ck400 FIND v(dout1_48) AT=205.025n

.meas tran vdout1_49ck400 FIND v(dout1_49) AT=205.025n

.meas tran vdout1_50ck400 FIND v(dout1_50) AT=205.025n

.meas tran vdout1_51ck400 FIND v(dout1_51) AT=205.025n

.meas tran vdout1_52ck400 FIND v(dout1_52) AT=205.025n

.meas tran vdout1_53ck400 FIND v(dout1_53) AT=205.025n

.meas tran vdout1_54ck400 FIND v(dout1_54) AT=205.025n

.meas tran vdout1_55ck400 FIND v(dout1_55) AT=205.025n

.meas tran vdout1_56ck400 FIND v(dout1_56) AT=205.025n

.meas tran vdout1_57ck400 FIND v(dout1_57) AT=205.025n

.meas tran vdout1_58ck400 FIND v(dout1_58) AT=205.025n

.meas tran vdout1_59ck400 FIND v(dout1_59) AT=205.025n

.meas tran vdout1_60ck400 FIND v(dout1_60) AT=205.025n

.meas tran vdout1_61ck400 FIND v(dout1_61) AT=205.025n

.meas tran vdout1_62ck400 FIND v(dout1_62) AT=205.025n

.meas tran vdout1_63ck400 FIND v(dout1_63) AT=205.025n

.meas tran vdout1_64ck400 FIND v(dout1_64) AT=205.025n

.meas tran vdout1_65ck400 FIND v(dout1_65) AT=205.025n

.meas tran vdout1_66ck400 FIND v(dout1_66) AT=205.025n

.meas tran vdout1_67ck400 FIND v(dout1_67) AT=205.025n

.meas tran vdout1_68ck400 FIND v(dout1_68) AT=205.025n

.meas tran vdout1_69ck400 FIND v(dout1_69) AT=205.025n

.meas tran vdout1_70ck400 FIND v(dout1_70) AT=205.025n

.meas tran vdout1_71ck400 FIND v(dout1_71) AT=205.025n

.meas tran vdout1_72ck400 FIND v(dout1_72) AT=205.025n

.meas tran vdout1_73ck400 FIND v(dout1_73) AT=205.025n

.meas tran vdout1_74ck400 FIND v(dout1_74) AT=205.025n

.meas tran vdout1_75ck400 FIND v(dout1_75) AT=205.025n

.meas tran vdout1_76ck400 FIND v(dout1_76) AT=205.025n

.meas tran vdout1_77ck400 FIND v(dout1_77) AT=205.025n

.meas tran vdout1_78ck400 FIND v(dout1_78) AT=205.025n

.meas tran vdout1_79ck400 FIND v(dout1_79) AT=205.025n

.meas tran vdout1_80ck400 FIND v(dout1_80) AT=205.025n

.meas tran vdout1_81ck400 FIND v(dout1_81) AT=205.025n

.meas tran vdout1_82ck400 FIND v(dout1_82) AT=205.025n

.meas tran vdout1_83ck400 FIND v(dout1_83) AT=205.025n

.meas tran vdout1_84ck400 FIND v(dout1_84) AT=205.025n

.meas tran vdout1_85ck400 FIND v(dout1_85) AT=205.025n

.meas tran vdout1_86ck400 FIND v(dout1_86) AT=205.025n

.meas tran vdout1_87ck400 FIND v(dout1_87) AT=205.025n

.meas tran vdout1_88ck400 FIND v(dout1_88) AT=205.025n

.meas tran vdout1_89ck400 FIND v(dout1_89) AT=205.025n

.meas tran vdout1_90ck400 FIND v(dout1_90) AT=205.025n

.meas tran vdout1_91ck400 FIND v(dout1_91) AT=205.025n

.meas tran vdout1_92ck400 FIND v(dout1_92) AT=205.025n

.meas tran vdout1_93ck400 FIND v(dout1_93) AT=205.025n

.meas tran vdout1_94ck400 FIND v(dout1_94) AT=205.025n

.meas tran vdout1_95ck400 FIND v(dout1_95) AT=205.025n

.meas tran vdout1_96ck400 FIND v(dout1_96) AT=205.025n

.meas tran vdout1_97ck400 FIND v(dout1_97) AT=205.025n

.meas tran vdout1_98ck400 FIND v(dout1_98) AT=205.025n

.meas tran vdout1_99ck400 FIND v(dout1_99) AT=205.025n

.meas tran vdout1_100ck400 FIND v(dout1_100) AT=205.025n

.meas tran vdout1_101ck400 FIND v(dout1_101) AT=205.025n

.meas tran vdout1_102ck400 FIND v(dout1_102) AT=205.025n

.meas tran vdout1_103ck400 FIND v(dout1_103) AT=205.025n

.meas tran vdout1_104ck400 FIND v(dout1_104) AT=205.025n

.meas tran vdout1_105ck400 FIND v(dout1_105) AT=205.025n

.meas tran vdout1_106ck400 FIND v(dout1_106) AT=205.025n

.meas tran vdout1_107ck400 FIND v(dout1_107) AT=205.025n

.meas tran vdout1_108ck400 FIND v(dout1_108) AT=205.025n

.meas tran vdout1_109ck400 FIND v(dout1_109) AT=205.025n

.meas tran vdout1_110ck400 FIND v(dout1_110) AT=205.025n

.meas tran vdout1_111ck400 FIND v(dout1_111) AT=205.025n

.meas tran vdout1_112ck400 FIND v(dout1_112) AT=205.025n

.meas tran vdout1_113ck400 FIND v(dout1_113) AT=205.025n

.meas tran vdout1_114ck400 FIND v(dout1_114) AT=205.025n

.meas tran vdout1_115ck400 FIND v(dout1_115) AT=205.025n

.meas tran vdout1_116ck400 FIND v(dout1_116) AT=205.025n

.meas tran vdout1_117ck400 FIND v(dout1_117) AT=205.025n

.meas tran vdout1_118ck400 FIND v(dout1_118) AT=205.025n

.meas tran vdout1_119ck400 FIND v(dout1_119) AT=205.025n

.meas tran vdout1_120ck400 FIND v(dout1_120) AT=205.025n

.meas tran vdout1_121ck400 FIND v(dout1_121) AT=205.025n

.meas tran vdout1_122ck400 FIND v(dout1_122) AT=205.025n

.meas tran vdout1_123ck400 FIND v(dout1_123) AT=205.025n

.meas tran vdout1_124ck400 FIND v(dout1_124) AT=205.025n

.meas tran vdout1_125ck400 FIND v(dout1_125) AT=205.025n

.meas tran vdout1_126ck400 FIND v(dout1_126) AT=205.025n

.meas tran vdout1_127ck400 FIND v(dout1_127) AT=205.025n

.meas tran vdout1_128ck400 FIND v(dout1_128) AT=205.025n

.meas tran vdout1_129ck400 FIND v(dout1_129) AT=205.025n

.meas tran vdout1_130ck400 FIND v(dout1_130) AT=205.025n

.meas tran vdout1_131ck400 FIND v(dout1_131) AT=205.025n

.meas tran vdout1_132ck400 FIND v(dout1_132) AT=205.025n

.meas tran vdout1_133ck400 FIND v(dout1_133) AT=205.025n

.meas tran vdout1_134ck400 FIND v(dout1_134) AT=205.025n

.meas tran vdout1_135ck400 FIND v(dout1_135) AT=205.025n

.meas tran vdout1_136ck400 FIND v(dout1_136) AT=205.025n

.meas tran vdout1_137ck400 FIND v(dout1_137) AT=205.025n

.meas tran vdout1_138ck400 FIND v(dout1_138) AT=205.025n

.meas tran vdout1_139ck400 FIND v(dout1_139) AT=205.025n

.meas tran vdout1_140ck400 FIND v(dout1_140) AT=205.025n

.meas tran vdout1_141ck400 FIND v(dout1_141) AT=205.025n

.meas tran vdout1_142ck400 FIND v(dout1_142) AT=205.025n

.meas tran vdout1_143ck400 FIND v(dout1_143) AT=205.025n

.meas tran vdout1_144ck400 FIND v(dout1_144) AT=205.025n

.meas tran vdout1_145ck400 FIND v(dout1_145) AT=205.025n

.meas tran vdout1_146ck400 FIND v(dout1_146) AT=205.025n

.meas tran vdout1_147ck400 FIND v(dout1_147) AT=205.025n

.meas tran vdout1_148ck400 FIND v(dout1_148) AT=205.025n

.meas tran vdout1_149ck400 FIND v(dout1_149) AT=205.025n

.meas tran vdout1_150ck400 FIND v(dout1_150) AT=205.025n

.meas tran vdout1_151ck400 FIND v(dout1_151) AT=205.025n

.meas tran vdout1_152ck400 FIND v(dout1_152) AT=205.025n

.meas tran vdout1_153ck400 FIND v(dout1_153) AT=205.025n

.meas tran vdout1_154ck400 FIND v(dout1_154) AT=205.025n

.meas tran vdout1_155ck400 FIND v(dout1_155) AT=205.025n

.meas tran vdout1_156ck400 FIND v(dout1_156) AT=205.025n

.meas tran vdout1_157ck400 FIND v(dout1_157) AT=205.025n

.meas tran vdout1_158ck400 FIND v(dout1_158) AT=205.025n

.meas tran vdout1_159ck400 FIND v(dout1_159) AT=205.025n

.meas tran vdout1_160ck400 FIND v(dout1_160) AT=205.025n

.meas tran vdout1_161ck400 FIND v(dout1_161) AT=205.025n

.meas tran vdout1_162ck400 FIND v(dout1_162) AT=205.025n

.meas tran vdout1_163ck400 FIND v(dout1_163) AT=205.025n

.meas tran vdout1_164ck400 FIND v(dout1_164) AT=205.025n

.meas tran vdout1_165ck400 FIND v(dout1_165) AT=205.025n

.meas tran vdout1_166ck400 FIND v(dout1_166) AT=205.025n

.meas tran vdout1_167ck400 FIND v(dout1_167) AT=205.025n

.meas tran vdout1_168ck400 FIND v(dout1_168) AT=205.025n

.meas tran vdout1_169ck400 FIND v(dout1_169) AT=205.025n

.meas tran vdout1_170ck400 FIND v(dout1_170) AT=205.025n

.meas tran vdout1_171ck400 FIND v(dout1_171) AT=205.025n

.meas tran vdout1_172ck400 FIND v(dout1_172) AT=205.025n

.meas tran vdout1_173ck400 FIND v(dout1_173) AT=205.025n

.meas tran vdout1_174ck400 FIND v(dout1_174) AT=205.025n

.meas tran vdout1_175ck400 FIND v(dout1_175) AT=205.025n

.meas tran vdout1_176ck400 FIND v(dout1_176) AT=205.025n

.meas tran vdout1_177ck400 FIND v(dout1_177) AT=205.025n

.meas tran vdout1_178ck400 FIND v(dout1_178) AT=205.025n

.meas tran vdout1_179ck400 FIND v(dout1_179) AT=205.025n

.meas tran vdout1_180ck400 FIND v(dout1_180) AT=205.025n

.meas tran vdout1_181ck400 FIND v(dout1_181) AT=205.025n

.meas tran vdout1_182ck400 FIND v(dout1_182) AT=205.025n

.meas tran vdout1_183ck400 FIND v(dout1_183) AT=205.025n

.meas tran vdout1_184ck400 FIND v(dout1_184) AT=205.025n

.meas tran vdout1_185ck400 FIND v(dout1_185) AT=205.025n

.meas tran vdout1_186ck400 FIND v(dout1_186) AT=205.025n

.meas tran vdout1_187ck400 FIND v(dout1_187) AT=205.025n

.meas tran vdout1_188ck400 FIND v(dout1_188) AT=205.025n

.meas tran vdout1_189ck400 FIND v(dout1_189) AT=205.025n

.meas tran vdout1_190ck400 FIND v(dout1_190) AT=205.025n

.meas tran vdout1_191ck400 FIND v(dout1_191) AT=205.025n

.meas tran vdout1_192ck400 FIND v(dout1_192) AT=205.025n

.meas tran vdout1_193ck400 FIND v(dout1_193) AT=205.025n

.meas tran vdout1_194ck400 FIND v(dout1_194) AT=205.025n

.meas tran vdout1_195ck400 FIND v(dout1_195) AT=205.025n

.meas tran vdout1_196ck400 FIND v(dout1_196) AT=205.025n

.meas tran vdout1_197ck400 FIND v(dout1_197) AT=205.025n

.meas tran vdout1_198ck400 FIND v(dout1_198) AT=205.025n

.meas tran vdout1_199ck400 FIND v(dout1_199) AT=205.025n

.meas tran vdout1_200ck400 FIND v(dout1_200) AT=205.025n

.meas tran vdout1_201ck400 FIND v(dout1_201) AT=205.025n

.meas tran vdout1_202ck400 FIND v(dout1_202) AT=205.025n

.meas tran vdout1_203ck400 FIND v(dout1_203) AT=205.025n

.meas tran vdout1_204ck400 FIND v(dout1_204) AT=205.025n

.meas tran vdout1_205ck400 FIND v(dout1_205) AT=205.025n

.meas tran vdout1_206ck400 FIND v(dout1_206) AT=205.025n

.meas tran vdout1_207ck400 FIND v(dout1_207) AT=205.025n

.meas tran vdout1_208ck400 FIND v(dout1_208) AT=205.025n

.meas tran vdout1_209ck400 FIND v(dout1_209) AT=205.025n

.meas tran vdout1_210ck400 FIND v(dout1_210) AT=205.025n

.meas tran vdout1_211ck400 FIND v(dout1_211) AT=205.025n

.meas tran vdout1_212ck400 FIND v(dout1_212) AT=205.025n

.meas tran vdout1_213ck400 FIND v(dout1_213) AT=205.025n

.meas tran vdout1_214ck400 FIND v(dout1_214) AT=205.025n

.meas tran vdout1_215ck400 FIND v(dout1_215) AT=205.025n

.meas tran vdout1_216ck400 FIND v(dout1_216) AT=205.025n

.meas tran vdout1_217ck400 FIND v(dout1_217) AT=205.025n

.meas tran vdout1_218ck400 FIND v(dout1_218) AT=205.025n

.meas tran vdout1_219ck400 FIND v(dout1_219) AT=205.025n

.meas tran vdout1_220ck400 FIND v(dout1_220) AT=205.025n

.meas tran vdout1_221ck400 FIND v(dout1_221) AT=205.025n

.meas tran vdout1_222ck400 FIND v(dout1_222) AT=205.025n

.meas tran vdout1_223ck400 FIND v(dout1_223) AT=205.025n

.meas tran vdout1_224ck400 FIND v(dout1_224) AT=205.025n

.meas tran vdout1_225ck400 FIND v(dout1_225) AT=205.025n

.meas tran vdout1_226ck400 FIND v(dout1_226) AT=205.025n

.meas tran vdout1_227ck400 FIND v(dout1_227) AT=205.025n

.meas tran vdout1_228ck400 FIND v(dout1_228) AT=205.025n

.meas tran vdout1_229ck400 FIND v(dout1_229) AT=205.025n

.meas tran vdout1_230ck400 FIND v(dout1_230) AT=205.025n

.meas tran vdout1_231ck400 FIND v(dout1_231) AT=205.025n

.meas tran vdout1_232ck400 FIND v(dout1_232) AT=205.025n

.meas tran vdout1_233ck400 FIND v(dout1_233) AT=205.025n

.meas tran vdout1_234ck400 FIND v(dout1_234) AT=205.025n

.meas tran vdout1_235ck400 FIND v(dout1_235) AT=205.025n

.meas tran vdout1_236ck400 FIND v(dout1_236) AT=205.025n

.meas tran vdout1_237ck400 FIND v(dout1_237) AT=205.025n

.meas tran vdout1_238ck400 FIND v(dout1_238) AT=205.025n

.meas tran vdout1_239ck400 FIND v(dout1_239) AT=205.025n

.meas tran vdout1_240ck400 FIND v(dout1_240) AT=205.025n

.meas tran vdout1_241ck400 FIND v(dout1_241) AT=205.025n

.meas tran vdout1_242ck400 FIND v(dout1_242) AT=205.025n

.meas tran vdout1_243ck400 FIND v(dout1_243) AT=205.025n

.meas tran vdout1_244ck400 FIND v(dout1_244) AT=205.025n

.meas tran vdout1_245ck400 FIND v(dout1_245) AT=205.025n

.meas tran vdout1_246ck400 FIND v(dout1_246) AT=205.025n

.meas tran vdout1_247ck400 FIND v(dout1_247) AT=205.025n

.meas tran vdout1_248ck400 FIND v(dout1_248) AT=205.025n

.meas tran vdout1_249ck400 FIND v(dout1_249) AT=205.025n

.meas tran vdout1_250ck400 FIND v(dout1_250) AT=205.025n

.meas tran vdout1_251ck400 FIND v(dout1_251) AT=205.025n

.meas tran vdout1_252ck400 FIND v(dout1_252) AT=205.025n

.meas tran vdout1_253ck400 FIND v(dout1_253) AT=205.025n

.meas tran vdout1_254ck400 FIND v(dout1_254) AT=205.025n

.meas tran vdout1_255ck400 FIND v(dout1_255) AT=205.025n

.meas tran vdout1_256ck400 FIND v(dout1_256) AT=205.025n

.meas tran vdout1_257ck400 FIND v(dout1_257) AT=205.025n

.meas tran vdout1_258ck400 FIND v(dout1_258) AT=205.025n

.meas tran vdout1_259ck400 FIND v(dout1_259) AT=205.025n

.meas tran vdout1_260ck400 FIND v(dout1_260) AT=205.025n

.meas tran vdout1_261ck400 FIND v(dout1_261) AT=205.025n

.meas tran vdout1_262ck400 FIND v(dout1_262) AT=205.025n

.meas tran vdout1_263ck400 FIND v(dout1_263) AT=205.025n

.meas tran vdout1_264ck400 FIND v(dout1_264) AT=205.025n

.meas tran vdout1_265ck400 FIND v(dout1_265) AT=205.025n

.meas tran vdout1_266ck400 FIND v(dout1_266) AT=205.025n

.meas tran vdout1_267ck400 FIND v(dout1_267) AT=205.025n

.meas tran vdout1_268ck400 FIND v(dout1_268) AT=205.025n

.meas tran vdout1_269ck400 FIND v(dout1_269) AT=205.025n

.meas tran vdout1_270ck400 FIND v(dout1_270) AT=205.025n

.meas tran vdout1_271ck400 FIND v(dout1_271) AT=205.025n

.meas tran vdout1_272ck400 FIND v(dout1_272) AT=205.025n

.meas tran vdout1_273ck400 FIND v(dout1_273) AT=205.025n

.meas tran vdout1_274ck400 FIND v(dout1_274) AT=205.025n

.meas tran vdout1_275ck400 FIND v(dout1_275) AT=205.025n

.meas tran vdout1_276ck400 FIND v(dout1_276) AT=205.025n

.meas tran vdout1_277ck400 FIND v(dout1_277) AT=205.025n

.meas tran vdout1_278ck400 FIND v(dout1_278) AT=205.025n

.meas tran vdout1_279ck400 FIND v(dout1_279) AT=205.025n

.meas tran vdout1_280ck400 FIND v(dout1_280) AT=205.025n

.meas tran vdout1_281ck400 FIND v(dout1_281) AT=205.025n

.meas tran vdout1_282ck400 FIND v(dout1_282) AT=205.025n

.meas tran vdout1_283ck400 FIND v(dout1_283) AT=205.025n

.meas tran vdout1_284ck400 FIND v(dout1_284) AT=205.025n

.meas tran vdout1_285ck400 FIND v(dout1_285) AT=205.025n

.meas tran vdout1_286ck400 FIND v(dout1_286) AT=205.025n

.meas tran vdout1_287ck400 FIND v(dout1_287) AT=205.025n

.meas tran vdout1_288ck400 FIND v(dout1_288) AT=205.025n

.meas tran vdout1_289ck400 FIND v(dout1_289) AT=205.025n

.meas tran vdout1_290ck400 FIND v(dout1_290) AT=205.025n

.meas tran vdout1_291ck400 FIND v(dout1_291) AT=205.025n

.meas tran vdout1_292ck400 FIND v(dout1_292) AT=205.025n

.meas tran vdout1_293ck400 FIND v(dout1_293) AT=205.025n

.meas tran vdout1_294ck400 FIND v(dout1_294) AT=205.025n

.meas tran vdout1_295ck400 FIND v(dout1_295) AT=205.025n

.meas tran vdout1_296ck400 FIND v(dout1_296) AT=205.025n

.meas tran vdout1_297ck400 FIND v(dout1_297) AT=205.025n

.meas tran vdout1_298ck400 FIND v(dout1_298) AT=205.025n

.meas tran vdout1_299ck400 FIND v(dout1_299) AT=205.025n

.meas tran vdout1_300ck400 FIND v(dout1_300) AT=205.025n

.meas tran vdout1_301ck400 FIND v(dout1_301) AT=205.025n

.meas tran vdout1_302ck400 FIND v(dout1_302) AT=205.025n

.meas tran vdout1_303ck400 FIND v(dout1_303) AT=205.025n

.meas tran vdout1_304ck400 FIND v(dout1_304) AT=205.025n

.meas tran vdout1_305ck400 FIND v(dout1_305) AT=205.025n

.meas tran vdout1_306ck400 FIND v(dout1_306) AT=205.025n

.meas tran vdout1_307ck400 FIND v(dout1_307) AT=205.025n

.meas tran vdout1_308ck400 FIND v(dout1_308) AT=205.025n

.meas tran vdout1_309ck400 FIND v(dout1_309) AT=205.025n

.meas tran vdout1_310ck400 FIND v(dout1_310) AT=205.025n

.meas tran vdout1_311ck400 FIND v(dout1_311) AT=205.025n

.meas tran vdout1_312ck400 FIND v(dout1_312) AT=205.025n

.meas tran vdout1_313ck400 FIND v(dout1_313) AT=205.025n

.meas tran vdout1_314ck400 FIND v(dout1_314) AT=205.025n

.meas tran vdout1_315ck400 FIND v(dout1_315) AT=205.025n

.meas tran vdout1_316ck400 FIND v(dout1_316) AT=205.025n

.meas tran vdout1_317ck400 FIND v(dout1_317) AT=205.025n

.meas tran vdout1_318ck400 FIND v(dout1_318) AT=205.025n

.meas tran vdout1_319ck400 FIND v(dout1_319) AT=205.025n

.meas tran vdout1_320ck400 FIND v(dout1_320) AT=205.025n

.meas tran vdout1_321ck400 FIND v(dout1_321) AT=205.025n

.meas tran vdout1_322ck400 FIND v(dout1_322) AT=205.025n

.meas tran vdout1_323ck400 FIND v(dout1_323) AT=205.025n

.meas tran vdout1_324ck400 FIND v(dout1_324) AT=205.025n

.meas tran vdout1_325ck400 FIND v(dout1_325) AT=205.025n

.meas tran vdout1_326ck400 FIND v(dout1_326) AT=205.025n

.meas tran vdout1_327ck400 FIND v(dout1_327) AT=205.025n

.meas tran vdout1_328ck400 FIND v(dout1_328) AT=205.025n

.meas tran vdout1_329ck400 FIND v(dout1_329) AT=205.025n

.meas tran vdout1_330ck400 FIND v(dout1_330) AT=205.025n

.meas tran vdout1_331ck400 FIND v(dout1_331) AT=205.025n

.meas tran vdout1_332ck400 FIND v(dout1_332) AT=205.025n

.meas tran vdout1_333ck400 FIND v(dout1_333) AT=205.025n

.meas tran vdout1_334ck400 FIND v(dout1_334) AT=205.025n

.meas tran vdout1_335ck400 FIND v(dout1_335) AT=205.025n

.meas tran vdout1_336ck400 FIND v(dout1_336) AT=205.025n

.meas tran vdout1_337ck400 FIND v(dout1_337) AT=205.025n

.meas tran vdout1_338ck400 FIND v(dout1_338) AT=205.025n

.meas tran vdout1_339ck400 FIND v(dout1_339) AT=205.025n

.meas tran vdout1_340ck400 FIND v(dout1_340) AT=205.025n

.meas tran vdout1_341ck400 FIND v(dout1_341) AT=205.025n

.meas tran vdout1_342ck400 FIND v(dout1_342) AT=205.025n

.meas tran vdout1_343ck400 FIND v(dout1_343) AT=205.025n

.meas tran vdout1_344ck400 FIND v(dout1_344) AT=205.025n

.meas tran vdout1_345ck400 FIND v(dout1_345) AT=205.025n

.meas tran vdout1_346ck400 FIND v(dout1_346) AT=205.025n

.meas tran vdout1_347ck400 FIND v(dout1_347) AT=205.025n

.meas tran vdout1_348ck400 FIND v(dout1_348) AT=205.025n

.meas tran vdout1_349ck400 FIND v(dout1_349) AT=205.025n

.meas tran vdout1_350ck400 FIND v(dout1_350) AT=205.025n

.meas tran vdout1_351ck400 FIND v(dout1_351) AT=205.025n

.meas tran vdout1_352ck400 FIND v(dout1_352) AT=205.025n

.meas tran vdout1_353ck400 FIND v(dout1_353) AT=205.025n

.meas tran vdout1_354ck400 FIND v(dout1_354) AT=205.025n

.meas tran vdout1_355ck400 FIND v(dout1_355) AT=205.025n

.meas tran vdout1_356ck400 FIND v(dout1_356) AT=205.025n

.meas tran vdout1_357ck400 FIND v(dout1_357) AT=205.025n

.meas tran vdout1_358ck400 FIND v(dout1_358) AT=205.025n

.meas tran vdout1_359ck400 FIND v(dout1_359) AT=205.025n

.meas tran vdout1_360ck400 FIND v(dout1_360) AT=205.025n

.meas tran vdout1_361ck400 FIND v(dout1_361) AT=205.025n

.meas tran vdout1_362ck400 FIND v(dout1_362) AT=205.025n

.meas tran vdout1_363ck400 FIND v(dout1_363) AT=205.025n

.meas tran vdout1_364ck400 FIND v(dout1_364) AT=205.025n

.meas tran vdout1_365ck400 FIND v(dout1_365) AT=205.025n

.meas tran vdout1_366ck400 FIND v(dout1_366) AT=205.025n

.meas tran vdout1_367ck400 FIND v(dout1_367) AT=205.025n

.meas tran vdout1_368ck400 FIND v(dout1_368) AT=205.025n

.meas tran vdout1_369ck400 FIND v(dout1_369) AT=205.025n

.meas tran vdout1_370ck400 FIND v(dout1_370) AT=205.025n

.meas tran vdout1_371ck400 FIND v(dout1_371) AT=205.025n

.meas tran vdout1_372ck400 FIND v(dout1_372) AT=205.025n

.meas tran vdout1_373ck400 FIND v(dout1_373) AT=205.025n

.meas tran vdout1_374ck400 FIND v(dout1_374) AT=205.025n

.meas tran vdout1_375ck400 FIND v(dout1_375) AT=205.025n

.meas tran vdout1_376ck400 FIND v(dout1_376) AT=205.025n

.meas tran vdout1_377ck400 FIND v(dout1_377) AT=205.025n

.meas tran vdout1_378ck400 FIND v(dout1_378) AT=205.025n

.meas tran vdout1_379ck400 FIND v(dout1_379) AT=205.025n

.meas tran vdout1_380ck400 FIND v(dout1_380) AT=205.025n

.meas tran vdout1_381ck400 FIND v(dout1_381) AT=205.025n

.meas tran vdout1_382ck400 FIND v(dout1_382) AT=205.025n

.meas tran vdout1_383ck400 FIND v(dout1_383) AT=205.025n

.meas tran vdout1_384ck400 FIND v(dout1_384) AT=205.025n

.meas tran vdout1_385ck400 FIND v(dout1_385) AT=205.025n

.meas tran vdout1_386ck400 FIND v(dout1_386) AT=205.025n

.meas tran vdout1_387ck400 FIND v(dout1_387) AT=205.025n

.meas tran vdout1_388ck400 FIND v(dout1_388) AT=205.025n

.meas tran vdout1_389ck400 FIND v(dout1_389) AT=205.025n

.meas tran vdout1_390ck400 FIND v(dout1_390) AT=205.025n

.meas tran vdout1_391ck400 FIND v(dout1_391) AT=205.025n

.meas tran vdout1_392ck400 FIND v(dout1_392) AT=205.025n

.meas tran vdout1_393ck400 FIND v(dout1_393) AT=205.025n

.meas tran vdout1_394ck400 FIND v(dout1_394) AT=205.025n

.meas tran vdout1_395ck400 FIND v(dout1_395) AT=205.025n

.meas tran vdout1_396ck400 FIND v(dout1_396) AT=205.025n

.meas tran vdout1_397ck400 FIND v(dout1_397) AT=205.025n

.meas tran vdout1_398ck400 FIND v(dout1_398) AT=205.025n

.meas tran vdout1_399ck400 FIND v(dout1_399) AT=205.025n

.meas tran vdout1_400ck400 FIND v(dout1_400) AT=205.025n

.meas tran vdout1_401ck400 FIND v(dout1_401) AT=205.025n

.meas tran vdout1_402ck400 FIND v(dout1_402) AT=205.025n

.meas tran vdout1_403ck400 FIND v(dout1_403) AT=205.025n

.meas tran vdout1_404ck400 FIND v(dout1_404) AT=205.025n

.meas tran vdout1_405ck400 FIND v(dout1_405) AT=205.025n

.meas tran vdout1_406ck400 FIND v(dout1_406) AT=205.025n

.meas tran vdout1_407ck400 FIND v(dout1_407) AT=205.025n

.meas tran vdout1_408ck400 FIND v(dout1_408) AT=205.025n

.meas tran vdout1_409ck400 FIND v(dout1_409) AT=205.025n

.meas tran vdout1_410ck400 FIND v(dout1_410) AT=205.025n

.meas tran vdout1_411ck400 FIND v(dout1_411) AT=205.025n

.meas tran vdout1_412ck400 FIND v(dout1_412) AT=205.025n

.meas tran vdout1_413ck400 FIND v(dout1_413) AT=205.025n

.meas tran vdout1_414ck400 FIND v(dout1_414) AT=205.025n

.meas tran vdout1_415ck400 FIND v(dout1_415) AT=205.025n

.meas tran vdout1_416ck400 FIND v(dout1_416) AT=205.025n

.meas tran vdout1_417ck400 FIND v(dout1_417) AT=205.025n

.meas tran vdout1_418ck400 FIND v(dout1_418) AT=205.025n

.meas tran vdout1_419ck400 FIND v(dout1_419) AT=205.025n

.meas tran vdout1_420ck400 FIND v(dout1_420) AT=205.025n

.meas tran vdout1_421ck400 FIND v(dout1_421) AT=205.025n

.meas tran vdout1_422ck400 FIND v(dout1_422) AT=205.025n

.meas tran vdout1_423ck400 FIND v(dout1_423) AT=205.025n

.meas tran vdout1_424ck400 FIND v(dout1_424) AT=205.025n

.meas tran vdout1_425ck400 FIND v(dout1_425) AT=205.025n

.meas tran vdout1_426ck400 FIND v(dout1_426) AT=205.025n

.meas tran vdout1_427ck400 FIND v(dout1_427) AT=205.025n

.meas tran vdout1_428ck400 FIND v(dout1_428) AT=205.025n

.meas tran vdout1_429ck400 FIND v(dout1_429) AT=205.025n

.meas tran vdout1_430ck400 FIND v(dout1_430) AT=205.025n

.meas tran vdout1_431ck400 FIND v(dout1_431) AT=205.025n

.meas tran vdout1_432ck400 FIND v(dout1_432) AT=205.025n

.meas tran vdout1_433ck400 FIND v(dout1_433) AT=205.025n

.meas tran vdout1_434ck400 FIND v(dout1_434) AT=205.025n

.meas tran vdout1_435ck400 FIND v(dout1_435) AT=205.025n

.meas tran vdout1_436ck400 FIND v(dout1_436) AT=205.025n

.meas tran vdout1_437ck400 FIND v(dout1_437) AT=205.025n

.meas tran vdout1_438ck400 FIND v(dout1_438) AT=205.025n

.meas tran vdout1_439ck400 FIND v(dout1_439) AT=205.025n

.meas tran vdout1_440ck400 FIND v(dout1_440) AT=205.025n

.meas tran vdout1_441ck400 FIND v(dout1_441) AT=205.025n

.meas tran vdout1_442ck400 FIND v(dout1_442) AT=205.025n

.meas tran vdout1_443ck400 FIND v(dout1_443) AT=205.025n

.meas tran vdout1_444ck400 FIND v(dout1_444) AT=205.025n

.meas tran vdout1_445ck400 FIND v(dout1_445) AT=205.025n

.meas tran vdout1_446ck400 FIND v(dout1_446) AT=205.025n

.meas tran vdout1_447ck400 FIND v(dout1_447) AT=205.025n

.meas tran vdout1_448ck400 FIND v(dout1_448) AT=205.025n

.meas tran vdout1_449ck400 FIND v(dout1_449) AT=205.025n

.meas tran vdout1_450ck400 FIND v(dout1_450) AT=205.025n

.meas tran vdout1_451ck400 FIND v(dout1_451) AT=205.025n

.meas tran vdout1_452ck400 FIND v(dout1_452) AT=205.025n

.meas tran vdout1_453ck400 FIND v(dout1_453) AT=205.025n

.meas tran vdout1_454ck400 FIND v(dout1_454) AT=205.025n

.meas tran vdout1_455ck400 FIND v(dout1_455) AT=205.025n

.meas tran vdout1_456ck400 FIND v(dout1_456) AT=205.025n

.meas tran vdout1_457ck400 FIND v(dout1_457) AT=205.025n

.meas tran vdout1_458ck400 FIND v(dout1_458) AT=205.025n

.meas tran vdout1_459ck400 FIND v(dout1_459) AT=205.025n

.meas tran vdout1_460ck400 FIND v(dout1_460) AT=205.025n

.meas tran vdout1_461ck400 FIND v(dout1_461) AT=205.025n

.meas tran vdout1_462ck400 FIND v(dout1_462) AT=205.025n

.meas tran vdout1_463ck400 FIND v(dout1_463) AT=205.025n

.meas tran vdout1_464ck400 FIND v(dout1_464) AT=205.025n

.meas tran vdout1_465ck400 FIND v(dout1_465) AT=205.025n

.meas tran vdout1_466ck400 FIND v(dout1_466) AT=205.025n

.meas tran vdout1_467ck400 FIND v(dout1_467) AT=205.025n

.meas tran vdout1_468ck400 FIND v(dout1_468) AT=205.025n

.meas tran vdout1_469ck400 FIND v(dout1_469) AT=205.025n

.meas tran vdout1_470ck400 FIND v(dout1_470) AT=205.025n

.meas tran vdout1_471ck400 FIND v(dout1_471) AT=205.025n

.meas tran vdout1_472ck400 FIND v(dout1_472) AT=205.025n

.meas tran vdout1_473ck400 FIND v(dout1_473) AT=205.025n

.meas tran vdout1_474ck400 FIND v(dout1_474) AT=205.025n

.meas tran vdout1_475ck400 FIND v(dout1_475) AT=205.025n

.meas tran vdout1_476ck400 FIND v(dout1_476) AT=205.025n

.meas tran vdout1_477ck400 FIND v(dout1_477) AT=205.025n

.meas tran vdout1_478ck400 FIND v(dout1_478) AT=205.025n

.meas tran vdout1_479ck400 FIND v(dout1_479) AT=205.025n

.meas tran vdout1_480ck400 FIND v(dout1_480) AT=205.025n

.meas tran vdout1_481ck400 FIND v(dout1_481) AT=205.025n

.meas tran vdout1_482ck400 FIND v(dout1_482) AT=205.025n

.meas tran vdout1_483ck400 FIND v(dout1_483) AT=205.025n

.meas tran vdout1_484ck400 FIND v(dout1_484) AT=205.025n

.meas tran vdout1_485ck400 FIND v(dout1_485) AT=205.025n

.meas tran vdout1_486ck400 FIND v(dout1_486) AT=205.025n

.meas tran vdout1_487ck400 FIND v(dout1_487) AT=205.025n

.meas tran vdout1_488ck400 FIND v(dout1_488) AT=205.025n

.meas tran vdout1_489ck400 FIND v(dout1_489) AT=205.025n

.meas tran vdout1_490ck400 FIND v(dout1_490) AT=205.025n

.meas tran vdout1_491ck400 FIND v(dout1_491) AT=205.025n

.meas tran vdout1_492ck400 FIND v(dout1_492) AT=205.025n

.meas tran vdout1_493ck400 FIND v(dout1_493) AT=205.025n

.meas tran vdout1_494ck400 FIND v(dout1_494) AT=205.025n

.meas tran vdout1_495ck400 FIND v(dout1_495) AT=205.025n

.meas tran vdout1_496ck400 FIND v(dout1_496) AT=205.025n

.meas tran vdout1_497ck400 FIND v(dout1_497) AT=205.025n

.meas tran vdout1_498ck400 FIND v(dout1_498) AT=205.025n

.meas tran vdout1_499ck400 FIND v(dout1_499) AT=205.025n

.meas tran vdout1_500ck400 FIND v(dout1_500) AT=205.025n

.meas tran vdout1_501ck400 FIND v(dout1_501) AT=205.025n

.meas tran vdout1_502ck400 FIND v(dout1_502) AT=205.025n

.meas tran vdout1_503ck400 FIND v(dout1_503) AT=205.025n

.meas tran vdout1_504ck400 FIND v(dout1_504) AT=205.025n

.meas tran vdout1_505ck400 FIND v(dout1_505) AT=205.025n

.meas tran vdout1_506ck400 FIND v(dout1_506) AT=205.025n

.meas tran vdout1_507ck400 FIND v(dout1_507) AT=205.025n

.meas tran vdout1_508ck400 FIND v(dout1_508) AT=205.025n

.meas tran vdout1_509ck400 FIND v(dout1_509) AT=205.025n

.meas tran vdout1_510ck400 FIND v(dout1_510) AT=205.025n

.meas tran vdout1_511ck400 FIND v(dout1_511) AT=205.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_17ck410 FIND v(dout1_17) AT=210.025n

.meas tran vdout1_18ck410 FIND v(dout1_18) AT=210.025n

.meas tran vdout1_19ck410 FIND v(dout1_19) AT=210.025n

.meas tran vdout1_20ck410 FIND v(dout1_20) AT=210.025n

.meas tran vdout1_21ck410 FIND v(dout1_21) AT=210.025n

.meas tran vdout1_22ck410 FIND v(dout1_22) AT=210.025n

.meas tran vdout1_23ck410 FIND v(dout1_23) AT=210.025n

.meas tran vdout1_24ck410 FIND v(dout1_24) AT=210.025n

.meas tran vdout1_25ck410 FIND v(dout1_25) AT=210.025n

.meas tran vdout1_26ck410 FIND v(dout1_26) AT=210.025n

.meas tran vdout1_27ck410 FIND v(dout1_27) AT=210.025n

.meas tran vdout1_28ck410 FIND v(dout1_28) AT=210.025n

.meas tran vdout1_29ck410 FIND v(dout1_29) AT=210.025n

.meas tran vdout1_30ck410 FIND v(dout1_30) AT=210.025n

.meas tran vdout1_31ck410 FIND v(dout1_31) AT=210.025n

.meas tran vdout1_32ck410 FIND v(dout1_32) AT=210.025n

.meas tran vdout1_33ck410 FIND v(dout1_33) AT=210.025n

.meas tran vdout1_34ck410 FIND v(dout1_34) AT=210.025n

.meas tran vdout1_35ck410 FIND v(dout1_35) AT=210.025n

.meas tran vdout1_36ck410 FIND v(dout1_36) AT=210.025n

.meas tran vdout1_37ck410 FIND v(dout1_37) AT=210.025n

.meas tran vdout1_38ck410 FIND v(dout1_38) AT=210.025n

.meas tran vdout1_39ck410 FIND v(dout1_39) AT=210.025n

.meas tran vdout1_40ck410 FIND v(dout1_40) AT=210.025n

.meas tran vdout1_41ck410 FIND v(dout1_41) AT=210.025n

.meas tran vdout1_42ck410 FIND v(dout1_42) AT=210.025n

.meas tran vdout1_43ck410 FIND v(dout1_43) AT=210.025n

.meas tran vdout1_44ck410 FIND v(dout1_44) AT=210.025n

.meas tran vdout1_45ck410 FIND v(dout1_45) AT=210.025n

.meas tran vdout1_46ck410 FIND v(dout1_46) AT=210.025n

.meas tran vdout1_47ck410 FIND v(dout1_47) AT=210.025n

.meas tran vdout1_48ck410 FIND v(dout1_48) AT=210.025n

.meas tran vdout1_49ck410 FIND v(dout1_49) AT=210.025n

.meas tran vdout1_50ck410 FIND v(dout1_50) AT=210.025n

.meas tran vdout1_51ck410 FIND v(dout1_51) AT=210.025n

.meas tran vdout1_52ck410 FIND v(dout1_52) AT=210.025n

.meas tran vdout1_53ck410 FIND v(dout1_53) AT=210.025n

.meas tran vdout1_54ck410 FIND v(dout1_54) AT=210.025n

.meas tran vdout1_55ck410 FIND v(dout1_55) AT=210.025n

.meas tran vdout1_56ck410 FIND v(dout1_56) AT=210.025n

.meas tran vdout1_57ck410 FIND v(dout1_57) AT=210.025n

.meas tran vdout1_58ck410 FIND v(dout1_58) AT=210.025n

.meas tran vdout1_59ck410 FIND v(dout1_59) AT=210.025n

.meas tran vdout1_60ck410 FIND v(dout1_60) AT=210.025n

.meas tran vdout1_61ck410 FIND v(dout1_61) AT=210.025n

.meas tran vdout1_62ck410 FIND v(dout1_62) AT=210.025n

.meas tran vdout1_63ck410 FIND v(dout1_63) AT=210.025n

.meas tran vdout1_64ck410 FIND v(dout1_64) AT=210.025n

.meas tran vdout1_65ck410 FIND v(dout1_65) AT=210.025n

.meas tran vdout1_66ck410 FIND v(dout1_66) AT=210.025n

.meas tran vdout1_67ck410 FIND v(dout1_67) AT=210.025n

.meas tran vdout1_68ck410 FIND v(dout1_68) AT=210.025n

.meas tran vdout1_69ck410 FIND v(dout1_69) AT=210.025n

.meas tran vdout1_70ck410 FIND v(dout1_70) AT=210.025n

.meas tran vdout1_71ck410 FIND v(dout1_71) AT=210.025n

.meas tran vdout1_72ck410 FIND v(dout1_72) AT=210.025n

.meas tran vdout1_73ck410 FIND v(dout1_73) AT=210.025n

.meas tran vdout1_74ck410 FIND v(dout1_74) AT=210.025n

.meas tran vdout1_75ck410 FIND v(dout1_75) AT=210.025n

.meas tran vdout1_76ck410 FIND v(dout1_76) AT=210.025n

.meas tran vdout1_77ck410 FIND v(dout1_77) AT=210.025n

.meas tran vdout1_78ck410 FIND v(dout1_78) AT=210.025n

.meas tran vdout1_79ck410 FIND v(dout1_79) AT=210.025n

.meas tran vdout1_80ck410 FIND v(dout1_80) AT=210.025n

.meas tran vdout1_81ck410 FIND v(dout1_81) AT=210.025n

.meas tran vdout1_82ck410 FIND v(dout1_82) AT=210.025n

.meas tran vdout1_83ck410 FIND v(dout1_83) AT=210.025n

.meas tran vdout1_84ck410 FIND v(dout1_84) AT=210.025n

.meas tran vdout1_85ck410 FIND v(dout1_85) AT=210.025n

.meas tran vdout1_86ck410 FIND v(dout1_86) AT=210.025n

.meas tran vdout1_87ck410 FIND v(dout1_87) AT=210.025n

.meas tran vdout1_88ck410 FIND v(dout1_88) AT=210.025n

.meas tran vdout1_89ck410 FIND v(dout1_89) AT=210.025n

.meas tran vdout1_90ck410 FIND v(dout1_90) AT=210.025n

.meas tran vdout1_91ck410 FIND v(dout1_91) AT=210.025n

.meas tran vdout1_92ck410 FIND v(dout1_92) AT=210.025n

.meas tran vdout1_93ck410 FIND v(dout1_93) AT=210.025n

.meas tran vdout1_94ck410 FIND v(dout1_94) AT=210.025n

.meas tran vdout1_95ck410 FIND v(dout1_95) AT=210.025n

.meas tran vdout1_96ck410 FIND v(dout1_96) AT=210.025n

.meas tran vdout1_97ck410 FIND v(dout1_97) AT=210.025n

.meas tran vdout1_98ck410 FIND v(dout1_98) AT=210.025n

.meas tran vdout1_99ck410 FIND v(dout1_99) AT=210.025n

.meas tran vdout1_100ck410 FIND v(dout1_100) AT=210.025n

.meas tran vdout1_101ck410 FIND v(dout1_101) AT=210.025n

.meas tran vdout1_102ck410 FIND v(dout1_102) AT=210.025n

.meas tran vdout1_103ck410 FIND v(dout1_103) AT=210.025n

.meas tran vdout1_104ck410 FIND v(dout1_104) AT=210.025n

.meas tran vdout1_105ck410 FIND v(dout1_105) AT=210.025n

.meas tran vdout1_106ck410 FIND v(dout1_106) AT=210.025n

.meas tran vdout1_107ck410 FIND v(dout1_107) AT=210.025n

.meas tran vdout1_108ck410 FIND v(dout1_108) AT=210.025n

.meas tran vdout1_109ck410 FIND v(dout1_109) AT=210.025n

.meas tran vdout1_110ck410 FIND v(dout1_110) AT=210.025n

.meas tran vdout1_111ck410 FIND v(dout1_111) AT=210.025n

.meas tran vdout1_112ck410 FIND v(dout1_112) AT=210.025n

.meas tran vdout1_113ck410 FIND v(dout1_113) AT=210.025n

.meas tran vdout1_114ck410 FIND v(dout1_114) AT=210.025n

.meas tran vdout1_115ck410 FIND v(dout1_115) AT=210.025n

.meas tran vdout1_116ck410 FIND v(dout1_116) AT=210.025n

.meas tran vdout1_117ck410 FIND v(dout1_117) AT=210.025n

.meas tran vdout1_118ck410 FIND v(dout1_118) AT=210.025n

.meas tran vdout1_119ck410 FIND v(dout1_119) AT=210.025n

.meas tran vdout1_120ck410 FIND v(dout1_120) AT=210.025n

.meas tran vdout1_121ck410 FIND v(dout1_121) AT=210.025n

.meas tran vdout1_122ck410 FIND v(dout1_122) AT=210.025n

.meas tran vdout1_123ck410 FIND v(dout1_123) AT=210.025n

.meas tran vdout1_124ck410 FIND v(dout1_124) AT=210.025n

.meas tran vdout1_125ck410 FIND v(dout1_125) AT=210.025n

.meas tran vdout1_126ck410 FIND v(dout1_126) AT=210.025n

.meas tran vdout1_127ck410 FIND v(dout1_127) AT=210.025n

.meas tran vdout1_128ck410 FIND v(dout1_128) AT=210.025n

.meas tran vdout1_129ck410 FIND v(dout1_129) AT=210.025n

.meas tran vdout1_130ck410 FIND v(dout1_130) AT=210.025n

.meas tran vdout1_131ck410 FIND v(dout1_131) AT=210.025n

.meas tran vdout1_132ck410 FIND v(dout1_132) AT=210.025n

.meas tran vdout1_133ck410 FIND v(dout1_133) AT=210.025n

.meas tran vdout1_134ck410 FIND v(dout1_134) AT=210.025n

.meas tran vdout1_135ck410 FIND v(dout1_135) AT=210.025n

.meas tran vdout1_136ck410 FIND v(dout1_136) AT=210.025n

.meas tran vdout1_137ck410 FIND v(dout1_137) AT=210.025n

.meas tran vdout1_138ck410 FIND v(dout1_138) AT=210.025n

.meas tran vdout1_139ck410 FIND v(dout1_139) AT=210.025n

.meas tran vdout1_140ck410 FIND v(dout1_140) AT=210.025n

.meas tran vdout1_141ck410 FIND v(dout1_141) AT=210.025n

.meas tran vdout1_142ck410 FIND v(dout1_142) AT=210.025n

.meas tran vdout1_143ck410 FIND v(dout1_143) AT=210.025n

.meas tran vdout1_144ck410 FIND v(dout1_144) AT=210.025n

.meas tran vdout1_145ck410 FIND v(dout1_145) AT=210.025n

.meas tran vdout1_146ck410 FIND v(dout1_146) AT=210.025n

.meas tran vdout1_147ck410 FIND v(dout1_147) AT=210.025n

.meas tran vdout1_148ck410 FIND v(dout1_148) AT=210.025n

.meas tran vdout1_149ck410 FIND v(dout1_149) AT=210.025n

.meas tran vdout1_150ck410 FIND v(dout1_150) AT=210.025n

.meas tran vdout1_151ck410 FIND v(dout1_151) AT=210.025n

.meas tran vdout1_152ck410 FIND v(dout1_152) AT=210.025n

.meas tran vdout1_153ck410 FIND v(dout1_153) AT=210.025n

.meas tran vdout1_154ck410 FIND v(dout1_154) AT=210.025n

.meas tran vdout1_155ck410 FIND v(dout1_155) AT=210.025n

.meas tran vdout1_156ck410 FIND v(dout1_156) AT=210.025n

.meas tran vdout1_157ck410 FIND v(dout1_157) AT=210.025n

.meas tran vdout1_158ck410 FIND v(dout1_158) AT=210.025n

.meas tran vdout1_159ck410 FIND v(dout1_159) AT=210.025n

.meas tran vdout1_160ck410 FIND v(dout1_160) AT=210.025n

.meas tran vdout1_161ck410 FIND v(dout1_161) AT=210.025n

.meas tran vdout1_162ck410 FIND v(dout1_162) AT=210.025n

.meas tran vdout1_163ck410 FIND v(dout1_163) AT=210.025n

.meas tran vdout1_164ck410 FIND v(dout1_164) AT=210.025n

.meas tran vdout1_165ck410 FIND v(dout1_165) AT=210.025n

.meas tran vdout1_166ck410 FIND v(dout1_166) AT=210.025n

.meas tran vdout1_167ck410 FIND v(dout1_167) AT=210.025n

.meas tran vdout1_168ck410 FIND v(dout1_168) AT=210.025n

.meas tran vdout1_169ck410 FIND v(dout1_169) AT=210.025n

.meas tran vdout1_170ck410 FIND v(dout1_170) AT=210.025n

.meas tran vdout1_171ck410 FIND v(dout1_171) AT=210.025n

.meas tran vdout1_172ck410 FIND v(dout1_172) AT=210.025n

.meas tran vdout1_173ck410 FIND v(dout1_173) AT=210.025n

.meas tran vdout1_174ck410 FIND v(dout1_174) AT=210.025n

.meas tran vdout1_175ck410 FIND v(dout1_175) AT=210.025n

.meas tran vdout1_176ck410 FIND v(dout1_176) AT=210.025n

.meas tran vdout1_177ck410 FIND v(dout1_177) AT=210.025n

.meas tran vdout1_178ck410 FIND v(dout1_178) AT=210.025n

.meas tran vdout1_179ck410 FIND v(dout1_179) AT=210.025n

.meas tran vdout1_180ck410 FIND v(dout1_180) AT=210.025n

.meas tran vdout1_181ck410 FIND v(dout1_181) AT=210.025n

.meas tran vdout1_182ck410 FIND v(dout1_182) AT=210.025n

.meas tran vdout1_183ck410 FIND v(dout1_183) AT=210.025n

.meas tran vdout1_184ck410 FIND v(dout1_184) AT=210.025n

.meas tran vdout1_185ck410 FIND v(dout1_185) AT=210.025n

.meas tran vdout1_186ck410 FIND v(dout1_186) AT=210.025n

.meas tran vdout1_187ck410 FIND v(dout1_187) AT=210.025n

.meas tran vdout1_188ck410 FIND v(dout1_188) AT=210.025n

.meas tran vdout1_189ck410 FIND v(dout1_189) AT=210.025n

.meas tran vdout1_190ck410 FIND v(dout1_190) AT=210.025n

.meas tran vdout1_191ck410 FIND v(dout1_191) AT=210.025n

.meas tran vdout1_192ck410 FIND v(dout1_192) AT=210.025n

.meas tran vdout1_193ck410 FIND v(dout1_193) AT=210.025n

.meas tran vdout1_194ck410 FIND v(dout1_194) AT=210.025n

.meas tran vdout1_195ck410 FIND v(dout1_195) AT=210.025n

.meas tran vdout1_196ck410 FIND v(dout1_196) AT=210.025n

.meas tran vdout1_197ck410 FIND v(dout1_197) AT=210.025n

.meas tran vdout1_198ck410 FIND v(dout1_198) AT=210.025n

.meas tran vdout1_199ck410 FIND v(dout1_199) AT=210.025n

.meas tran vdout1_200ck410 FIND v(dout1_200) AT=210.025n

.meas tran vdout1_201ck410 FIND v(dout1_201) AT=210.025n

.meas tran vdout1_202ck410 FIND v(dout1_202) AT=210.025n

.meas tran vdout1_203ck410 FIND v(dout1_203) AT=210.025n

.meas tran vdout1_204ck410 FIND v(dout1_204) AT=210.025n

.meas tran vdout1_205ck410 FIND v(dout1_205) AT=210.025n

.meas tran vdout1_206ck410 FIND v(dout1_206) AT=210.025n

.meas tran vdout1_207ck410 FIND v(dout1_207) AT=210.025n

.meas tran vdout1_208ck410 FIND v(dout1_208) AT=210.025n

.meas tran vdout1_209ck410 FIND v(dout1_209) AT=210.025n

.meas tran vdout1_210ck410 FIND v(dout1_210) AT=210.025n

.meas tran vdout1_211ck410 FIND v(dout1_211) AT=210.025n

.meas tran vdout1_212ck410 FIND v(dout1_212) AT=210.025n

.meas tran vdout1_213ck410 FIND v(dout1_213) AT=210.025n

.meas tran vdout1_214ck410 FIND v(dout1_214) AT=210.025n

.meas tran vdout1_215ck410 FIND v(dout1_215) AT=210.025n

.meas tran vdout1_216ck410 FIND v(dout1_216) AT=210.025n

.meas tran vdout1_217ck410 FIND v(dout1_217) AT=210.025n

.meas tran vdout1_218ck410 FIND v(dout1_218) AT=210.025n

.meas tran vdout1_219ck410 FIND v(dout1_219) AT=210.025n

.meas tran vdout1_220ck410 FIND v(dout1_220) AT=210.025n

.meas tran vdout1_221ck410 FIND v(dout1_221) AT=210.025n

.meas tran vdout1_222ck410 FIND v(dout1_222) AT=210.025n

.meas tran vdout1_223ck410 FIND v(dout1_223) AT=210.025n

.meas tran vdout1_224ck410 FIND v(dout1_224) AT=210.025n

.meas tran vdout1_225ck410 FIND v(dout1_225) AT=210.025n

.meas tran vdout1_226ck410 FIND v(dout1_226) AT=210.025n

.meas tran vdout1_227ck410 FIND v(dout1_227) AT=210.025n

.meas tran vdout1_228ck410 FIND v(dout1_228) AT=210.025n

.meas tran vdout1_229ck410 FIND v(dout1_229) AT=210.025n

.meas tran vdout1_230ck410 FIND v(dout1_230) AT=210.025n

.meas tran vdout1_231ck410 FIND v(dout1_231) AT=210.025n

.meas tran vdout1_232ck410 FIND v(dout1_232) AT=210.025n

.meas tran vdout1_233ck410 FIND v(dout1_233) AT=210.025n

.meas tran vdout1_234ck410 FIND v(dout1_234) AT=210.025n

.meas tran vdout1_235ck410 FIND v(dout1_235) AT=210.025n

.meas tran vdout1_236ck410 FIND v(dout1_236) AT=210.025n

.meas tran vdout1_237ck410 FIND v(dout1_237) AT=210.025n

.meas tran vdout1_238ck410 FIND v(dout1_238) AT=210.025n

.meas tran vdout1_239ck410 FIND v(dout1_239) AT=210.025n

.meas tran vdout1_240ck410 FIND v(dout1_240) AT=210.025n

.meas tran vdout1_241ck410 FIND v(dout1_241) AT=210.025n

.meas tran vdout1_242ck410 FIND v(dout1_242) AT=210.025n

.meas tran vdout1_243ck410 FIND v(dout1_243) AT=210.025n

.meas tran vdout1_244ck410 FIND v(dout1_244) AT=210.025n

.meas tran vdout1_245ck410 FIND v(dout1_245) AT=210.025n

.meas tran vdout1_246ck410 FIND v(dout1_246) AT=210.025n

.meas tran vdout1_247ck410 FIND v(dout1_247) AT=210.025n

.meas tran vdout1_248ck410 FIND v(dout1_248) AT=210.025n

.meas tran vdout1_249ck410 FIND v(dout1_249) AT=210.025n

.meas tran vdout1_250ck410 FIND v(dout1_250) AT=210.025n

.meas tran vdout1_251ck410 FIND v(dout1_251) AT=210.025n

.meas tran vdout1_252ck410 FIND v(dout1_252) AT=210.025n

.meas tran vdout1_253ck410 FIND v(dout1_253) AT=210.025n

.meas tran vdout1_254ck410 FIND v(dout1_254) AT=210.025n

.meas tran vdout1_255ck410 FIND v(dout1_255) AT=210.025n

.meas tran vdout1_256ck410 FIND v(dout1_256) AT=210.025n

.meas tran vdout1_257ck410 FIND v(dout1_257) AT=210.025n

.meas tran vdout1_258ck410 FIND v(dout1_258) AT=210.025n

.meas tran vdout1_259ck410 FIND v(dout1_259) AT=210.025n

.meas tran vdout1_260ck410 FIND v(dout1_260) AT=210.025n

.meas tran vdout1_261ck410 FIND v(dout1_261) AT=210.025n

.meas tran vdout1_262ck410 FIND v(dout1_262) AT=210.025n

.meas tran vdout1_263ck410 FIND v(dout1_263) AT=210.025n

.meas tran vdout1_264ck410 FIND v(dout1_264) AT=210.025n

.meas tran vdout1_265ck410 FIND v(dout1_265) AT=210.025n

.meas tran vdout1_266ck410 FIND v(dout1_266) AT=210.025n

.meas tran vdout1_267ck410 FIND v(dout1_267) AT=210.025n

.meas tran vdout1_268ck410 FIND v(dout1_268) AT=210.025n

.meas tran vdout1_269ck410 FIND v(dout1_269) AT=210.025n

.meas tran vdout1_270ck410 FIND v(dout1_270) AT=210.025n

.meas tran vdout1_271ck410 FIND v(dout1_271) AT=210.025n

.meas tran vdout1_272ck410 FIND v(dout1_272) AT=210.025n

.meas tran vdout1_273ck410 FIND v(dout1_273) AT=210.025n

.meas tran vdout1_274ck410 FIND v(dout1_274) AT=210.025n

.meas tran vdout1_275ck410 FIND v(dout1_275) AT=210.025n

.meas tran vdout1_276ck410 FIND v(dout1_276) AT=210.025n

.meas tran vdout1_277ck410 FIND v(dout1_277) AT=210.025n

.meas tran vdout1_278ck410 FIND v(dout1_278) AT=210.025n

.meas tran vdout1_279ck410 FIND v(dout1_279) AT=210.025n

.meas tran vdout1_280ck410 FIND v(dout1_280) AT=210.025n

.meas tran vdout1_281ck410 FIND v(dout1_281) AT=210.025n

.meas tran vdout1_282ck410 FIND v(dout1_282) AT=210.025n

.meas tran vdout1_283ck410 FIND v(dout1_283) AT=210.025n

.meas tran vdout1_284ck410 FIND v(dout1_284) AT=210.025n

.meas tran vdout1_285ck410 FIND v(dout1_285) AT=210.025n

.meas tran vdout1_286ck410 FIND v(dout1_286) AT=210.025n

.meas tran vdout1_287ck410 FIND v(dout1_287) AT=210.025n

.meas tran vdout1_288ck410 FIND v(dout1_288) AT=210.025n

.meas tran vdout1_289ck410 FIND v(dout1_289) AT=210.025n

.meas tran vdout1_290ck410 FIND v(dout1_290) AT=210.025n

.meas tran vdout1_291ck410 FIND v(dout1_291) AT=210.025n

.meas tran vdout1_292ck410 FIND v(dout1_292) AT=210.025n

.meas tran vdout1_293ck410 FIND v(dout1_293) AT=210.025n

.meas tran vdout1_294ck410 FIND v(dout1_294) AT=210.025n

.meas tran vdout1_295ck410 FIND v(dout1_295) AT=210.025n

.meas tran vdout1_296ck410 FIND v(dout1_296) AT=210.025n

.meas tran vdout1_297ck410 FIND v(dout1_297) AT=210.025n

.meas tran vdout1_298ck410 FIND v(dout1_298) AT=210.025n

.meas tran vdout1_299ck410 FIND v(dout1_299) AT=210.025n

.meas tran vdout1_300ck410 FIND v(dout1_300) AT=210.025n

.meas tran vdout1_301ck410 FIND v(dout1_301) AT=210.025n

.meas tran vdout1_302ck410 FIND v(dout1_302) AT=210.025n

.meas tran vdout1_303ck410 FIND v(dout1_303) AT=210.025n

.meas tran vdout1_304ck410 FIND v(dout1_304) AT=210.025n

.meas tran vdout1_305ck410 FIND v(dout1_305) AT=210.025n

.meas tran vdout1_306ck410 FIND v(dout1_306) AT=210.025n

.meas tran vdout1_307ck410 FIND v(dout1_307) AT=210.025n

.meas tran vdout1_308ck410 FIND v(dout1_308) AT=210.025n

.meas tran vdout1_309ck410 FIND v(dout1_309) AT=210.025n

.meas tran vdout1_310ck410 FIND v(dout1_310) AT=210.025n

.meas tran vdout1_311ck410 FIND v(dout1_311) AT=210.025n

.meas tran vdout1_312ck410 FIND v(dout1_312) AT=210.025n

.meas tran vdout1_313ck410 FIND v(dout1_313) AT=210.025n

.meas tran vdout1_314ck410 FIND v(dout1_314) AT=210.025n

.meas tran vdout1_315ck410 FIND v(dout1_315) AT=210.025n

.meas tran vdout1_316ck410 FIND v(dout1_316) AT=210.025n

.meas tran vdout1_317ck410 FIND v(dout1_317) AT=210.025n

.meas tran vdout1_318ck410 FIND v(dout1_318) AT=210.025n

.meas tran vdout1_319ck410 FIND v(dout1_319) AT=210.025n

.meas tran vdout1_320ck410 FIND v(dout1_320) AT=210.025n

.meas tran vdout1_321ck410 FIND v(dout1_321) AT=210.025n

.meas tran vdout1_322ck410 FIND v(dout1_322) AT=210.025n

.meas tran vdout1_323ck410 FIND v(dout1_323) AT=210.025n

.meas tran vdout1_324ck410 FIND v(dout1_324) AT=210.025n

.meas tran vdout1_325ck410 FIND v(dout1_325) AT=210.025n

.meas tran vdout1_326ck410 FIND v(dout1_326) AT=210.025n

.meas tran vdout1_327ck410 FIND v(dout1_327) AT=210.025n

.meas tran vdout1_328ck410 FIND v(dout1_328) AT=210.025n

.meas tran vdout1_329ck410 FIND v(dout1_329) AT=210.025n

.meas tran vdout1_330ck410 FIND v(dout1_330) AT=210.025n

.meas tran vdout1_331ck410 FIND v(dout1_331) AT=210.025n

.meas tran vdout1_332ck410 FIND v(dout1_332) AT=210.025n

.meas tran vdout1_333ck410 FIND v(dout1_333) AT=210.025n

.meas tran vdout1_334ck410 FIND v(dout1_334) AT=210.025n

.meas tran vdout1_335ck410 FIND v(dout1_335) AT=210.025n

.meas tran vdout1_336ck410 FIND v(dout1_336) AT=210.025n

.meas tran vdout1_337ck410 FIND v(dout1_337) AT=210.025n

.meas tran vdout1_338ck410 FIND v(dout1_338) AT=210.025n

.meas tran vdout1_339ck410 FIND v(dout1_339) AT=210.025n

.meas tran vdout1_340ck410 FIND v(dout1_340) AT=210.025n

.meas tran vdout1_341ck410 FIND v(dout1_341) AT=210.025n

.meas tran vdout1_342ck410 FIND v(dout1_342) AT=210.025n

.meas tran vdout1_343ck410 FIND v(dout1_343) AT=210.025n

.meas tran vdout1_344ck410 FIND v(dout1_344) AT=210.025n

.meas tran vdout1_345ck410 FIND v(dout1_345) AT=210.025n

.meas tran vdout1_346ck410 FIND v(dout1_346) AT=210.025n

.meas tran vdout1_347ck410 FIND v(dout1_347) AT=210.025n

.meas tran vdout1_348ck410 FIND v(dout1_348) AT=210.025n

.meas tran vdout1_349ck410 FIND v(dout1_349) AT=210.025n

.meas tran vdout1_350ck410 FIND v(dout1_350) AT=210.025n

.meas tran vdout1_351ck410 FIND v(dout1_351) AT=210.025n

.meas tran vdout1_352ck410 FIND v(dout1_352) AT=210.025n

.meas tran vdout1_353ck410 FIND v(dout1_353) AT=210.025n

.meas tran vdout1_354ck410 FIND v(dout1_354) AT=210.025n

.meas tran vdout1_355ck410 FIND v(dout1_355) AT=210.025n

.meas tran vdout1_356ck410 FIND v(dout1_356) AT=210.025n

.meas tran vdout1_357ck410 FIND v(dout1_357) AT=210.025n

.meas tran vdout1_358ck410 FIND v(dout1_358) AT=210.025n

.meas tran vdout1_359ck410 FIND v(dout1_359) AT=210.025n

.meas tran vdout1_360ck410 FIND v(dout1_360) AT=210.025n

.meas tran vdout1_361ck410 FIND v(dout1_361) AT=210.025n

.meas tran vdout1_362ck410 FIND v(dout1_362) AT=210.025n

.meas tran vdout1_363ck410 FIND v(dout1_363) AT=210.025n

.meas tran vdout1_364ck410 FIND v(dout1_364) AT=210.025n

.meas tran vdout1_365ck410 FIND v(dout1_365) AT=210.025n

.meas tran vdout1_366ck410 FIND v(dout1_366) AT=210.025n

.meas tran vdout1_367ck410 FIND v(dout1_367) AT=210.025n

.meas tran vdout1_368ck410 FIND v(dout1_368) AT=210.025n

.meas tran vdout1_369ck410 FIND v(dout1_369) AT=210.025n

.meas tran vdout1_370ck410 FIND v(dout1_370) AT=210.025n

.meas tran vdout1_371ck410 FIND v(dout1_371) AT=210.025n

.meas tran vdout1_372ck410 FIND v(dout1_372) AT=210.025n

.meas tran vdout1_373ck410 FIND v(dout1_373) AT=210.025n

.meas tran vdout1_374ck410 FIND v(dout1_374) AT=210.025n

.meas tran vdout1_375ck410 FIND v(dout1_375) AT=210.025n

.meas tran vdout1_376ck410 FIND v(dout1_376) AT=210.025n

.meas tran vdout1_377ck410 FIND v(dout1_377) AT=210.025n

.meas tran vdout1_378ck410 FIND v(dout1_378) AT=210.025n

.meas tran vdout1_379ck410 FIND v(dout1_379) AT=210.025n

.meas tran vdout1_380ck410 FIND v(dout1_380) AT=210.025n

.meas tran vdout1_381ck410 FIND v(dout1_381) AT=210.025n

.meas tran vdout1_382ck410 FIND v(dout1_382) AT=210.025n

.meas tran vdout1_383ck410 FIND v(dout1_383) AT=210.025n

.meas tran vdout1_384ck410 FIND v(dout1_384) AT=210.025n

.meas tran vdout1_385ck410 FIND v(dout1_385) AT=210.025n

.meas tran vdout1_386ck410 FIND v(dout1_386) AT=210.025n

.meas tran vdout1_387ck410 FIND v(dout1_387) AT=210.025n

.meas tran vdout1_388ck410 FIND v(dout1_388) AT=210.025n

.meas tran vdout1_389ck410 FIND v(dout1_389) AT=210.025n

.meas tran vdout1_390ck410 FIND v(dout1_390) AT=210.025n

.meas tran vdout1_391ck410 FIND v(dout1_391) AT=210.025n

.meas tran vdout1_392ck410 FIND v(dout1_392) AT=210.025n

.meas tran vdout1_393ck410 FIND v(dout1_393) AT=210.025n

.meas tran vdout1_394ck410 FIND v(dout1_394) AT=210.025n

.meas tran vdout1_395ck410 FIND v(dout1_395) AT=210.025n

.meas tran vdout1_396ck410 FIND v(dout1_396) AT=210.025n

.meas tran vdout1_397ck410 FIND v(dout1_397) AT=210.025n

.meas tran vdout1_398ck410 FIND v(dout1_398) AT=210.025n

.meas tran vdout1_399ck410 FIND v(dout1_399) AT=210.025n

.meas tran vdout1_400ck410 FIND v(dout1_400) AT=210.025n

.meas tran vdout1_401ck410 FIND v(dout1_401) AT=210.025n

.meas tran vdout1_402ck410 FIND v(dout1_402) AT=210.025n

.meas tran vdout1_403ck410 FIND v(dout1_403) AT=210.025n

.meas tran vdout1_404ck410 FIND v(dout1_404) AT=210.025n

.meas tran vdout1_405ck410 FIND v(dout1_405) AT=210.025n

.meas tran vdout1_406ck410 FIND v(dout1_406) AT=210.025n

.meas tran vdout1_407ck410 FIND v(dout1_407) AT=210.025n

.meas tran vdout1_408ck410 FIND v(dout1_408) AT=210.025n

.meas tran vdout1_409ck410 FIND v(dout1_409) AT=210.025n

.meas tran vdout1_410ck410 FIND v(dout1_410) AT=210.025n

.meas tran vdout1_411ck410 FIND v(dout1_411) AT=210.025n

.meas tran vdout1_412ck410 FIND v(dout1_412) AT=210.025n

.meas tran vdout1_413ck410 FIND v(dout1_413) AT=210.025n

.meas tran vdout1_414ck410 FIND v(dout1_414) AT=210.025n

.meas tran vdout1_415ck410 FIND v(dout1_415) AT=210.025n

.meas tran vdout1_416ck410 FIND v(dout1_416) AT=210.025n

.meas tran vdout1_417ck410 FIND v(dout1_417) AT=210.025n

.meas tran vdout1_418ck410 FIND v(dout1_418) AT=210.025n

.meas tran vdout1_419ck410 FIND v(dout1_419) AT=210.025n

.meas tran vdout1_420ck410 FIND v(dout1_420) AT=210.025n

.meas tran vdout1_421ck410 FIND v(dout1_421) AT=210.025n

.meas tran vdout1_422ck410 FIND v(dout1_422) AT=210.025n

.meas tran vdout1_423ck410 FIND v(dout1_423) AT=210.025n

.meas tran vdout1_424ck410 FIND v(dout1_424) AT=210.025n

.meas tran vdout1_425ck410 FIND v(dout1_425) AT=210.025n

.meas tran vdout1_426ck410 FIND v(dout1_426) AT=210.025n

.meas tran vdout1_427ck410 FIND v(dout1_427) AT=210.025n

.meas tran vdout1_428ck410 FIND v(dout1_428) AT=210.025n

.meas tran vdout1_429ck410 FIND v(dout1_429) AT=210.025n

.meas tran vdout1_430ck410 FIND v(dout1_430) AT=210.025n

.meas tran vdout1_431ck410 FIND v(dout1_431) AT=210.025n

.meas tran vdout1_432ck410 FIND v(dout1_432) AT=210.025n

.meas tran vdout1_433ck410 FIND v(dout1_433) AT=210.025n

.meas tran vdout1_434ck410 FIND v(dout1_434) AT=210.025n

.meas tran vdout1_435ck410 FIND v(dout1_435) AT=210.025n

.meas tran vdout1_436ck410 FIND v(dout1_436) AT=210.025n

.meas tran vdout1_437ck410 FIND v(dout1_437) AT=210.025n

.meas tran vdout1_438ck410 FIND v(dout1_438) AT=210.025n

.meas tran vdout1_439ck410 FIND v(dout1_439) AT=210.025n

.meas tran vdout1_440ck410 FIND v(dout1_440) AT=210.025n

.meas tran vdout1_441ck410 FIND v(dout1_441) AT=210.025n

.meas tran vdout1_442ck410 FIND v(dout1_442) AT=210.025n

.meas tran vdout1_443ck410 FIND v(dout1_443) AT=210.025n

.meas tran vdout1_444ck410 FIND v(dout1_444) AT=210.025n

.meas tran vdout1_445ck410 FIND v(dout1_445) AT=210.025n

.meas tran vdout1_446ck410 FIND v(dout1_446) AT=210.025n

.meas tran vdout1_447ck410 FIND v(dout1_447) AT=210.025n

.meas tran vdout1_448ck410 FIND v(dout1_448) AT=210.025n

.meas tran vdout1_449ck410 FIND v(dout1_449) AT=210.025n

.meas tran vdout1_450ck410 FIND v(dout1_450) AT=210.025n

.meas tran vdout1_451ck410 FIND v(dout1_451) AT=210.025n

.meas tran vdout1_452ck410 FIND v(dout1_452) AT=210.025n

.meas tran vdout1_453ck410 FIND v(dout1_453) AT=210.025n

.meas tran vdout1_454ck410 FIND v(dout1_454) AT=210.025n

.meas tran vdout1_455ck410 FIND v(dout1_455) AT=210.025n

.meas tran vdout1_456ck410 FIND v(dout1_456) AT=210.025n

.meas tran vdout1_457ck410 FIND v(dout1_457) AT=210.025n

.meas tran vdout1_458ck410 FIND v(dout1_458) AT=210.025n

.meas tran vdout1_459ck410 FIND v(dout1_459) AT=210.025n

.meas tran vdout1_460ck410 FIND v(dout1_460) AT=210.025n

.meas tran vdout1_461ck410 FIND v(dout1_461) AT=210.025n

.meas tran vdout1_462ck410 FIND v(dout1_462) AT=210.025n

.meas tran vdout1_463ck410 FIND v(dout1_463) AT=210.025n

.meas tran vdout1_464ck410 FIND v(dout1_464) AT=210.025n

.meas tran vdout1_465ck410 FIND v(dout1_465) AT=210.025n

.meas tran vdout1_466ck410 FIND v(dout1_466) AT=210.025n

.meas tran vdout1_467ck410 FIND v(dout1_467) AT=210.025n

.meas tran vdout1_468ck410 FIND v(dout1_468) AT=210.025n

.meas tran vdout1_469ck410 FIND v(dout1_469) AT=210.025n

.meas tran vdout1_470ck410 FIND v(dout1_470) AT=210.025n

.meas tran vdout1_471ck410 FIND v(dout1_471) AT=210.025n

.meas tran vdout1_472ck410 FIND v(dout1_472) AT=210.025n

.meas tran vdout1_473ck410 FIND v(dout1_473) AT=210.025n

.meas tran vdout1_474ck410 FIND v(dout1_474) AT=210.025n

.meas tran vdout1_475ck410 FIND v(dout1_475) AT=210.025n

.meas tran vdout1_476ck410 FIND v(dout1_476) AT=210.025n

.meas tran vdout1_477ck410 FIND v(dout1_477) AT=210.025n

.meas tran vdout1_478ck410 FIND v(dout1_478) AT=210.025n

.meas tran vdout1_479ck410 FIND v(dout1_479) AT=210.025n

.meas tran vdout1_480ck410 FIND v(dout1_480) AT=210.025n

.meas tran vdout1_481ck410 FIND v(dout1_481) AT=210.025n

.meas tran vdout1_482ck410 FIND v(dout1_482) AT=210.025n

.meas tran vdout1_483ck410 FIND v(dout1_483) AT=210.025n

.meas tran vdout1_484ck410 FIND v(dout1_484) AT=210.025n

.meas tran vdout1_485ck410 FIND v(dout1_485) AT=210.025n

.meas tran vdout1_486ck410 FIND v(dout1_486) AT=210.025n

.meas tran vdout1_487ck410 FIND v(dout1_487) AT=210.025n

.meas tran vdout1_488ck410 FIND v(dout1_488) AT=210.025n

.meas tran vdout1_489ck410 FIND v(dout1_489) AT=210.025n

.meas tran vdout1_490ck410 FIND v(dout1_490) AT=210.025n

.meas tran vdout1_491ck410 FIND v(dout1_491) AT=210.025n

.meas tran vdout1_492ck410 FIND v(dout1_492) AT=210.025n

.meas tran vdout1_493ck410 FIND v(dout1_493) AT=210.025n

.meas tran vdout1_494ck410 FIND v(dout1_494) AT=210.025n

.meas tran vdout1_495ck410 FIND v(dout1_495) AT=210.025n

.meas tran vdout1_496ck410 FIND v(dout1_496) AT=210.025n

.meas tran vdout1_497ck410 FIND v(dout1_497) AT=210.025n

.meas tran vdout1_498ck410 FIND v(dout1_498) AT=210.025n

.meas tran vdout1_499ck410 FIND v(dout1_499) AT=210.025n

.meas tran vdout1_500ck410 FIND v(dout1_500) AT=210.025n

.meas tran vdout1_501ck410 FIND v(dout1_501) AT=210.025n

.meas tran vdout1_502ck410 FIND v(dout1_502) AT=210.025n

.meas tran vdout1_503ck410 FIND v(dout1_503) AT=210.025n

.meas tran vdout1_504ck410 FIND v(dout1_504) AT=210.025n

.meas tran vdout1_505ck410 FIND v(dout1_505) AT=210.025n

.meas tran vdout1_506ck410 FIND v(dout1_506) AT=210.025n

.meas tran vdout1_507ck410 FIND v(dout1_507) AT=210.025n

.meas tran vdout1_508ck410 FIND v(dout1_508) AT=210.025n

.meas tran vdout1_509ck410 FIND v(dout1_509) AT=210.025n

.meas tran vdout1_510ck410 FIND v(dout1_510) AT=210.025n

.meas tran vdout1_511ck410 FIND v(dout1_511) AT=210.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_32ck450 FIND v(dout1_32) AT=230.025n

.meas tran vdout1_33ck450 FIND v(dout1_33) AT=230.025n

.meas tran vdout1_34ck450 FIND v(dout1_34) AT=230.025n

.meas tran vdout1_35ck450 FIND v(dout1_35) AT=230.025n

.meas tran vdout1_36ck450 FIND v(dout1_36) AT=230.025n

.meas tran vdout1_37ck450 FIND v(dout1_37) AT=230.025n

.meas tran vdout1_38ck450 FIND v(dout1_38) AT=230.025n

.meas tran vdout1_39ck450 FIND v(dout1_39) AT=230.025n

.meas tran vdout1_40ck450 FIND v(dout1_40) AT=230.025n

.meas tran vdout1_41ck450 FIND v(dout1_41) AT=230.025n

.meas tran vdout1_42ck450 FIND v(dout1_42) AT=230.025n

.meas tran vdout1_43ck450 FIND v(dout1_43) AT=230.025n

.meas tran vdout1_44ck450 FIND v(dout1_44) AT=230.025n

.meas tran vdout1_45ck450 FIND v(dout1_45) AT=230.025n

.meas tran vdout1_46ck450 FIND v(dout1_46) AT=230.025n

.meas tran vdout1_47ck450 FIND v(dout1_47) AT=230.025n

.meas tran vdout1_48ck450 FIND v(dout1_48) AT=230.025n

.meas tran vdout1_49ck450 FIND v(dout1_49) AT=230.025n

.meas tran vdout1_50ck450 FIND v(dout1_50) AT=230.025n

.meas tran vdout1_51ck450 FIND v(dout1_51) AT=230.025n

.meas tran vdout1_52ck450 FIND v(dout1_52) AT=230.025n

.meas tran vdout1_53ck450 FIND v(dout1_53) AT=230.025n

.meas tran vdout1_54ck450 FIND v(dout1_54) AT=230.025n

.meas tran vdout1_55ck450 FIND v(dout1_55) AT=230.025n

.meas tran vdout1_56ck450 FIND v(dout1_56) AT=230.025n

.meas tran vdout1_57ck450 FIND v(dout1_57) AT=230.025n

.meas tran vdout1_58ck450 FIND v(dout1_58) AT=230.025n

.meas tran vdout1_59ck450 FIND v(dout1_59) AT=230.025n

.meas tran vdout1_60ck450 FIND v(dout1_60) AT=230.025n

.meas tran vdout1_61ck450 FIND v(dout1_61) AT=230.025n

.meas tran vdout1_62ck450 FIND v(dout1_62) AT=230.025n

.meas tran vdout1_63ck450 FIND v(dout1_63) AT=230.025n

.meas tran vdout1_64ck450 FIND v(dout1_64) AT=230.025n

.meas tran vdout1_65ck450 FIND v(dout1_65) AT=230.025n

.meas tran vdout1_66ck450 FIND v(dout1_66) AT=230.025n

.meas tran vdout1_67ck450 FIND v(dout1_67) AT=230.025n

.meas tran vdout1_68ck450 FIND v(dout1_68) AT=230.025n

.meas tran vdout1_69ck450 FIND v(dout1_69) AT=230.025n

.meas tran vdout1_70ck450 FIND v(dout1_70) AT=230.025n

.meas tran vdout1_71ck450 FIND v(dout1_71) AT=230.025n

.meas tran vdout1_72ck450 FIND v(dout1_72) AT=230.025n

.meas tran vdout1_73ck450 FIND v(dout1_73) AT=230.025n

.meas tran vdout1_74ck450 FIND v(dout1_74) AT=230.025n

.meas tran vdout1_75ck450 FIND v(dout1_75) AT=230.025n

.meas tran vdout1_76ck450 FIND v(dout1_76) AT=230.025n

.meas tran vdout1_77ck450 FIND v(dout1_77) AT=230.025n

.meas tran vdout1_78ck450 FIND v(dout1_78) AT=230.025n

.meas tran vdout1_79ck450 FIND v(dout1_79) AT=230.025n

.meas tran vdout1_80ck450 FIND v(dout1_80) AT=230.025n

.meas tran vdout1_81ck450 FIND v(dout1_81) AT=230.025n

.meas tran vdout1_82ck450 FIND v(dout1_82) AT=230.025n

.meas tran vdout1_83ck450 FIND v(dout1_83) AT=230.025n

.meas tran vdout1_84ck450 FIND v(dout1_84) AT=230.025n

.meas tran vdout1_85ck450 FIND v(dout1_85) AT=230.025n

.meas tran vdout1_86ck450 FIND v(dout1_86) AT=230.025n

.meas tran vdout1_87ck450 FIND v(dout1_87) AT=230.025n

.meas tran vdout1_88ck450 FIND v(dout1_88) AT=230.025n

.meas tran vdout1_89ck450 FIND v(dout1_89) AT=230.025n

.meas tran vdout1_90ck450 FIND v(dout1_90) AT=230.025n

.meas tran vdout1_91ck450 FIND v(dout1_91) AT=230.025n

.meas tran vdout1_92ck450 FIND v(dout1_92) AT=230.025n

.meas tran vdout1_93ck450 FIND v(dout1_93) AT=230.025n

.meas tran vdout1_94ck450 FIND v(dout1_94) AT=230.025n

.meas tran vdout1_95ck450 FIND v(dout1_95) AT=230.025n

.meas tran vdout1_96ck450 FIND v(dout1_96) AT=230.025n

.meas tran vdout1_97ck450 FIND v(dout1_97) AT=230.025n

.meas tran vdout1_98ck450 FIND v(dout1_98) AT=230.025n

.meas tran vdout1_99ck450 FIND v(dout1_99) AT=230.025n

.meas tran vdout1_100ck450 FIND v(dout1_100) AT=230.025n

.meas tran vdout1_101ck450 FIND v(dout1_101) AT=230.025n

.meas tran vdout1_102ck450 FIND v(dout1_102) AT=230.025n

.meas tran vdout1_103ck450 FIND v(dout1_103) AT=230.025n

.meas tran vdout1_104ck450 FIND v(dout1_104) AT=230.025n

.meas tran vdout1_105ck450 FIND v(dout1_105) AT=230.025n

.meas tran vdout1_106ck450 FIND v(dout1_106) AT=230.025n

.meas tran vdout1_107ck450 FIND v(dout1_107) AT=230.025n

.meas tran vdout1_108ck450 FIND v(dout1_108) AT=230.025n

.meas tran vdout1_109ck450 FIND v(dout1_109) AT=230.025n

.meas tran vdout1_110ck450 FIND v(dout1_110) AT=230.025n

.meas tran vdout1_111ck450 FIND v(dout1_111) AT=230.025n

.meas tran vdout1_112ck450 FIND v(dout1_112) AT=230.025n

.meas tran vdout1_113ck450 FIND v(dout1_113) AT=230.025n

.meas tran vdout1_114ck450 FIND v(dout1_114) AT=230.025n

.meas tran vdout1_115ck450 FIND v(dout1_115) AT=230.025n

.meas tran vdout1_116ck450 FIND v(dout1_116) AT=230.025n

.meas tran vdout1_117ck450 FIND v(dout1_117) AT=230.025n

.meas tran vdout1_118ck450 FIND v(dout1_118) AT=230.025n

.meas tran vdout1_119ck450 FIND v(dout1_119) AT=230.025n

.meas tran vdout1_120ck450 FIND v(dout1_120) AT=230.025n

.meas tran vdout1_121ck450 FIND v(dout1_121) AT=230.025n

.meas tran vdout1_122ck450 FIND v(dout1_122) AT=230.025n

.meas tran vdout1_123ck450 FIND v(dout1_123) AT=230.025n

.meas tran vdout1_124ck450 FIND v(dout1_124) AT=230.025n

.meas tran vdout1_125ck450 FIND v(dout1_125) AT=230.025n

.meas tran vdout1_126ck450 FIND v(dout1_126) AT=230.025n

.meas tran vdout1_127ck450 FIND v(dout1_127) AT=230.025n

.meas tran vdout1_128ck450 FIND v(dout1_128) AT=230.025n

.meas tran vdout1_129ck450 FIND v(dout1_129) AT=230.025n

.meas tran vdout1_130ck450 FIND v(dout1_130) AT=230.025n

.meas tran vdout1_131ck450 FIND v(dout1_131) AT=230.025n

.meas tran vdout1_132ck450 FIND v(dout1_132) AT=230.025n

.meas tran vdout1_133ck450 FIND v(dout1_133) AT=230.025n

.meas tran vdout1_134ck450 FIND v(dout1_134) AT=230.025n

.meas tran vdout1_135ck450 FIND v(dout1_135) AT=230.025n

.meas tran vdout1_136ck450 FIND v(dout1_136) AT=230.025n

.meas tran vdout1_137ck450 FIND v(dout1_137) AT=230.025n

.meas tran vdout1_138ck450 FIND v(dout1_138) AT=230.025n

.meas tran vdout1_139ck450 FIND v(dout1_139) AT=230.025n

.meas tran vdout1_140ck450 FIND v(dout1_140) AT=230.025n

.meas tran vdout1_141ck450 FIND v(dout1_141) AT=230.025n

.meas tran vdout1_142ck450 FIND v(dout1_142) AT=230.025n

.meas tran vdout1_143ck450 FIND v(dout1_143) AT=230.025n

.meas tran vdout1_144ck450 FIND v(dout1_144) AT=230.025n

.meas tran vdout1_145ck450 FIND v(dout1_145) AT=230.025n

.meas tran vdout1_146ck450 FIND v(dout1_146) AT=230.025n

.meas tran vdout1_147ck450 FIND v(dout1_147) AT=230.025n

.meas tran vdout1_148ck450 FIND v(dout1_148) AT=230.025n

.meas tran vdout1_149ck450 FIND v(dout1_149) AT=230.025n

.meas tran vdout1_150ck450 FIND v(dout1_150) AT=230.025n

.meas tran vdout1_151ck450 FIND v(dout1_151) AT=230.025n

.meas tran vdout1_152ck450 FIND v(dout1_152) AT=230.025n

.meas tran vdout1_153ck450 FIND v(dout1_153) AT=230.025n

.meas tran vdout1_154ck450 FIND v(dout1_154) AT=230.025n

.meas tran vdout1_155ck450 FIND v(dout1_155) AT=230.025n

.meas tran vdout1_156ck450 FIND v(dout1_156) AT=230.025n

.meas tran vdout1_157ck450 FIND v(dout1_157) AT=230.025n

.meas tran vdout1_158ck450 FIND v(dout1_158) AT=230.025n

.meas tran vdout1_159ck450 FIND v(dout1_159) AT=230.025n

.meas tran vdout1_160ck450 FIND v(dout1_160) AT=230.025n

.meas tran vdout1_161ck450 FIND v(dout1_161) AT=230.025n

.meas tran vdout1_162ck450 FIND v(dout1_162) AT=230.025n

.meas tran vdout1_163ck450 FIND v(dout1_163) AT=230.025n

.meas tran vdout1_164ck450 FIND v(dout1_164) AT=230.025n

.meas tran vdout1_165ck450 FIND v(dout1_165) AT=230.025n

.meas tran vdout1_166ck450 FIND v(dout1_166) AT=230.025n

.meas tran vdout1_167ck450 FIND v(dout1_167) AT=230.025n

.meas tran vdout1_168ck450 FIND v(dout1_168) AT=230.025n

.meas tran vdout1_169ck450 FIND v(dout1_169) AT=230.025n

.meas tran vdout1_170ck450 FIND v(dout1_170) AT=230.025n

.meas tran vdout1_171ck450 FIND v(dout1_171) AT=230.025n

.meas tran vdout1_172ck450 FIND v(dout1_172) AT=230.025n

.meas tran vdout1_173ck450 FIND v(dout1_173) AT=230.025n

.meas tran vdout1_174ck450 FIND v(dout1_174) AT=230.025n

.meas tran vdout1_175ck450 FIND v(dout1_175) AT=230.025n

.meas tran vdout1_176ck450 FIND v(dout1_176) AT=230.025n

.meas tran vdout1_177ck450 FIND v(dout1_177) AT=230.025n

.meas tran vdout1_178ck450 FIND v(dout1_178) AT=230.025n

.meas tran vdout1_179ck450 FIND v(dout1_179) AT=230.025n

.meas tran vdout1_180ck450 FIND v(dout1_180) AT=230.025n

.meas tran vdout1_181ck450 FIND v(dout1_181) AT=230.025n

.meas tran vdout1_182ck450 FIND v(dout1_182) AT=230.025n

.meas tran vdout1_183ck450 FIND v(dout1_183) AT=230.025n

.meas tran vdout1_184ck450 FIND v(dout1_184) AT=230.025n

.meas tran vdout1_185ck450 FIND v(dout1_185) AT=230.025n

.meas tran vdout1_186ck450 FIND v(dout1_186) AT=230.025n

.meas tran vdout1_187ck450 FIND v(dout1_187) AT=230.025n

.meas tran vdout1_188ck450 FIND v(dout1_188) AT=230.025n

.meas tran vdout1_189ck450 FIND v(dout1_189) AT=230.025n

.meas tran vdout1_190ck450 FIND v(dout1_190) AT=230.025n

.meas tran vdout1_191ck450 FIND v(dout1_191) AT=230.025n

.meas tran vdout1_192ck450 FIND v(dout1_192) AT=230.025n

.meas tran vdout1_193ck450 FIND v(dout1_193) AT=230.025n

.meas tran vdout1_194ck450 FIND v(dout1_194) AT=230.025n

.meas tran vdout1_195ck450 FIND v(dout1_195) AT=230.025n

.meas tran vdout1_196ck450 FIND v(dout1_196) AT=230.025n

.meas tran vdout1_197ck450 FIND v(dout1_197) AT=230.025n

.meas tran vdout1_198ck450 FIND v(dout1_198) AT=230.025n

.meas tran vdout1_199ck450 FIND v(dout1_199) AT=230.025n

.meas tran vdout1_200ck450 FIND v(dout1_200) AT=230.025n

.meas tran vdout1_201ck450 FIND v(dout1_201) AT=230.025n

.meas tran vdout1_202ck450 FIND v(dout1_202) AT=230.025n

.meas tran vdout1_203ck450 FIND v(dout1_203) AT=230.025n

.meas tran vdout1_204ck450 FIND v(dout1_204) AT=230.025n

.meas tran vdout1_205ck450 FIND v(dout1_205) AT=230.025n

.meas tran vdout1_206ck450 FIND v(dout1_206) AT=230.025n

.meas tran vdout1_207ck450 FIND v(dout1_207) AT=230.025n

.meas tran vdout1_208ck450 FIND v(dout1_208) AT=230.025n

.meas tran vdout1_209ck450 FIND v(dout1_209) AT=230.025n

.meas tran vdout1_210ck450 FIND v(dout1_210) AT=230.025n

.meas tran vdout1_211ck450 FIND v(dout1_211) AT=230.025n

.meas tran vdout1_212ck450 FIND v(dout1_212) AT=230.025n

.meas tran vdout1_213ck450 FIND v(dout1_213) AT=230.025n

.meas tran vdout1_214ck450 FIND v(dout1_214) AT=230.025n

.meas tran vdout1_215ck450 FIND v(dout1_215) AT=230.025n

.meas tran vdout1_216ck450 FIND v(dout1_216) AT=230.025n

.meas tran vdout1_217ck450 FIND v(dout1_217) AT=230.025n

.meas tran vdout1_218ck450 FIND v(dout1_218) AT=230.025n

.meas tran vdout1_219ck450 FIND v(dout1_219) AT=230.025n

.meas tran vdout1_220ck450 FIND v(dout1_220) AT=230.025n

.meas tran vdout1_221ck450 FIND v(dout1_221) AT=230.025n

.meas tran vdout1_222ck450 FIND v(dout1_222) AT=230.025n

.meas tran vdout1_223ck450 FIND v(dout1_223) AT=230.025n

.meas tran vdout1_224ck450 FIND v(dout1_224) AT=230.025n

.meas tran vdout1_225ck450 FIND v(dout1_225) AT=230.025n

.meas tran vdout1_226ck450 FIND v(dout1_226) AT=230.025n

.meas tran vdout1_227ck450 FIND v(dout1_227) AT=230.025n

.meas tran vdout1_228ck450 FIND v(dout1_228) AT=230.025n

.meas tran vdout1_229ck450 FIND v(dout1_229) AT=230.025n

.meas tran vdout1_230ck450 FIND v(dout1_230) AT=230.025n

.meas tran vdout1_231ck450 FIND v(dout1_231) AT=230.025n

.meas tran vdout1_232ck450 FIND v(dout1_232) AT=230.025n

.meas tran vdout1_233ck450 FIND v(dout1_233) AT=230.025n

.meas tran vdout1_234ck450 FIND v(dout1_234) AT=230.025n

.meas tran vdout1_235ck450 FIND v(dout1_235) AT=230.025n

.meas tran vdout1_236ck450 FIND v(dout1_236) AT=230.025n

.meas tran vdout1_237ck450 FIND v(dout1_237) AT=230.025n

.meas tran vdout1_238ck450 FIND v(dout1_238) AT=230.025n

.meas tran vdout1_239ck450 FIND v(dout1_239) AT=230.025n

.meas tran vdout1_240ck450 FIND v(dout1_240) AT=230.025n

.meas tran vdout1_241ck450 FIND v(dout1_241) AT=230.025n

.meas tran vdout1_242ck450 FIND v(dout1_242) AT=230.025n

.meas tran vdout1_243ck450 FIND v(dout1_243) AT=230.025n

.meas tran vdout1_244ck450 FIND v(dout1_244) AT=230.025n

.meas tran vdout1_245ck450 FIND v(dout1_245) AT=230.025n

.meas tran vdout1_246ck450 FIND v(dout1_246) AT=230.025n

.meas tran vdout1_247ck450 FIND v(dout1_247) AT=230.025n

.meas tran vdout1_248ck450 FIND v(dout1_248) AT=230.025n

.meas tran vdout1_249ck450 FIND v(dout1_249) AT=230.025n

.meas tran vdout1_250ck450 FIND v(dout1_250) AT=230.025n

.meas tran vdout1_251ck450 FIND v(dout1_251) AT=230.025n

.meas tran vdout1_252ck450 FIND v(dout1_252) AT=230.025n

.meas tran vdout1_253ck450 FIND v(dout1_253) AT=230.025n

.meas tran vdout1_254ck450 FIND v(dout1_254) AT=230.025n

.meas tran vdout1_255ck450 FIND v(dout1_255) AT=230.025n

.meas tran vdout1_256ck450 FIND v(dout1_256) AT=230.025n

.meas tran vdout1_257ck450 FIND v(dout1_257) AT=230.025n

.meas tran vdout1_258ck450 FIND v(dout1_258) AT=230.025n

.meas tran vdout1_259ck450 FIND v(dout1_259) AT=230.025n

.meas tran vdout1_260ck450 FIND v(dout1_260) AT=230.025n

.meas tran vdout1_261ck450 FIND v(dout1_261) AT=230.025n

.meas tran vdout1_262ck450 FIND v(dout1_262) AT=230.025n

.meas tran vdout1_263ck450 FIND v(dout1_263) AT=230.025n

.meas tran vdout1_264ck450 FIND v(dout1_264) AT=230.025n

.meas tran vdout1_265ck450 FIND v(dout1_265) AT=230.025n

.meas tran vdout1_266ck450 FIND v(dout1_266) AT=230.025n

.meas tran vdout1_267ck450 FIND v(dout1_267) AT=230.025n

.meas tran vdout1_268ck450 FIND v(dout1_268) AT=230.025n

.meas tran vdout1_269ck450 FIND v(dout1_269) AT=230.025n

.meas tran vdout1_270ck450 FIND v(dout1_270) AT=230.025n

.meas tran vdout1_271ck450 FIND v(dout1_271) AT=230.025n

.meas tran vdout1_272ck450 FIND v(dout1_272) AT=230.025n

.meas tran vdout1_273ck450 FIND v(dout1_273) AT=230.025n

.meas tran vdout1_274ck450 FIND v(dout1_274) AT=230.025n

.meas tran vdout1_275ck450 FIND v(dout1_275) AT=230.025n

.meas tran vdout1_276ck450 FIND v(dout1_276) AT=230.025n

.meas tran vdout1_277ck450 FIND v(dout1_277) AT=230.025n

.meas tran vdout1_278ck450 FIND v(dout1_278) AT=230.025n

.meas tran vdout1_279ck450 FIND v(dout1_279) AT=230.025n

.meas tran vdout1_280ck450 FIND v(dout1_280) AT=230.025n

.meas tran vdout1_281ck450 FIND v(dout1_281) AT=230.025n

.meas tran vdout1_282ck450 FIND v(dout1_282) AT=230.025n

.meas tran vdout1_283ck450 FIND v(dout1_283) AT=230.025n

.meas tran vdout1_284ck450 FIND v(dout1_284) AT=230.025n

.meas tran vdout1_285ck450 FIND v(dout1_285) AT=230.025n

.meas tran vdout1_286ck450 FIND v(dout1_286) AT=230.025n

.meas tran vdout1_287ck450 FIND v(dout1_287) AT=230.025n

.meas tran vdout1_288ck450 FIND v(dout1_288) AT=230.025n

.meas tran vdout1_289ck450 FIND v(dout1_289) AT=230.025n

.meas tran vdout1_290ck450 FIND v(dout1_290) AT=230.025n

.meas tran vdout1_291ck450 FIND v(dout1_291) AT=230.025n

.meas tran vdout1_292ck450 FIND v(dout1_292) AT=230.025n

.meas tran vdout1_293ck450 FIND v(dout1_293) AT=230.025n

.meas tran vdout1_294ck450 FIND v(dout1_294) AT=230.025n

.meas tran vdout1_295ck450 FIND v(dout1_295) AT=230.025n

.meas tran vdout1_296ck450 FIND v(dout1_296) AT=230.025n

.meas tran vdout1_297ck450 FIND v(dout1_297) AT=230.025n

.meas tran vdout1_298ck450 FIND v(dout1_298) AT=230.025n

.meas tran vdout1_299ck450 FIND v(dout1_299) AT=230.025n

.meas tran vdout1_300ck450 FIND v(dout1_300) AT=230.025n

.meas tran vdout1_301ck450 FIND v(dout1_301) AT=230.025n

.meas tran vdout1_302ck450 FIND v(dout1_302) AT=230.025n

.meas tran vdout1_303ck450 FIND v(dout1_303) AT=230.025n

.meas tran vdout1_304ck450 FIND v(dout1_304) AT=230.025n

.meas tran vdout1_305ck450 FIND v(dout1_305) AT=230.025n

.meas tran vdout1_306ck450 FIND v(dout1_306) AT=230.025n

.meas tran vdout1_307ck450 FIND v(dout1_307) AT=230.025n

.meas tran vdout1_308ck450 FIND v(dout1_308) AT=230.025n

.meas tran vdout1_309ck450 FIND v(dout1_309) AT=230.025n

.meas tran vdout1_310ck450 FIND v(dout1_310) AT=230.025n

.meas tran vdout1_311ck450 FIND v(dout1_311) AT=230.025n

.meas tran vdout1_312ck450 FIND v(dout1_312) AT=230.025n

.meas tran vdout1_313ck450 FIND v(dout1_313) AT=230.025n

.meas tran vdout1_314ck450 FIND v(dout1_314) AT=230.025n

.meas tran vdout1_315ck450 FIND v(dout1_315) AT=230.025n

.meas tran vdout1_316ck450 FIND v(dout1_316) AT=230.025n

.meas tran vdout1_317ck450 FIND v(dout1_317) AT=230.025n

.meas tran vdout1_318ck450 FIND v(dout1_318) AT=230.025n

.meas tran vdout1_319ck450 FIND v(dout1_319) AT=230.025n

.meas tran vdout1_320ck450 FIND v(dout1_320) AT=230.025n

.meas tran vdout1_321ck450 FIND v(dout1_321) AT=230.025n

.meas tran vdout1_322ck450 FIND v(dout1_322) AT=230.025n

.meas tran vdout1_323ck450 FIND v(dout1_323) AT=230.025n

.meas tran vdout1_324ck450 FIND v(dout1_324) AT=230.025n

.meas tran vdout1_325ck450 FIND v(dout1_325) AT=230.025n

.meas tran vdout1_326ck450 FIND v(dout1_326) AT=230.025n

.meas tran vdout1_327ck450 FIND v(dout1_327) AT=230.025n

.meas tran vdout1_328ck450 FIND v(dout1_328) AT=230.025n

.meas tran vdout1_329ck450 FIND v(dout1_329) AT=230.025n

.meas tran vdout1_330ck450 FIND v(dout1_330) AT=230.025n

.meas tran vdout1_331ck450 FIND v(dout1_331) AT=230.025n

.meas tran vdout1_332ck450 FIND v(dout1_332) AT=230.025n

.meas tran vdout1_333ck450 FIND v(dout1_333) AT=230.025n

.meas tran vdout1_334ck450 FIND v(dout1_334) AT=230.025n

.meas tran vdout1_335ck450 FIND v(dout1_335) AT=230.025n

.meas tran vdout1_336ck450 FIND v(dout1_336) AT=230.025n

.meas tran vdout1_337ck450 FIND v(dout1_337) AT=230.025n

.meas tran vdout1_338ck450 FIND v(dout1_338) AT=230.025n

.meas tran vdout1_339ck450 FIND v(dout1_339) AT=230.025n

.meas tran vdout1_340ck450 FIND v(dout1_340) AT=230.025n

.meas tran vdout1_341ck450 FIND v(dout1_341) AT=230.025n

.meas tran vdout1_342ck450 FIND v(dout1_342) AT=230.025n

.meas tran vdout1_343ck450 FIND v(dout1_343) AT=230.025n

.meas tran vdout1_344ck450 FIND v(dout1_344) AT=230.025n

.meas tran vdout1_345ck450 FIND v(dout1_345) AT=230.025n

.meas tran vdout1_346ck450 FIND v(dout1_346) AT=230.025n

.meas tran vdout1_347ck450 FIND v(dout1_347) AT=230.025n

.meas tran vdout1_348ck450 FIND v(dout1_348) AT=230.025n

.meas tran vdout1_349ck450 FIND v(dout1_349) AT=230.025n

.meas tran vdout1_350ck450 FIND v(dout1_350) AT=230.025n

.meas tran vdout1_351ck450 FIND v(dout1_351) AT=230.025n

.meas tran vdout1_352ck450 FIND v(dout1_352) AT=230.025n

.meas tran vdout1_353ck450 FIND v(dout1_353) AT=230.025n

.meas tran vdout1_354ck450 FIND v(dout1_354) AT=230.025n

.meas tran vdout1_355ck450 FIND v(dout1_355) AT=230.025n

.meas tran vdout1_356ck450 FIND v(dout1_356) AT=230.025n

.meas tran vdout1_357ck450 FIND v(dout1_357) AT=230.025n

.meas tran vdout1_358ck450 FIND v(dout1_358) AT=230.025n

.meas tran vdout1_359ck450 FIND v(dout1_359) AT=230.025n

.meas tran vdout1_360ck450 FIND v(dout1_360) AT=230.025n

.meas tran vdout1_361ck450 FIND v(dout1_361) AT=230.025n

.meas tran vdout1_362ck450 FIND v(dout1_362) AT=230.025n

.meas tran vdout1_363ck450 FIND v(dout1_363) AT=230.025n

.meas tran vdout1_364ck450 FIND v(dout1_364) AT=230.025n

.meas tran vdout1_365ck450 FIND v(dout1_365) AT=230.025n

.meas tran vdout1_366ck450 FIND v(dout1_366) AT=230.025n

.meas tran vdout1_367ck450 FIND v(dout1_367) AT=230.025n

.meas tran vdout1_368ck450 FIND v(dout1_368) AT=230.025n

.meas tran vdout1_369ck450 FIND v(dout1_369) AT=230.025n

.meas tran vdout1_370ck450 FIND v(dout1_370) AT=230.025n

.meas tran vdout1_371ck450 FIND v(dout1_371) AT=230.025n

.meas tran vdout1_372ck450 FIND v(dout1_372) AT=230.025n

.meas tran vdout1_373ck450 FIND v(dout1_373) AT=230.025n

.meas tran vdout1_374ck450 FIND v(dout1_374) AT=230.025n

.meas tran vdout1_375ck450 FIND v(dout1_375) AT=230.025n

.meas tran vdout1_376ck450 FIND v(dout1_376) AT=230.025n

.meas tran vdout1_377ck450 FIND v(dout1_377) AT=230.025n

.meas tran vdout1_378ck450 FIND v(dout1_378) AT=230.025n

.meas tran vdout1_379ck450 FIND v(dout1_379) AT=230.025n

.meas tran vdout1_380ck450 FIND v(dout1_380) AT=230.025n

.meas tran vdout1_381ck450 FIND v(dout1_381) AT=230.025n

.meas tran vdout1_382ck450 FIND v(dout1_382) AT=230.025n

.meas tran vdout1_383ck450 FIND v(dout1_383) AT=230.025n

.meas tran vdout1_384ck450 FIND v(dout1_384) AT=230.025n

.meas tran vdout1_385ck450 FIND v(dout1_385) AT=230.025n

.meas tran vdout1_386ck450 FIND v(dout1_386) AT=230.025n

.meas tran vdout1_387ck450 FIND v(dout1_387) AT=230.025n

.meas tran vdout1_388ck450 FIND v(dout1_388) AT=230.025n

.meas tran vdout1_389ck450 FIND v(dout1_389) AT=230.025n

.meas tran vdout1_390ck450 FIND v(dout1_390) AT=230.025n

.meas tran vdout1_391ck450 FIND v(dout1_391) AT=230.025n

.meas tran vdout1_392ck450 FIND v(dout1_392) AT=230.025n

.meas tran vdout1_393ck450 FIND v(dout1_393) AT=230.025n

.meas tran vdout1_394ck450 FIND v(dout1_394) AT=230.025n

.meas tran vdout1_395ck450 FIND v(dout1_395) AT=230.025n

.meas tran vdout1_396ck450 FIND v(dout1_396) AT=230.025n

.meas tran vdout1_397ck450 FIND v(dout1_397) AT=230.025n

.meas tran vdout1_398ck450 FIND v(dout1_398) AT=230.025n

.meas tran vdout1_399ck450 FIND v(dout1_399) AT=230.025n

.meas tran vdout1_400ck450 FIND v(dout1_400) AT=230.025n

.meas tran vdout1_401ck450 FIND v(dout1_401) AT=230.025n

.meas tran vdout1_402ck450 FIND v(dout1_402) AT=230.025n

.meas tran vdout1_403ck450 FIND v(dout1_403) AT=230.025n

.meas tran vdout1_404ck450 FIND v(dout1_404) AT=230.025n

.meas tran vdout1_405ck450 FIND v(dout1_405) AT=230.025n

.meas tran vdout1_406ck450 FIND v(dout1_406) AT=230.025n

.meas tran vdout1_407ck450 FIND v(dout1_407) AT=230.025n

.meas tran vdout1_408ck450 FIND v(dout1_408) AT=230.025n

.meas tran vdout1_409ck450 FIND v(dout1_409) AT=230.025n

.meas tran vdout1_410ck450 FIND v(dout1_410) AT=230.025n

.meas tran vdout1_411ck450 FIND v(dout1_411) AT=230.025n

.meas tran vdout1_412ck450 FIND v(dout1_412) AT=230.025n

.meas tran vdout1_413ck450 FIND v(dout1_413) AT=230.025n

.meas tran vdout1_414ck450 FIND v(dout1_414) AT=230.025n

.meas tran vdout1_415ck450 FIND v(dout1_415) AT=230.025n

.meas tran vdout1_416ck450 FIND v(dout1_416) AT=230.025n

.meas tran vdout1_417ck450 FIND v(dout1_417) AT=230.025n

.meas tran vdout1_418ck450 FIND v(dout1_418) AT=230.025n

.meas tran vdout1_419ck450 FIND v(dout1_419) AT=230.025n

.meas tran vdout1_420ck450 FIND v(dout1_420) AT=230.025n

.meas tran vdout1_421ck450 FIND v(dout1_421) AT=230.025n

.meas tran vdout1_422ck450 FIND v(dout1_422) AT=230.025n

.meas tran vdout1_423ck450 FIND v(dout1_423) AT=230.025n

.meas tran vdout1_424ck450 FIND v(dout1_424) AT=230.025n

.meas tran vdout1_425ck450 FIND v(dout1_425) AT=230.025n

.meas tran vdout1_426ck450 FIND v(dout1_426) AT=230.025n

.meas tran vdout1_427ck450 FIND v(dout1_427) AT=230.025n

.meas tran vdout1_428ck450 FIND v(dout1_428) AT=230.025n

.meas tran vdout1_429ck450 FIND v(dout1_429) AT=230.025n

.meas tran vdout1_430ck450 FIND v(dout1_430) AT=230.025n

.meas tran vdout1_431ck450 FIND v(dout1_431) AT=230.025n

.meas tran vdout1_432ck450 FIND v(dout1_432) AT=230.025n

.meas tran vdout1_433ck450 FIND v(dout1_433) AT=230.025n

.meas tran vdout1_434ck450 FIND v(dout1_434) AT=230.025n

.meas tran vdout1_435ck450 FIND v(dout1_435) AT=230.025n

.meas tran vdout1_436ck450 FIND v(dout1_436) AT=230.025n

.meas tran vdout1_437ck450 FIND v(dout1_437) AT=230.025n

.meas tran vdout1_438ck450 FIND v(dout1_438) AT=230.025n

.meas tran vdout1_439ck450 FIND v(dout1_439) AT=230.025n

.meas tran vdout1_440ck450 FIND v(dout1_440) AT=230.025n

.meas tran vdout1_441ck450 FIND v(dout1_441) AT=230.025n

.meas tran vdout1_442ck450 FIND v(dout1_442) AT=230.025n

.meas tran vdout1_443ck450 FIND v(dout1_443) AT=230.025n

.meas tran vdout1_444ck450 FIND v(dout1_444) AT=230.025n

.meas tran vdout1_445ck450 FIND v(dout1_445) AT=230.025n

.meas tran vdout1_446ck450 FIND v(dout1_446) AT=230.025n

.meas tran vdout1_447ck450 FIND v(dout1_447) AT=230.025n

.meas tran vdout1_448ck450 FIND v(dout1_448) AT=230.025n

.meas tran vdout1_449ck450 FIND v(dout1_449) AT=230.025n

.meas tran vdout1_450ck450 FIND v(dout1_450) AT=230.025n

.meas tran vdout1_451ck450 FIND v(dout1_451) AT=230.025n

.meas tran vdout1_452ck450 FIND v(dout1_452) AT=230.025n

.meas tran vdout1_453ck450 FIND v(dout1_453) AT=230.025n

.meas tran vdout1_454ck450 FIND v(dout1_454) AT=230.025n

.meas tran vdout1_455ck450 FIND v(dout1_455) AT=230.025n

.meas tran vdout1_456ck450 FIND v(dout1_456) AT=230.025n

.meas tran vdout1_457ck450 FIND v(dout1_457) AT=230.025n

.meas tran vdout1_458ck450 FIND v(dout1_458) AT=230.025n

.meas tran vdout1_459ck450 FIND v(dout1_459) AT=230.025n

.meas tran vdout1_460ck450 FIND v(dout1_460) AT=230.025n

.meas tran vdout1_461ck450 FIND v(dout1_461) AT=230.025n

.meas tran vdout1_462ck450 FIND v(dout1_462) AT=230.025n

.meas tran vdout1_463ck450 FIND v(dout1_463) AT=230.025n

.meas tran vdout1_464ck450 FIND v(dout1_464) AT=230.025n

.meas tran vdout1_465ck450 FIND v(dout1_465) AT=230.025n

.meas tran vdout1_466ck450 FIND v(dout1_466) AT=230.025n

.meas tran vdout1_467ck450 FIND v(dout1_467) AT=230.025n

.meas tran vdout1_468ck450 FIND v(dout1_468) AT=230.025n

.meas tran vdout1_469ck450 FIND v(dout1_469) AT=230.025n

.meas tran vdout1_470ck450 FIND v(dout1_470) AT=230.025n

.meas tran vdout1_471ck450 FIND v(dout1_471) AT=230.025n

.meas tran vdout1_472ck450 FIND v(dout1_472) AT=230.025n

.meas tran vdout1_473ck450 FIND v(dout1_473) AT=230.025n

.meas tran vdout1_474ck450 FIND v(dout1_474) AT=230.025n

.meas tran vdout1_475ck450 FIND v(dout1_475) AT=230.025n

.meas tran vdout1_476ck450 FIND v(dout1_476) AT=230.025n

.meas tran vdout1_477ck450 FIND v(dout1_477) AT=230.025n

.meas tran vdout1_478ck450 FIND v(dout1_478) AT=230.025n

.meas tran vdout1_479ck450 FIND v(dout1_479) AT=230.025n

.meas tran vdout1_480ck450 FIND v(dout1_480) AT=230.025n

.meas tran vdout1_481ck450 FIND v(dout1_481) AT=230.025n

.meas tran vdout1_482ck450 FIND v(dout1_482) AT=230.025n

.meas tran vdout1_483ck450 FIND v(dout1_483) AT=230.025n

.meas tran vdout1_484ck450 FIND v(dout1_484) AT=230.025n

.meas tran vdout1_485ck450 FIND v(dout1_485) AT=230.025n

.meas tran vdout1_486ck450 FIND v(dout1_486) AT=230.025n

.meas tran vdout1_487ck450 FIND v(dout1_487) AT=230.025n

.meas tran vdout1_488ck450 FIND v(dout1_488) AT=230.025n

.meas tran vdout1_489ck450 FIND v(dout1_489) AT=230.025n

.meas tran vdout1_490ck450 FIND v(dout1_490) AT=230.025n

.meas tran vdout1_491ck450 FIND v(dout1_491) AT=230.025n

.meas tran vdout1_492ck450 FIND v(dout1_492) AT=230.025n

.meas tran vdout1_493ck450 FIND v(dout1_493) AT=230.025n

.meas tran vdout1_494ck450 FIND v(dout1_494) AT=230.025n

.meas tran vdout1_495ck450 FIND v(dout1_495) AT=230.025n

.meas tran vdout1_496ck450 FIND v(dout1_496) AT=230.025n

.meas tran vdout1_497ck450 FIND v(dout1_497) AT=230.025n

.meas tran vdout1_498ck450 FIND v(dout1_498) AT=230.025n

.meas tran vdout1_499ck450 FIND v(dout1_499) AT=230.025n

.meas tran vdout1_500ck450 FIND v(dout1_500) AT=230.025n

.meas tran vdout1_501ck450 FIND v(dout1_501) AT=230.025n

.meas tran vdout1_502ck450 FIND v(dout1_502) AT=230.025n

.meas tran vdout1_503ck450 FIND v(dout1_503) AT=230.025n

.meas tran vdout1_504ck450 FIND v(dout1_504) AT=230.025n

.meas tran vdout1_505ck450 FIND v(dout1_505) AT=230.025n

.meas tran vdout1_506ck450 FIND v(dout1_506) AT=230.025n

.meas tran vdout1_507ck450 FIND v(dout1_507) AT=230.025n

.meas tran vdout1_508ck450 FIND v(dout1_508) AT=230.025n

.meas tran vdout1_509ck450 FIND v(dout1_509) AT=230.025n

.meas tran vdout1_510ck450 FIND v(dout1_510) AT=230.025n

.meas tran vdout1_511ck450 FIND v(dout1_511) AT=230.025n

.meas tran vdout1_0ck500 FIND v(dout1_0) AT=255.025n

.meas tran vdout1_1ck500 FIND v(dout1_1) AT=255.025n

.meas tran vdout1_2ck500 FIND v(dout1_2) AT=255.025n

.meas tran vdout1_3ck500 FIND v(dout1_3) AT=255.025n

.meas tran vdout1_4ck500 FIND v(dout1_4) AT=255.025n

.meas tran vdout1_5ck500 FIND v(dout1_5) AT=255.025n

.meas tran vdout1_6ck500 FIND v(dout1_6) AT=255.025n

.meas tran vdout1_7ck500 FIND v(dout1_7) AT=255.025n

.meas tran vdout1_8ck500 FIND v(dout1_8) AT=255.025n

.meas tran vdout1_9ck500 FIND v(dout1_9) AT=255.025n

.meas tran vdout1_10ck500 FIND v(dout1_10) AT=255.025n

.meas tran vdout1_11ck500 FIND v(dout1_11) AT=255.025n

.meas tran vdout1_12ck500 FIND v(dout1_12) AT=255.025n

.meas tran vdout1_13ck500 FIND v(dout1_13) AT=255.025n

.meas tran vdout1_14ck500 FIND v(dout1_14) AT=255.025n

.meas tran vdout1_15ck500 FIND v(dout1_15) AT=255.025n

.meas tran vdout1_16ck500 FIND v(dout1_16) AT=255.025n

.meas tran vdout1_17ck500 FIND v(dout1_17) AT=255.025n

.meas tran vdout1_18ck500 FIND v(dout1_18) AT=255.025n

.meas tran vdout1_19ck500 FIND v(dout1_19) AT=255.025n

.meas tran vdout1_20ck500 FIND v(dout1_20) AT=255.025n

.meas tran vdout1_21ck500 FIND v(dout1_21) AT=255.025n

.meas tran vdout1_22ck500 FIND v(dout1_22) AT=255.025n

.meas tran vdout1_23ck500 FIND v(dout1_23) AT=255.025n

.meas tran vdout1_24ck500 FIND v(dout1_24) AT=255.025n

.meas tran vdout1_25ck500 FIND v(dout1_25) AT=255.025n

.meas tran vdout1_26ck500 FIND v(dout1_26) AT=255.025n

.meas tran vdout1_27ck500 FIND v(dout1_27) AT=255.025n

.meas tran vdout1_28ck500 FIND v(dout1_28) AT=255.025n

.meas tran vdout1_29ck500 FIND v(dout1_29) AT=255.025n

.meas tran vdout1_30ck500 FIND v(dout1_30) AT=255.025n

.meas tran vdout1_31ck500 FIND v(dout1_31) AT=255.025n

.meas tran vdout1_32ck500 FIND v(dout1_32) AT=255.025n

.meas tran vdout1_33ck500 FIND v(dout1_33) AT=255.025n

.meas tran vdout1_34ck500 FIND v(dout1_34) AT=255.025n

.meas tran vdout1_35ck500 FIND v(dout1_35) AT=255.025n

.meas tran vdout1_36ck500 FIND v(dout1_36) AT=255.025n

.meas tran vdout1_37ck500 FIND v(dout1_37) AT=255.025n

.meas tran vdout1_38ck500 FIND v(dout1_38) AT=255.025n

.meas tran vdout1_39ck500 FIND v(dout1_39) AT=255.025n

.meas tran vdout1_40ck500 FIND v(dout1_40) AT=255.025n

.meas tran vdout1_41ck500 FIND v(dout1_41) AT=255.025n

.meas tran vdout1_42ck500 FIND v(dout1_42) AT=255.025n

.meas tran vdout1_43ck500 FIND v(dout1_43) AT=255.025n

.meas tran vdout1_44ck500 FIND v(dout1_44) AT=255.025n

.meas tran vdout1_45ck500 FIND v(dout1_45) AT=255.025n

.meas tran vdout1_46ck500 FIND v(dout1_46) AT=255.025n

.meas tran vdout1_47ck500 FIND v(dout1_47) AT=255.025n

.meas tran vdout1_48ck500 FIND v(dout1_48) AT=255.025n

.meas tran vdout1_49ck500 FIND v(dout1_49) AT=255.025n

.meas tran vdout1_50ck500 FIND v(dout1_50) AT=255.025n

.meas tran vdout1_51ck500 FIND v(dout1_51) AT=255.025n

.meas tran vdout1_52ck500 FIND v(dout1_52) AT=255.025n

.meas tran vdout1_53ck500 FIND v(dout1_53) AT=255.025n

.meas tran vdout1_54ck500 FIND v(dout1_54) AT=255.025n

.meas tran vdout1_55ck500 FIND v(dout1_55) AT=255.025n

.meas tran vdout1_56ck500 FIND v(dout1_56) AT=255.025n

.meas tran vdout1_57ck500 FIND v(dout1_57) AT=255.025n

.meas tran vdout1_58ck500 FIND v(dout1_58) AT=255.025n

.meas tran vdout1_59ck500 FIND v(dout1_59) AT=255.025n

.meas tran vdout1_60ck500 FIND v(dout1_60) AT=255.025n

.meas tran vdout1_61ck500 FIND v(dout1_61) AT=255.025n

.meas tran vdout1_62ck500 FIND v(dout1_62) AT=255.025n

.meas tran vdout1_63ck500 FIND v(dout1_63) AT=255.025n

.meas tran vdout1_64ck500 FIND v(dout1_64) AT=255.025n

.meas tran vdout1_65ck500 FIND v(dout1_65) AT=255.025n

.meas tran vdout1_66ck500 FIND v(dout1_66) AT=255.025n

.meas tran vdout1_67ck500 FIND v(dout1_67) AT=255.025n

.meas tran vdout1_68ck500 FIND v(dout1_68) AT=255.025n

.meas tran vdout1_69ck500 FIND v(dout1_69) AT=255.025n

.meas tran vdout1_70ck500 FIND v(dout1_70) AT=255.025n

.meas tran vdout1_71ck500 FIND v(dout1_71) AT=255.025n

.meas tran vdout1_72ck500 FIND v(dout1_72) AT=255.025n

.meas tran vdout1_73ck500 FIND v(dout1_73) AT=255.025n

.meas tran vdout1_74ck500 FIND v(dout1_74) AT=255.025n

.meas tran vdout1_75ck500 FIND v(dout1_75) AT=255.025n

.meas tran vdout1_76ck500 FIND v(dout1_76) AT=255.025n

.meas tran vdout1_77ck500 FIND v(dout1_77) AT=255.025n

.meas tran vdout1_78ck500 FIND v(dout1_78) AT=255.025n

.meas tran vdout1_79ck500 FIND v(dout1_79) AT=255.025n

.meas tran vdout1_80ck500 FIND v(dout1_80) AT=255.025n

.meas tran vdout1_81ck500 FIND v(dout1_81) AT=255.025n

.meas tran vdout1_82ck500 FIND v(dout1_82) AT=255.025n

.meas tran vdout1_83ck500 FIND v(dout1_83) AT=255.025n

.meas tran vdout1_84ck500 FIND v(dout1_84) AT=255.025n

.meas tran vdout1_85ck500 FIND v(dout1_85) AT=255.025n

.meas tran vdout1_86ck500 FIND v(dout1_86) AT=255.025n

.meas tran vdout1_87ck500 FIND v(dout1_87) AT=255.025n

.meas tran vdout1_88ck500 FIND v(dout1_88) AT=255.025n

.meas tran vdout1_89ck500 FIND v(dout1_89) AT=255.025n

.meas tran vdout1_90ck500 FIND v(dout1_90) AT=255.025n

.meas tran vdout1_91ck500 FIND v(dout1_91) AT=255.025n

.meas tran vdout1_92ck500 FIND v(dout1_92) AT=255.025n

.meas tran vdout1_93ck500 FIND v(dout1_93) AT=255.025n

.meas tran vdout1_94ck500 FIND v(dout1_94) AT=255.025n

.meas tran vdout1_95ck500 FIND v(dout1_95) AT=255.025n

.meas tran vdout1_96ck500 FIND v(dout1_96) AT=255.025n

.meas tran vdout1_97ck500 FIND v(dout1_97) AT=255.025n

.meas tran vdout1_98ck500 FIND v(dout1_98) AT=255.025n

.meas tran vdout1_99ck500 FIND v(dout1_99) AT=255.025n

.meas tran vdout1_100ck500 FIND v(dout1_100) AT=255.025n

.meas tran vdout1_101ck500 FIND v(dout1_101) AT=255.025n

.meas tran vdout1_102ck500 FIND v(dout1_102) AT=255.025n

.meas tran vdout1_103ck500 FIND v(dout1_103) AT=255.025n

.meas tran vdout1_104ck500 FIND v(dout1_104) AT=255.025n

.meas tran vdout1_105ck500 FIND v(dout1_105) AT=255.025n

.meas tran vdout1_106ck500 FIND v(dout1_106) AT=255.025n

.meas tran vdout1_107ck500 FIND v(dout1_107) AT=255.025n

.meas tran vdout1_108ck500 FIND v(dout1_108) AT=255.025n

.meas tran vdout1_109ck500 FIND v(dout1_109) AT=255.025n

.meas tran vdout1_110ck500 FIND v(dout1_110) AT=255.025n

.meas tran vdout1_111ck500 FIND v(dout1_111) AT=255.025n

.meas tran vdout1_112ck500 FIND v(dout1_112) AT=255.025n

.meas tran vdout1_113ck500 FIND v(dout1_113) AT=255.025n

.meas tran vdout1_114ck500 FIND v(dout1_114) AT=255.025n

.meas tran vdout1_115ck500 FIND v(dout1_115) AT=255.025n

.meas tran vdout1_116ck500 FIND v(dout1_116) AT=255.025n

.meas tran vdout1_117ck500 FIND v(dout1_117) AT=255.025n

.meas tran vdout1_118ck500 FIND v(dout1_118) AT=255.025n

.meas tran vdout1_119ck500 FIND v(dout1_119) AT=255.025n

.meas tran vdout1_120ck500 FIND v(dout1_120) AT=255.025n

.meas tran vdout1_121ck500 FIND v(dout1_121) AT=255.025n

.meas tran vdout1_122ck500 FIND v(dout1_122) AT=255.025n

.meas tran vdout1_123ck500 FIND v(dout1_123) AT=255.025n

.meas tran vdout1_124ck500 FIND v(dout1_124) AT=255.025n

.meas tran vdout1_125ck500 FIND v(dout1_125) AT=255.025n

.meas tran vdout1_126ck500 FIND v(dout1_126) AT=255.025n

.meas tran vdout1_127ck500 FIND v(dout1_127) AT=255.025n

.meas tran vdout1_128ck500 FIND v(dout1_128) AT=255.025n

.meas tran vdout1_129ck500 FIND v(dout1_129) AT=255.025n

.meas tran vdout1_130ck500 FIND v(dout1_130) AT=255.025n

.meas tran vdout1_131ck500 FIND v(dout1_131) AT=255.025n

.meas tran vdout1_132ck500 FIND v(dout1_132) AT=255.025n

.meas tran vdout1_133ck500 FIND v(dout1_133) AT=255.025n

.meas tran vdout1_134ck500 FIND v(dout1_134) AT=255.025n

.meas tran vdout1_135ck500 FIND v(dout1_135) AT=255.025n

.meas tran vdout1_136ck500 FIND v(dout1_136) AT=255.025n

.meas tran vdout1_137ck500 FIND v(dout1_137) AT=255.025n

.meas tran vdout1_138ck500 FIND v(dout1_138) AT=255.025n

.meas tran vdout1_139ck500 FIND v(dout1_139) AT=255.025n

.meas tran vdout1_140ck500 FIND v(dout1_140) AT=255.025n

.meas tran vdout1_141ck500 FIND v(dout1_141) AT=255.025n

.meas tran vdout1_142ck500 FIND v(dout1_142) AT=255.025n

.meas tran vdout1_143ck500 FIND v(dout1_143) AT=255.025n

.meas tran vdout1_144ck500 FIND v(dout1_144) AT=255.025n

.meas tran vdout1_145ck500 FIND v(dout1_145) AT=255.025n

.meas tran vdout1_146ck500 FIND v(dout1_146) AT=255.025n

.meas tran vdout1_147ck500 FIND v(dout1_147) AT=255.025n

.meas tran vdout1_148ck500 FIND v(dout1_148) AT=255.025n

.meas tran vdout1_149ck500 FIND v(dout1_149) AT=255.025n

.meas tran vdout1_150ck500 FIND v(dout1_150) AT=255.025n

.meas tran vdout1_151ck500 FIND v(dout1_151) AT=255.025n

.meas tran vdout1_152ck500 FIND v(dout1_152) AT=255.025n

.meas tran vdout1_153ck500 FIND v(dout1_153) AT=255.025n

.meas tran vdout1_154ck500 FIND v(dout1_154) AT=255.025n

.meas tran vdout1_155ck500 FIND v(dout1_155) AT=255.025n

.meas tran vdout1_156ck500 FIND v(dout1_156) AT=255.025n

.meas tran vdout1_157ck500 FIND v(dout1_157) AT=255.025n

.meas tran vdout1_158ck500 FIND v(dout1_158) AT=255.025n

.meas tran vdout1_159ck500 FIND v(dout1_159) AT=255.025n

.meas tran vdout1_160ck500 FIND v(dout1_160) AT=255.025n

.meas tran vdout1_161ck500 FIND v(dout1_161) AT=255.025n

.meas tran vdout1_162ck500 FIND v(dout1_162) AT=255.025n

.meas tran vdout1_163ck500 FIND v(dout1_163) AT=255.025n

.meas tran vdout1_164ck500 FIND v(dout1_164) AT=255.025n

.meas tran vdout1_165ck500 FIND v(dout1_165) AT=255.025n

.meas tran vdout1_166ck500 FIND v(dout1_166) AT=255.025n

.meas tran vdout1_167ck500 FIND v(dout1_167) AT=255.025n

.meas tran vdout1_168ck500 FIND v(dout1_168) AT=255.025n

.meas tran vdout1_169ck500 FIND v(dout1_169) AT=255.025n

.meas tran vdout1_170ck500 FIND v(dout1_170) AT=255.025n

.meas tran vdout1_171ck500 FIND v(dout1_171) AT=255.025n

.meas tran vdout1_172ck500 FIND v(dout1_172) AT=255.025n

.meas tran vdout1_173ck500 FIND v(dout1_173) AT=255.025n

.meas tran vdout1_174ck500 FIND v(dout1_174) AT=255.025n

.meas tran vdout1_175ck500 FIND v(dout1_175) AT=255.025n

.meas tran vdout1_176ck500 FIND v(dout1_176) AT=255.025n

.meas tran vdout1_177ck500 FIND v(dout1_177) AT=255.025n

.meas tran vdout1_178ck500 FIND v(dout1_178) AT=255.025n

.meas tran vdout1_179ck500 FIND v(dout1_179) AT=255.025n

.meas tran vdout1_180ck500 FIND v(dout1_180) AT=255.025n

.meas tran vdout1_181ck500 FIND v(dout1_181) AT=255.025n

.meas tran vdout1_182ck500 FIND v(dout1_182) AT=255.025n

.meas tran vdout1_183ck500 FIND v(dout1_183) AT=255.025n

.meas tran vdout1_184ck500 FIND v(dout1_184) AT=255.025n

.meas tran vdout1_185ck500 FIND v(dout1_185) AT=255.025n

.meas tran vdout1_186ck500 FIND v(dout1_186) AT=255.025n

.meas tran vdout1_187ck500 FIND v(dout1_187) AT=255.025n

.meas tran vdout1_188ck500 FIND v(dout1_188) AT=255.025n

.meas tran vdout1_189ck500 FIND v(dout1_189) AT=255.025n

.meas tran vdout1_190ck500 FIND v(dout1_190) AT=255.025n

.meas tran vdout1_191ck500 FIND v(dout1_191) AT=255.025n

.meas tran vdout1_192ck500 FIND v(dout1_192) AT=255.025n

.meas tran vdout1_193ck500 FIND v(dout1_193) AT=255.025n

.meas tran vdout1_194ck500 FIND v(dout1_194) AT=255.025n

.meas tran vdout1_195ck500 FIND v(dout1_195) AT=255.025n

.meas tran vdout1_196ck500 FIND v(dout1_196) AT=255.025n

.meas tran vdout1_197ck500 FIND v(dout1_197) AT=255.025n

.meas tran vdout1_198ck500 FIND v(dout1_198) AT=255.025n

.meas tran vdout1_199ck500 FIND v(dout1_199) AT=255.025n

.meas tran vdout1_200ck500 FIND v(dout1_200) AT=255.025n

.meas tran vdout1_201ck500 FIND v(dout1_201) AT=255.025n

.meas tran vdout1_202ck500 FIND v(dout1_202) AT=255.025n

.meas tran vdout1_203ck500 FIND v(dout1_203) AT=255.025n

.meas tran vdout1_204ck500 FIND v(dout1_204) AT=255.025n

.meas tran vdout1_205ck500 FIND v(dout1_205) AT=255.025n

.meas tran vdout1_206ck500 FIND v(dout1_206) AT=255.025n

.meas tran vdout1_207ck500 FIND v(dout1_207) AT=255.025n

.meas tran vdout1_208ck500 FIND v(dout1_208) AT=255.025n

.meas tran vdout1_209ck500 FIND v(dout1_209) AT=255.025n

.meas tran vdout1_210ck500 FIND v(dout1_210) AT=255.025n

.meas tran vdout1_211ck500 FIND v(dout1_211) AT=255.025n

.meas tran vdout1_212ck500 FIND v(dout1_212) AT=255.025n

.meas tran vdout1_213ck500 FIND v(dout1_213) AT=255.025n

.meas tran vdout1_214ck500 FIND v(dout1_214) AT=255.025n

.meas tran vdout1_215ck500 FIND v(dout1_215) AT=255.025n

.meas tran vdout1_216ck500 FIND v(dout1_216) AT=255.025n

.meas tran vdout1_217ck500 FIND v(dout1_217) AT=255.025n

.meas tran vdout1_218ck500 FIND v(dout1_218) AT=255.025n

.meas tran vdout1_219ck500 FIND v(dout1_219) AT=255.025n

.meas tran vdout1_220ck500 FIND v(dout1_220) AT=255.025n

.meas tran vdout1_221ck500 FIND v(dout1_221) AT=255.025n

.meas tran vdout1_222ck500 FIND v(dout1_222) AT=255.025n

.meas tran vdout1_223ck500 FIND v(dout1_223) AT=255.025n

.meas tran vdout1_224ck500 FIND v(dout1_224) AT=255.025n

.meas tran vdout1_225ck500 FIND v(dout1_225) AT=255.025n

.meas tran vdout1_226ck500 FIND v(dout1_226) AT=255.025n

.meas tran vdout1_227ck500 FIND v(dout1_227) AT=255.025n

.meas tran vdout1_228ck500 FIND v(dout1_228) AT=255.025n

.meas tran vdout1_229ck500 FIND v(dout1_229) AT=255.025n

.meas tran vdout1_230ck500 FIND v(dout1_230) AT=255.025n

.meas tran vdout1_231ck500 FIND v(dout1_231) AT=255.025n

.meas tran vdout1_232ck500 FIND v(dout1_232) AT=255.025n

.meas tran vdout1_233ck500 FIND v(dout1_233) AT=255.025n

.meas tran vdout1_234ck500 FIND v(dout1_234) AT=255.025n

.meas tran vdout1_235ck500 FIND v(dout1_235) AT=255.025n

.meas tran vdout1_236ck500 FIND v(dout1_236) AT=255.025n

.meas tran vdout1_237ck500 FIND v(dout1_237) AT=255.025n

.meas tran vdout1_238ck500 FIND v(dout1_238) AT=255.025n

.meas tran vdout1_239ck500 FIND v(dout1_239) AT=255.025n

.meas tran vdout1_240ck500 FIND v(dout1_240) AT=255.025n

.meas tran vdout1_241ck500 FIND v(dout1_241) AT=255.025n

.meas tran vdout1_242ck500 FIND v(dout1_242) AT=255.025n

.meas tran vdout1_243ck500 FIND v(dout1_243) AT=255.025n

.meas tran vdout1_244ck500 FIND v(dout1_244) AT=255.025n

.meas tran vdout1_245ck500 FIND v(dout1_245) AT=255.025n

.meas tran vdout1_246ck500 FIND v(dout1_246) AT=255.025n

.meas tran vdout1_247ck500 FIND v(dout1_247) AT=255.025n

.meas tran vdout1_248ck500 FIND v(dout1_248) AT=255.025n

.meas tran vdout1_249ck500 FIND v(dout1_249) AT=255.025n

.meas tran vdout1_250ck500 FIND v(dout1_250) AT=255.025n

.meas tran vdout1_251ck500 FIND v(dout1_251) AT=255.025n

.meas tran vdout1_252ck500 FIND v(dout1_252) AT=255.025n

.meas tran vdout1_253ck500 FIND v(dout1_253) AT=255.025n

.meas tran vdout1_254ck500 FIND v(dout1_254) AT=255.025n

.meas tran vdout1_255ck500 FIND v(dout1_255) AT=255.025n

.meas tran vdout1_256ck500 FIND v(dout1_256) AT=255.025n

.meas tran vdout1_257ck500 FIND v(dout1_257) AT=255.025n

.meas tran vdout1_258ck500 FIND v(dout1_258) AT=255.025n

.meas tran vdout1_259ck500 FIND v(dout1_259) AT=255.025n

.meas tran vdout1_260ck500 FIND v(dout1_260) AT=255.025n

.meas tran vdout1_261ck500 FIND v(dout1_261) AT=255.025n

.meas tran vdout1_262ck500 FIND v(dout1_262) AT=255.025n

.meas tran vdout1_263ck500 FIND v(dout1_263) AT=255.025n

.meas tran vdout1_264ck500 FIND v(dout1_264) AT=255.025n

.meas tran vdout1_265ck500 FIND v(dout1_265) AT=255.025n

.meas tran vdout1_266ck500 FIND v(dout1_266) AT=255.025n

.meas tran vdout1_267ck500 FIND v(dout1_267) AT=255.025n

.meas tran vdout1_268ck500 FIND v(dout1_268) AT=255.025n

.meas tran vdout1_269ck500 FIND v(dout1_269) AT=255.025n

.meas tran vdout1_270ck500 FIND v(dout1_270) AT=255.025n

.meas tran vdout1_271ck500 FIND v(dout1_271) AT=255.025n

.meas tran vdout1_272ck500 FIND v(dout1_272) AT=255.025n

.meas tran vdout1_273ck500 FIND v(dout1_273) AT=255.025n

.meas tran vdout1_274ck500 FIND v(dout1_274) AT=255.025n

.meas tran vdout1_275ck500 FIND v(dout1_275) AT=255.025n

.meas tran vdout1_276ck500 FIND v(dout1_276) AT=255.025n

.meas tran vdout1_277ck500 FIND v(dout1_277) AT=255.025n

.meas tran vdout1_278ck500 FIND v(dout1_278) AT=255.025n

.meas tran vdout1_279ck500 FIND v(dout1_279) AT=255.025n

.meas tran vdout1_280ck500 FIND v(dout1_280) AT=255.025n

.meas tran vdout1_281ck500 FIND v(dout1_281) AT=255.025n

.meas tran vdout1_282ck500 FIND v(dout1_282) AT=255.025n

.meas tran vdout1_283ck500 FIND v(dout1_283) AT=255.025n

.meas tran vdout1_284ck500 FIND v(dout1_284) AT=255.025n

.meas tran vdout1_285ck500 FIND v(dout1_285) AT=255.025n

.meas tran vdout1_286ck500 FIND v(dout1_286) AT=255.025n

.meas tran vdout1_287ck500 FIND v(dout1_287) AT=255.025n

.meas tran vdout1_288ck500 FIND v(dout1_288) AT=255.025n

.meas tran vdout1_289ck500 FIND v(dout1_289) AT=255.025n

.meas tran vdout1_290ck500 FIND v(dout1_290) AT=255.025n

.meas tran vdout1_291ck500 FIND v(dout1_291) AT=255.025n

.meas tran vdout1_292ck500 FIND v(dout1_292) AT=255.025n

.meas tran vdout1_293ck500 FIND v(dout1_293) AT=255.025n

.meas tran vdout1_294ck500 FIND v(dout1_294) AT=255.025n

.meas tran vdout1_295ck500 FIND v(dout1_295) AT=255.025n

.meas tran vdout1_296ck500 FIND v(dout1_296) AT=255.025n

.meas tran vdout1_297ck500 FIND v(dout1_297) AT=255.025n

.meas tran vdout1_298ck500 FIND v(dout1_298) AT=255.025n

.meas tran vdout1_299ck500 FIND v(dout1_299) AT=255.025n

.meas tran vdout1_300ck500 FIND v(dout1_300) AT=255.025n

.meas tran vdout1_301ck500 FIND v(dout1_301) AT=255.025n

.meas tran vdout1_302ck500 FIND v(dout1_302) AT=255.025n

.meas tran vdout1_303ck500 FIND v(dout1_303) AT=255.025n

.meas tran vdout1_304ck500 FIND v(dout1_304) AT=255.025n

.meas tran vdout1_305ck500 FIND v(dout1_305) AT=255.025n

.meas tran vdout1_306ck500 FIND v(dout1_306) AT=255.025n

.meas tran vdout1_307ck500 FIND v(dout1_307) AT=255.025n

.meas tran vdout1_308ck500 FIND v(dout1_308) AT=255.025n

.meas tran vdout1_309ck500 FIND v(dout1_309) AT=255.025n

.meas tran vdout1_310ck500 FIND v(dout1_310) AT=255.025n

.meas tran vdout1_311ck500 FIND v(dout1_311) AT=255.025n

.meas tran vdout1_312ck500 FIND v(dout1_312) AT=255.025n

.meas tran vdout1_313ck500 FIND v(dout1_313) AT=255.025n

.meas tran vdout1_314ck500 FIND v(dout1_314) AT=255.025n

.meas tran vdout1_315ck500 FIND v(dout1_315) AT=255.025n

.meas tran vdout1_316ck500 FIND v(dout1_316) AT=255.025n

.meas tran vdout1_317ck500 FIND v(dout1_317) AT=255.025n

.meas tran vdout1_318ck500 FIND v(dout1_318) AT=255.025n

.meas tran vdout1_319ck500 FIND v(dout1_319) AT=255.025n

.meas tran vdout1_320ck500 FIND v(dout1_320) AT=255.025n

.meas tran vdout1_321ck500 FIND v(dout1_321) AT=255.025n

.meas tran vdout1_322ck500 FIND v(dout1_322) AT=255.025n

.meas tran vdout1_323ck500 FIND v(dout1_323) AT=255.025n

.meas tran vdout1_324ck500 FIND v(dout1_324) AT=255.025n

.meas tran vdout1_325ck500 FIND v(dout1_325) AT=255.025n

.meas tran vdout1_326ck500 FIND v(dout1_326) AT=255.025n

.meas tran vdout1_327ck500 FIND v(dout1_327) AT=255.025n

.meas tran vdout1_328ck500 FIND v(dout1_328) AT=255.025n

.meas tran vdout1_329ck500 FIND v(dout1_329) AT=255.025n

.meas tran vdout1_330ck500 FIND v(dout1_330) AT=255.025n

.meas tran vdout1_331ck500 FIND v(dout1_331) AT=255.025n

.meas tran vdout1_332ck500 FIND v(dout1_332) AT=255.025n

.meas tran vdout1_333ck500 FIND v(dout1_333) AT=255.025n

.meas tran vdout1_334ck500 FIND v(dout1_334) AT=255.025n

.meas tran vdout1_335ck500 FIND v(dout1_335) AT=255.025n

.meas tran vdout1_336ck500 FIND v(dout1_336) AT=255.025n

.meas tran vdout1_337ck500 FIND v(dout1_337) AT=255.025n

.meas tran vdout1_338ck500 FIND v(dout1_338) AT=255.025n

.meas tran vdout1_339ck500 FIND v(dout1_339) AT=255.025n

.meas tran vdout1_340ck500 FIND v(dout1_340) AT=255.025n

.meas tran vdout1_341ck500 FIND v(dout1_341) AT=255.025n

.meas tran vdout1_342ck500 FIND v(dout1_342) AT=255.025n

.meas tran vdout1_343ck500 FIND v(dout1_343) AT=255.025n

.meas tran vdout1_344ck500 FIND v(dout1_344) AT=255.025n

.meas tran vdout1_345ck500 FIND v(dout1_345) AT=255.025n

.meas tran vdout1_346ck500 FIND v(dout1_346) AT=255.025n

.meas tran vdout1_347ck500 FIND v(dout1_347) AT=255.025n

.meas tran vdout1_348ck500 FIND v(dout1_348) AT=255.025n

.meas tran vdout1_349ck500 FIND v(dout1_349) AT=255.025n

.meas tran vdout1_350ck500 FIND v(dout1_350) AT=255.025n

.meas tran vdout1_351ck500 FIND v(dout1_351) AT=255.025n

.meas tran vdout1_352ck500 FIND v(dout1_352) AT=255.025n

.meas tran vdout1_353ck500 FIND v(dout1_353) AT=255.025n

.meas tran vdout1_354ck500 FIND v(dout1_354) AT=255.025n

.meas tran vdout1_355ck500 FIND v(dout1_355) AT=255.025n

.meas tran vdout1_356ck500 FIND v(dout1_356) AT=255.025n

.meas tran vdout1_357ck500 FIND v(dout1_357) AT=255.025n

.meas tran vdout1_358ck500 FIND v(dout1_358) AT=255.025n

.meas tran vdout1_359ck500 FIND v(dout1_359) AT=255.025n

.meas tran vdout1_360ck500 FIND v(dout1_360) AT=255.025n

.meas tran vdout1_361ck500 FIND v(dout1_361) AT=255.025n

.meas tran vdout1_362ck500 FIND v(dout1_362) AT=255.025n

.meas tran vdout1_363ck500 FIND v(dout1_363) AT=255.025n

.meas tran vdout1_364ck500 FIND v(dout1_364) AT=255.025n

.meas tran vdout1_365ck500 FIND v(dout1_365) AT=255.025n

.meas tran vdout1_366ck500 FIND v(dout1_366) AT=255.025n

.meas tran vdout1_367ck500 FIND v(dout1_367) AT=255.025n

.meas tran vdout1_368ck500 FIND v(dout1_368) AT=255.025n

.meas tran vdout1_369ck500 FIND v(dout1_369) AT=255.025n

.meas tran vdout1_370ck500 FIND v(dout1_370) AT=255.025n

.meas tran vdout1_371ck500 FIND v(dout1_371) AT=255.025n

.meas tran vdout1_372ck500 FIND v(dout1_372) AT=255.025n

.meas tran vdout1_373ck500 FIND v(dout1_373) AT=255.025n

.meas tran vdout1_374ck500 FIND v(dout1_374) AT=255.025n

.meas tran vdout1_375ck500 FIND v(dout1_375) AT=255.025n

.meas tran vdout1_376ck500 FIND v(dout1_376) AT=255.025n

.meas tran vdout1_377ck500 FIND v(dout1_377) AT=255.025n

.meas tran vdout1_378ck500 FIND v(dout1_378) AT=255.025n

.meas tran vdout1_379ck500 FIND v(dout1_379) AT=255.025n

.meas tran vdout1_380ck500 FIND v(dout1_380) AT=255.025n

.meas tran vdout1_381ck500 FIND v(dout1_381) AT=255.025n

.meas tran vdout1_382ck500 FIND v(dout1_382) AT=255.025n

.meas tran vdout1_383ck500 FIND v(dout1_383) AT=255.025n

.meas tran vdout1_384ck500 FIND v(dout1_384) AT=255.025n

.meas tran vdout1_385ck500 FIND v(dout1_385) AT=255.025n

.meas tran vdout1_386ck500 FIND v(dout1_386) AT=255.025n

.meas tran vdout1_387ck500 FIND v(dout1_387) AT=255.025n

.meas tran vdout1_388ck500 FIND v(dout1_388) AT=255.025n

.meas tran vdout1_389ck500 FIND v(dout1_389) AT=255.025n

.meas tran vdout1_390ck500 FIND v(dout1_390) AT=255.025n

.meas tran vdout1_391ck500 FIND v(dout1_391) AT=255.025n

.meas tran vdout1_392ck500 FIND v(dout1_392) AT=255.025n

.meas tran vdout1_393ck500 FIND v(dout1_393) AT=255.025n

.meas tran vdout1_394ck500 FIND v(dout1_394) AT=255.025n

.meas tran vdout1_395ck500 FIND v(dout1_395) AT=255.025n

.meas tran vdout1_396ck500 FIND v(dout1_396) AT=255.025n

.meas tran vdout1_397ck500 FIND v(dout1_397) AT=255.025n

.meas tran vdout1_398ck500 FIND v(dout1_398) AT=255.025n

.meas tran vdout1_399ck500 FIND v(dout1_399) AT=255.025n

.meas tran vdout1_400ck500 FIND v(dout1_400) AT=255.025n

.meas tran vdout1_401ck500 FIND v(dout1_401) AT=255.025n

.meas tran vdout1_402ck500 FIND v(dout1_402) AT=255.025n

.meas tran vdout1_403ck500 FIND v(dout1_403) AT=255.025n

.meas tran vdout1_404ck500 FIND v(dout1_404) AT=255.025n

.meas tran vdout1_405ck500 FIND v(dout1_405) AT=255.025n

.meas tran vdout1_406ck500 FIND v(dout1_406) AT=255.025n

.meas tran vdout1_407ck500 FIND v(dout1_407) AT=255.025n

.meas tran vdout1_408ck500 FIND v(dout1_408) AT=255.025n

.meas tran vdout1_409ck500 FIND v(dout1_409) AT=255.025n

.meas tran vdout1_410ck500 FIND v(dout1_410) AT=255.025n

.meas tran vdout1_411ck500 FIND v(dout1_411) AT=255.025n

.meas tran vdout1_412ck500 FIND v(dout1_412) AT=255.025n

.meas tran vdout1_413ck500 FIND v(dout1_413) AT=255.025n

.meas tran vdout1_414ck500 FIND v(dout1_414) AT=255.025n

.meas tran vdout1_415ck500 FIND v(dout1_415) AT=255.025n

.meas tran vdout1_416ck500 FIND v(dout1_416) AT=255.025n

.meas tran vdout1_417ck500 FIND v(dout1_417) AT=255.025n

.meas tran vdout1_418ck500 FIND v(dout1_418) AT=255.025n

.meas tran vdout1_419ck500 FIND v(dout1_419) AT=255.025n

.meas tran vdout1_420ck500 FIND v(dout1_420) AT=255.025n

.meas tran vdout1_421ck500 FIND v(dout1_421) AT=255.025n

.meas tran vdout1_422ck500 FIND v(dout1_422) AT=255.025n

.meas tran vdout1_423ck500 FIND v(dout1_423) AT=255.025n

.meas tran vdout1_424ck500 FIND v(dout1_424) AT=255.025n

.meas tran vdout1_425ck500 FIND v(dout1_425) AT=255.025n

.meas tran vdout1_426ck500 FIND v(dout1_426) AT=255.025n

.meas tran vdout1_427ck500 FIND v(dout1_427) AT=255.025n

.meas tran vdout1_428ck500 FIND v(dout1_428) AT=255.025n

.meas tran vdout1_429ck500 FIND v(dout1_429) AT=255.025n

.meas tran vdout1_430ck500 FIND v(dout1_430) AT=255.025n

.meas tran vdout1_431ck500 FIND v(dout1_431) AT=255.025n

.meas tran vdout1_432ck500 FIND v(dout1_432) AT=255.025n

.meas tran vdout1_433ck500 FIND v(dout1_433) AT=255.025n

.meas tran vdout1_434ck500 FIND v(dout1_434) AT=255.025n

.meas tran vdout1_435ck500 FIND v(dout1_435) AT=255.025n

.meas tran vdout1_436ck500 FIND v(dout1_436) AT=255.025n

.meas tran vdout1_437ck500 FIND v(dout1_437) AT=255.025n

.meas tran vdout1_438ck500 FIND v(dout1_438) AT=255.025n

.meas tran vdout1_439ck500 FIND v(dout1_439) AT=255.025n

.meas tran vdout1_440ck500 FIND v(dout1_440) AT=255.025n

.meas tran vdout1_441ck500 FIND v(dout1_441) AT=255.025n

.meas tran vdout1_442ck500 FIND v(dout1_442) AT=255.025n

.meas tran vdout1_443ck500 FIND v(dout1_443) AT=255.025n

.meas tran vdout1_444ck500 FIND v(dout1_444) AT=255.025n

.meas tran vdout1_445ck500 FIND v(dout1_445) AT=255.025n

.meas tran vdout1_446ck500 FIND v(dout1_446) AT=255.025n

.meas tran vdout1_447ck500 FIND v(dout1_447) AT=255.025n

.meas tran vdout1_448ck500 FIND v(dout1_448) AT=255.025n

.meas tran vdout1_449ck500 FIND v(dout1_449) AT=255.025n

.meas tran vdout1_450ck500 FIND v(dout1_450) AT=255.025n

.meas tran vdout1_451ck500 FIND v(dout1_451) AT=255.025n

.meas tran vdout1_452ck500 FIND v(dout1_452) AT=255.025n

.meas tran vdout1_453ck500 FIND v(dout1_453) AT=255.025n

.meas tran vdout1_454ck500 FIND v(dout1_454) AT=255.025n

.meas tran vdout1_455ck500 FIND v(dout1_455) AT=255.025n

.meas tran vdout1_456ck500 FIND v(dout1_456) AT=255.025n

.meas tran vdout1_457ck500 FIND v(dout1_457) AT=255.025n

.meas tran vdout1_458ck500 FIND v(dout1_458) AT=255.025n

.meas tran vdout1_459ck500 FIND v(dout1_459) AT=255.025n

.meas tran vdout1_460ck500 FIND v(dout1_460) AT=255.025n

.meas tran vdout1_461ck500 FIND v(dout1_461) AT=255.025n

.meas tran vdout1_462ck500 FIND v(dout1_462) AT=255.025n

.meas tran vdout1_463ck500 FIND v(dout1_463) AT=255.025n

.meas tran vdout1_464ck500 FIND v(dout1_464) AT=255.025n

.meas tran vdout1_465ck500 FIND v(dout1_465) AT=255.025n

.meas tran vdout1_466ck500 FIND v(dout1_466) AT=255.025n

.meas tran vdout1_467ck500 FIND v(dout1_467) AT=255.025n

.meas tran vdout1_468ck500 FIND v(dout1_468) AT=255.025n

.meas tran vdout1_469ck500 FIND v(dout1_469) AT=255.025n

.meas tran vdout1_470ck500 FIND v(dout1_470) AT=255.025n

.meas tran vdout1_471ck500 FIND v(dout1_471) AT=255.025n

.meas tran vdout1_472ck500 FIND v(dout1_472) AT=255.025n

.meas tran vdout1_473ck500 FIND v(dout1_473) AT=255.025n

.meas tran vdout1_474ck500 FIND v(dout1_474) AT=255.025n

.meas tran vdout1_475ck500 FIND v(dout1_475) AT=255.025n

.meas tran vdout1_476ck500 FIND v(dout1_476) AT=255.025n

.meas tran vdout1_477ck500 FIND v(dout1_477) AT=255.025n

.meas tran vdout1_478ck500 FIND v(dout1_478) AT=255.025n

.meas tran vdout1_479ck500 FIND v(dout1_479) AT=255.025n

.meas tran vdout1_480ck500 FIND v(dout1_480) AT=255.025n

.meas tran vdout1_481ck500 FIND v(dout1_481) AT=255.025n

.meas tran vdout1_482ck500 FIND v(dout1_482) AT=255.025n

.meas tran vdout1_483ck500 FIND v(dout1_483) AT=255.025n

.meas tran vdout1_484ck500 FIND v(dout1_484) AT=255.025n

.meas tran vdout1_485ck500 FIND v(dout1_485) AT=255.025n

.meas tran vdout1_486ck500 FIND v(dout1_486) AT=255.025n

.meas tran vdout1_487ck500 FIND v(dout1_487) AT=255.025n

.meas tran vdout1_488ck500 FIND v(dout1_488) AT=255.025n

.meas tran vdout1_489ck500 FIND v(dout1_489) AT=255.025n

.meas tran vdout1_490ck500 FIND v(dout1_490) AT=255.025n

.meas tran vdout1_491ck500 FIND v(dout1_491) AT=255.025n

.meas tran vdout1_492ck500 FIND v(dout1_492) AT=255.025n

.meas tran vdout1_493ck500 FIND v(dout1_493) AT=255.025n

.meas tran vdout1_494ck500 FIND v(dout1_494) AT=255.025n

.meas tran vdout1_495ck500 FIND v(dout1_495) AT=255.025n

.meas tran vdout1_496ck500 FIND v(dout1_496) AT=255.025n

.meas tran vdout1_497ck500 FIND v(dout1_497) AT=255.025n

.meas tran vdout1_498ck500 FIND v(dout1_498) AT=255.025n

.meas tran vdout1_499ck500 FIND v(dout1_499) AT=255.025n

.meas tran vdout1_500ck500 FIND v(dout1_500) AT=255.025n

.meas tran vdout1_501ck500 FIND v(dout1_501) AT=255.025n

.meas tran vdout1_502ck500 FIND v(dout1_502) AT=255.025n

.meas tran vdout1_503ck500 FIND v(dout1_503) AT=255.025n

.meas tran vdout1_504ck500 FIND v(dout1_504) AT=255.025n

.meas tran vdout1_505ck500 FIND v(dout1_505) AT=255.025n

.meas tran vdout1_506ck500 FIND v(dout1_506) AT=255.025n

.meas tran vdout1_507ck500 FIND v(dout1_507) AT=255.025n

.meas tran vdout1_508ck500 FIND v(dout1_508) AT=255.025n

.meas tran vdout1_509ck500 FIND v(dout1_509) AT=255.025n

.meas tran vdout1_510ck500 FIND v(dout1_510) AT=255.025n

.meas tran vdout1_511ck500 FIND v(dout1_511) AT=255.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_8ck520 FIND v(dout1_8) AT=265.025n

.meas tran vdout1_9ck520 FIND v(dout1_9) AT=265.025n

.meas tran vdout1_10ck520 FIND v(dout1_10) AT=265.025n

.meas tran vdout1_11ck520 FIND v(dout1_11) AT=265.025n

.meas tran vdout1_12ck520 FIND v(dout1_12) AT=265.025n

.meas tran vdout1_13ck520 FIND v(dout1_13) AT=265.025n

.meas tran vdout1_14ck520 FIND v(dout1_14) AT=265.025n

.meas tran vdout1_15ck520 FIND v(dout1_15) AT=265.025n

.meas tran vdout1_16ck520 FIND v(dout1_16) AT=265.025n

.meas tran vdout1_17ck520 FIND v(dout1_17) AT=265.025n

.meas tran vdout1_18ck520 FIND v(dout1_18) AT=265.025n

.meas tran vdout1_19ck520 FIND v(dout1_19) AT=265.025n

.meas tran vdout1_20ck520 FIND v(dout1_20) AT=265.025n

.meas tran vdout1_21ck520 FIND v(dout1_21) AT=265.025n

.meas tran vdout1_22ck520 FIND v(dout1_22) AT=265.025n

.meas tran vdout1_23ck520 FIND v(dout1_23) AT=265.025n

.meas tran vdout1_24ck520 FIND v(dout1_24) AT=265.025n

.meas tran vdout1_25ck520 FIND v(dout1_25) AT=265.025n

.meas tran vdout1_26ck520 FIND v(dout1_26) AT=265.025n

.meas tran vdout1_27ck520 FIND v(dout1_27) AT=265.025n

.meas tran vdout1_28ck520 FIND v(dout1_28) AT=265.025n

.meas tran vdout1_29ck520 FIND v(dout1_29) AT=265.025n

.meas tran vdout1_30ck520 FIND v(dout1_30) AT=265.025n

.meas tran vdout1_31ck520 FIND v(dout1_31) AT=265.025n

.meas tran vdout1_32ck520 FIND v(dout1_32) AT=265.025n

.meas tran vdout1_33ck520 FIND v(dout1_33) AT=265.025n

.meas tran vdout1_34ck520 FIND v(dout1_34) AT=265.025n

.meas tran vdout1_35ck520 FIND v(dout1_35) AT=265.025n

.meas tran vdout1_36ck520 FIND v(dout1_36) AT=265.025n

.meas tran vdout1_37ck520 FIND v(dout1_37) AT=265.025n

.meas tran vdout1_38ck520 FIND v(dout1_38) AT=265.025n

.meas tran vdout1_39ck520 FIND v(dout1_39) AT=265.025n

.meas tran vdout1_40ck520 FIND v(dout1_40) AT=265.025n

.meas tran vdout1_41ck520 FIND v(dout1_41) AT=265.025n

.meas tran vdout1_42ck520 FIND v(dout1_42) AT=265.025n

.meas tran vdout1_43ck520 FIND v(dout1_43) AT=265.025n

.meas tran vdout1_44ck520 FIND v(dout1_44) AT=265.025n

.meas tran vdout1_45ck520 FIND v(dout1_45) AT=265.025n

.meas tran vdout1_46ck520 FIND v(dout1_46) AT=265.025n

.meas tran vdout1_47ck520 FIND v(dout1_47) AT=265.025n

.meas tran vdout1_48ck520 FIND v(dout1_48) AT=265.025n

.meas tran vdout1_49ck520 FIND v(dout1_49) AT=265.025n

.meas tran vdout1_50ck520 FIND v(dout1_50) AT=265.025n

.meas tran vdout1_51ck520 FIND v(dout1_51) AT=265.025n

.meas tran vdout1_52ck520 FIND v(dout1_52) AT=265.025n

.meas tran vdout1_53ck520 FIND v(dout1_53) AT=265.025n

.meas tran vdout1_54ck520 FIND v(dout1_54) AT=265.025n

.meas tran vdout1_55ck520 FIND v(dout1_55) AT=265.025n

.meas tran vdout1_56ck520 FIND v(dout1_56) AT=265.025n

.meas tran vdout1_57ck520 FIND v(dout1_57) AT=265.025n

.meas tran vdout1_58ck520 FIND v(dout1_58) AT=265.025n

.meas tran vdout1_59ck520 FIND v(dout1_59) AT=265.025n

.meas tran vdout1_60ck520 FIND v(dout1_60) AT=265.025n

.meas tran vdout1_61ck520 FIND v(dout1_61) AT=265.025n

.meas tran vdout1_62ck520 FIND v(dout1_62) AT=265.025n

.meas tran vdout1_63ck520 FIND v(dout1_63) AT=265.025n

.meas tran vdout1_64ck520 FIND v(dout1_64) AT=265.025n

.meas tran vdout1_65ck520 FIND v(dout1_65) AT=265.025n

.meas tran vdout1_66ck520 FIND v(dout1_66) AT=265.025n

.meas tran vdout1_67ck520 FIND v(dout1_67) AT=265.025n

.meas tran vdout1_68ck520 FIND v(dout1_68) AT=265.025n

.meas tran vdout1_69ck520 FIND v(dout1_69) AT=265.025n

.meas tran vdout1_70ck520 FIND v(dout1_70) AT=265.025n

.meas tran vdout1_71ck520 FIND v(dout1_71) AT=265.025n

.meas tran vdout1_72ck520 FIND v(dout1_72) AT=265.025n

.meas tran vdout1_73ck520 FIND v(dout1_73) AT=265.025n

.meas tran vdout1_74ck520 FIND v(dout1_74) AT=265.025n

.meas tran vdout1_75ck520 FIND v(dout1_75) AT=265.025n

.meas tran vdout1_76ck520 FIND v(dout1_76) AT=265.025n

.meas tran vdout1_77ck520 FIND v(dout1_77) AT=265.025n

.meas tran vdout1_78ck520 FIND v(dout1_78) AT=265.025n

.meas tran vdout1_79ck520 FIND v(dout1_79) AT=265.025n

.meas tran vdout1_80ck520 FIND v(dout1_80) AT=265.025n

.meas tran vdout1_81ck520 FIND v(dout1_81) AT=265.025n

.meas tran vdout1_82ck520 FIND v(dout1_82) AT=265.025n

.meas tran vdout1_83ck520 FIND v(dout1_83) AT=265.025n

.meas tran vdout1_84ck520 FIND v(dout1_84) AT=265.025n

.meas tran vdout1_85ck520 FIND v(dout1_85) AT=265.025n

.meas tran vdout1_86ck520 FIND v(dout1_86) AT=265.025n

.meas tran vdout1_87ck520 FIND v(dout1_87) AT=265.025n

.meas tran vdout1_88ck520 FIND v(dout1_88) AT=265.025n

.meas tran vdout1_89ck520 FIND v(dout1_89) AT=265.025n

.meas tran vdout1_90ck520 FIND v(dout1_90) AT=265.025n

.meas tran vdout1_91ck520 FIND v(dout1_91) AT=265.025n

.meas tran vdout1_92ck520 FIND v(dout1_92) AT=265.025n

.meas tran vdout1_93ck520 FIND v(dout1_93) AT=265.025n

.meas tran vdout1_94ck520 FIND v(dout1_94) AT=265.025n

.meas tran vdout1_95ck520 FIND v(dout1_95) AT=265.025n

.meas tran vdout1_96ck520 FIND v(dout1_96) AT=265.025n

.meas tran vdout1_97ck520 FIND v(dout1_97) AT=265.025n

.meas tran vdout1_98ck520 FIND v(dout1_98) AT=265.025n

.meas tran vdout1_99ck520 FIND v(dout1_99) AT=265.025n

.meas tran vdout1_100ck520 FIND v(dout1_100) AT=265.025n

.meas tran vdout1_101ck520 FIND v(dout1_101) AT=265.025n

.meas tran vdout1_102ck520 FIND v(dout1_102) AT=265.025n

.meas tran vdout1_103ck520 FIND v(dout1_103) AT=265.025n

.meas tran vdout1_104ck520 FIND v(dout1_104) AT=265.025n

.meas tran vdout1_105ck520 FIND v(dout1_105) AT=265.025n

.meas tran vdout1_106ck520 FIND v(dout1_106) AT=265.025n

.meas tran vdout1_107ck520 FIND v(dout1_107) AT=265.025n

.meas tran vdout1_108ck520 FIND v(dout1_108) AT=265.025n

.meas tran vdout1_109ck520 FIND v(dout1_109) AT=265.025n

.meas tran vdout1_110ck520 FIND v(dout1_110) AT=265.025n

.meas tran vdout1_111ck520 FIND v(dout1_111) AT=265.025n

.meas tran vdout1_112ck520 FIND v(dout1_112) AT=265.025n

.meas tran vdout1_113ck520 FIND v(dout1_113) AT=265.025n

.meas tran vdout1_114ck520 FIND v(dout1_114) AT=265.025n

.meas tran vdout1_115ck520 FIND v(dout1_115) AT=265.025n

.meas tran vdout1_116ck520 FIND v(dout1_116) AT=265.025n

.meas tran vdout1_117ck520 FIND v(dout1_117) AT=265.025n

.meas tran vdout1_118ck520 FIND v(dout1_118) AT=265.025n

.meas tran vdout1_119ck520 FIND v(dout1_119) AT=265.025n

.meas tran vdout1_120ck520 FIND v(dout1_120) AT=265.025n

.meas tran vdout1_121ck520 FIND v(dout1_121) AT=265.025n

.meas tran vdout1_122ck520 FIND v(dout1_122) AT=265.025n

.meas tran vdout1_123ck520 FIND v(dout1_123) AT=265.025n

.meas tran vdout1_124ck520 FIND v(dout1_124) AT=265.025n

.meas tran vdout1_125ck520 FIND v(dout1_125) AT=265.025n

.meas tran vdout1_126ck520 FIND v(dout1_126) AT=265.025n

.meas tran vdout1_127ck520 FIND v(dout1_127) AT=265.025n

.meas tran vdout1_128ck520 FIND v(dout1_128) AT=265.025n

.meas tran vdout1_129ck520 FIND v(dout1_129) AT=265.025n

.meas tran vdout1_130ck520 FIND v(dout1_130) AT=265.025n

.meas tran vdout1_131ck520 FIND v(dout1_131) AT=265.025n

.meas tran vdout1_132ck520 FIND v(dout1_132) AT=265.025n

.meas tran vdout1_133ck520 FIND v(dout1_133) AT=265.025n

.meas tran vdout1_134ck520 FIND v(dout1_134) AT=265.025n

.meas tran vdout1_135ck520 FIND v(dout1_135) AT=265.025n

.meas tran vdout1_136ck520 FIND v(dout1_136) AT=265.025n

.meas tran vdout1_137ck520 FIND v(dout1_137) AT=265.025n

.meas tran vdout1_138ck520 FIND v(dout1_138) AT=265.025n

.meas tran vdout1_139ck520 FIND v(dout1_139) AT=265.025n

.meas tran vdout1_140ck520 FIND v(dout1_140) AT=265.025n

.meas tran vdout1_141ck520 FIND v(dout1_141) AT=265.025n

.meas tran vdout1_142ck520 FIND v(dout1_142) AT=265.025n

.meas tran vdout1_143ck520 FIND v(dout1_143) AT=265.025n

.meas tran vdout1_144ck520 FIND v(dout1_144) AT=265.025n

.meas tran vdout1_145ck520 FIND v(dout1_145) AT=265.025n

.meas tran vdout1_146ck520 FIND v(dout1_146) AT=265.025n

.meas tran vdout1_147ck520 FIND v(dout1_147) AT=265.025n

.meas tran vdout1_148ck520 FIND v(dout1_148) AT=265.025n

.meas tran vdout1_149ck520 FIND v(dout1_149) AT=265.025n

.meas tran vdout1_150ck520 FIND v(dout1_150) AT=265.025n

.meas tran vdout1_151ck520 FIND v(dout1_151) AT=265.025n

.meas tran vdout1_152ck520 FIND v(dout1_152) AT=265.025n

.meas tran vdout1_153ck520 FIND v(dout1_153) AT=265.025n

.meas tran vdout1_154ck520 FIND v(dout1_154) AT=265.025n

.meas tran vdout1_155ck520 FIND v(dout1_155) AT=265.025n

.meas tran vdout1_156ck520 FIND v(dout1_156) AT=265.025n

.meas tran vdout1_157ck520 FIND v(dout1_157) AT=265.025n

.meas tran vdout1_158ck520 FIND v(dout1_158) AT=265.025n

.meas tran vdout1_159ck520 FIND v(dout1_159) AT=265.025n

.meas tran vdout1_160ck520 FIND v(dout1_160) AT=265.025n

.meas tran vdout1_161ck520 FIND v(dout1_161) AT=265.025n

.meas tran vdout1_162ck520 FIND v(dout1_162) AT=265.025n

.meas tran vdout1_163ck520 FIND v(dout1_163) AT=265.025n

.meas tran vdout1_164ck520 FIND v(dout1_164) AT=265.025n

.meas tran vdout1_165ck520 FIND v(dout1_165) AT=265.025n

.meas tran vdout1_166ck520 FIND v(dout1_166) AT=265.025n

.meas tran vdout1_167ck520 FIND v(dout1_167) AT=265.025n

.meas tran vdout1_168ck520 FIND v(dout1_168) AT=265.025n

.meas tran vdout1_169ck520 FIND v(dout1_169) AT=265.025n

.meas tran vdout1_170ck520 FIND v(dout1_170) AT=265.025n

.meas tran vdout1_171ck520 FIND v(dout1_171) AT=265.025n

.meas tran vdout1_172ck520 FIND v(dout1_172) AT=265.025n

.meas tran vdout1_173ck520 FIND v(dout1_173) AT=265.025n

.meas tran vdout1_174ck520 FIND v(dout1_174) AT=265.025n

.meas tran vdout1_175ck520 FIND v(dout1_175) AT=265.025n

.meas tran vdout1_176ck520 FIND v(dout1_176) AT=265.025n

.meas tran vdout1_177ck520 FIND v(dout1_177) AT=265.025n

.meas tran vdout1_178ck520 FIND v(dout1_178) AT=265.025n

.meas tran vdout1_179ck520 FIND v(dout1_179) AT=265.025n

.meas tran vdout1_180ck520 FIND v(dout1_180) AT=265.025n

.meas tran vdout1_181ck520 FIND v(dout1_181) AT=265.025n

.meas tran vdout1_182ck520 FIND v(dout1_182) AT=265.025n

.meas tran vdout1_183ck520 FIND v(dout1_183) AT=265.025n

.meas tran vdout1_184ck520 FIND v(dout1_184) AT=265.025n

.meas tran vdout1_185ck520 FIND v(dout1_185) AT=265.025n

.meas tran vdout1_186ck520 FIND v(dout1_186) AT=265.025n

.meas tran vdout1_187ck520 FIND v(dout1_187) AT=265.025n

.meas tran vdout1_188ck520 FIND v(dout1_188) AT=265.025n

.meas tran vdout1_189ck520 FIND v(dout1_189) AT=265.025n

.meas tran vdout1_190ck520 FIND v(dout1_190) AT=265.025n

.meas tran vdout1_191ck520 FIND v(dout1_191) AT=265.025n

.meas tran vdout1_192ck520 FIND v(dout1_192) AT=265.025n

.meas tran vdout1_193ck520 FIND v(dout1_193) AT=265.025n

.meas tran vdout1_194ck520 FIND v(dout1_194) AT=265.025n

.meas tran vdout1_195ck520 FIND v(dout1_195) AT=265.025n

.meas tran vdout1_196ck520 FIND v(dout1_196) AT=265.025n

.meas tran vdout1_197ck520 FIND v(dout1_197) AT=265.025n

.meas tran vdout1_198ck520 FIND v(dout1_198) AT=265.025n

.meas tran vdout1_199ck520 FIND v(dout1_199) AT=265.025n

.meas tran vdout1_200ck520 FIND v(dout1_200) AT=265.025n

.meas tran vdout1_201ck520 FIND v(dout1_201) AT=265.025n

.meas tran vdout1_202ck520 FIND v(dout1_202) AT=265.025n

.meas tran vdout1_203ck520 FIND v(dout1_203) AT=265.025n

.meas tran vdout1_204ck520 FIND v(dout1_204) AT=265.025n

.meas tran vdout1_205ck520 FIND v(dout1_205) AT=265.025n

.meas tran vdout1_206ck520 FIND v(dout1_206) AT=265.025n

.meas tran vdout1_207ck520 FIND v(dout1_207) AT=265.025n

.meas tran vdout1_208ck520 FIND v(dout1_208) AT=265.025n

.meas tran vdout1_209ck520 FIND v(dout1_209) AT=265.025n

.meas tran vdout1_210ck520 FIND v(dout1_210) AT=265.025n

.meas tran vdout1_211ck520 FIND v(dout1_211) AT=265.025n

.meas tran vdout1_212ck520 FIND v(dout1_212) AT=265.025n

.meas tran vdout1_213ck520 FIND v(dout1_213) AT=265.025n

.meas tran vdout1_214ck520 FIND v(dout1_214) AT=265.025n

.meas tran vdout1_215ck520 FIND v(dout1_215) AT=265.025n

.meas tran vdout1_216ck520 FIND v(dout1_216) AT=265.025n

.meas tran vdout1_217ck520 FIND v(dout1_217) AT=265.025n

.meas tran vdout1_218ck520 FIND v(dout1_218) AT=265.025n

.meas tran vdout1_219ck520 FIND v(dout1_219) AT=265.025n

.meas tran vdout1_220ck520 FIND v(dout1_220) AT=265.025n

.meas tran vdout1_221ck520 FIND v(dout1_221) AT=265.025n

.meas tran vdout1_222ck520 FIND v(dout1_222) AT=265.025n

.meas tran vdout1_223ck520 FIND v(dout1_223) AT=265.025n

.meas tran vdout1_224ck520 FIND v(dout1_224) AT=265.025n

.meas tran vdout1_225ck520 FIND v(dout1_225) AT=265.025n

.meas tran vdout1_226ck520 FIND v(dout1_226) AT=265.025n

.meas tran vdout1_227ck520 FIND v(dout1_227) AT=265.025n

.meas tran vdout1_228ck520 FIND v(dout1_228) AT=265.025n

.meas tran vdout1_229ck520 FIND v(dout1_229) AT=265.025n

.meas tran vdout1_230ck520 FIND v(dout1_230) AT=265.025n

.meas tran vdout1_231ck520 FIND v(dout1_231) AT=265.025n

.meas tran vdout1_232ck520 FIND v(dout1_232) AT=265.025n

.meas tran vdout1_233ck520 FIND v(dout1_233) AT=265.025n

.meas tran vdout1_234ck520 FIND v(dout1_234) AT=265.025n

.meas tran vdout1_235ck520 FIND v(dout1_235) AT=265.025n

.meas tran vdout1_236ck520 FIND v(dout1_236) AT=265.025n

.meas tran vdout1_237ck520 FIND v(dout1_237) AT=265.025n

.meas tran vdout1_238ck520 FIND v(dout1_238) AT=265.025n

.meas tran vdout1_239ck520 FIND v(dout1_239) AT=265.025n

.meas tran vdout1_240ck520 FIND v(dout1_240) AT=265.025n

.meas tran vdout1_241ck520 FIND v(dout1_241) AT=265.025n

.meas tran vdout1_242ck520 FIND v(dout1_242) AT=265.025n

.meas tran vdout1_243ck520 FIND v(dout1_243) AT=265.025n

.meas tran vdout1_244ck520 FIND v(dout1_244) AT=265.025n

.meas tran vdout1_245ck520 FIND v(dout1_245) AT=265.025n

.meas tran vdout1_246ck520 FIND v(dout1_246) AT=265.025n

.meas tran vdout1_247ck520 FIND v(dout1_247) AT=265.025n

.meas tran vdout1_248ck520 FIND v(dout1_248) AT=265.025n

.meas tran vdout1_249ck520 FIND v(dout1_249) AT=265.025n

.meas tran vdout1_250ck520 FIND v(dout1_250) AT=265.025n

.meas tran vdout1_251ck520 FIND v(dout1_251) AT=265.025n

.meas tran vdout1_252ck520 FIND v(dout1_252) AT=265.025n

.meas tran vdout1_253ck520 FIND v(dout1_253) AT=265.025n

.meas tran vdout1_254ck520 FIND v(dout1_254) AT=265.025n

.meas tran vdout1_255ck520 FIND v(dout1_255) AT=265.025n

.meas tran vdout1_256ck520 FIND v(dout1_256) AT=265.025n

.meas tran vdout1_257ck520 FIND v(dout1_257) AT=265.025n

.meas tran vdout1_258ck520 FIND v(dout1_258) AT=265.025n

.meas tran vdout1_259ck520 FIND v(dout1_259) AT=265.025n

.meas tran vdout1_260ck520 FIND v(dout1_260) AT=265.025n

.meas tran vdout1_261ck520 FIND v(dout1_261) AT=265.025n

.meas tran vdout1_262ck520 FIND v(dout1_262) AT=265.025n

.meas tran vdout1_263ck520 FIND v(dout1_263) AT=265.025n

.meas tran vdout1_264ck520 FIND v(dout1_264) AT=265.025n

.meas tran vdout1_265ck520 FIND v(dout1_265) AT=265.025n

.meas tran vdout1_266ck520 FIND v(dout1_266) AT=265.025n

.meas tran vdout1_267ck520 FIND v(dout1_267) AT=265.025n

.meas tran vdout1_268ck520 FIND v(dout1_268) AT=265.025n

.meas tran vdout1_269ck520 FIND v(dout1_269) AT=265.025n

.meas tran vdout1_270ck520 FIND v(dout1_270) AT=265.025n

.meas tran vdout1_271ck520 FIND v(dout1_271) AT=265.025n

.meas tran vdout1_272ck520 FIND v(dout1_272) AT=265.025n

.meas tran vdout1_273ck520 FIND v(dout1_273) AT=265.025n

.meas tran vdout1_274ck520 FIND v(dout1_274) AT=265.025n

.meas tran vdout1_275ck520 FIND v(dout1_275) AT=265.025n

.meas tran vdout1_276ck520 FIND v(dout1_276) AT=265.025n

.meas tran vdout1_277ck520 FIND v(dout1_277) AT=265.025n

.meas tran vdout1_278ck520 FIND v(dout1_278) AT=265.025n

.meas tran vdout1_279ck520 FIND v(dout1_279) AT=265.025n

.meas tran vdout1_280ck520 FIND v(dout1_280) AT=265.025n

.meas tran vdout1_281ck520 FIND v(dout1_281) AT=265.025n

.meas tran vdout1_282ck520 FIND v(dout1_282) AT=265.025n

.meas tran vdout1_283ck520 FIND v(dout1_283) AT=265.025n

.meas tran vdout1_284ck520 FIND v(dout1_284) AT=265.025n

.meas tran vdout1_285ck520 FIND v(dout1_285) AT=265.025n

.meas tran vdout1_286ck520 FIND v(dout1_286) AT=265.025n

.meas tran vdout1_287ck520 FIND v(dout1_287) AT=265.025n

.meas tran vdout1_288ck520 FIND v(dout1_288) AT=265.025n

.meas tran vdout1_289ck520 FIND v(dout1_289) AT=265.025n

.meas tran vdout1_290ck520 FIND v(dout1_290) AT=265.025n

.meas tran vdout1_291ck520 FIND v(dout1_291) AT=265.025n

.meas tran vdout1_292ck520 FIND v(dout1_292) AT=265.025n

.meas tran vdout1_293ck520 FIND v(dout1_293) AT=265.025n

.meas tran vdout1_294ck520 FIND v(dout1_294) AT=265.025n

.meas tran vdout1_295ck520 FIND v(dout1_295) AT=265.025n

.meas tran vdout1_296ck520 FIND v(dout1_296) AT=265.025n

.meas tran vdout1_297ck520 FIND v(dout1_297) AT=265.025n

.meas tran vdout1_298ck520 FIND v(dout1_298) AT=265.025n

.meas tran vdout1_299ck520 FIND v(dout1_299) AT=265.025n

.meas tran vdout1_300ck520 FIND v(dout1_300) AT=265.025n

.meas tran vdout1_301ck520 FIND v(dout1_301) AT=265.025n

.meas tran vdout1_302ck520 FIND v(dout1_302) AT=265.025n

.meas tran vdout1_303ck520 FIND v(dout1_303) AT=265.025n

.meas tran vdout1_304ck520 FIND v(dout1_304) AT=265.025n

.meas tran vdout1_305ck520 FIND v(dout1_305) AT=265.025n

.meas tran vdout1_306ck520 FIND v(dout1_306) AT=265.025n

.meas tran vdout1_307ck520 FIND v(dout1_307) AT=265.025n

.meas tran vdout1_308ck520 FIND v(dout1_308) AT=265.025n

.meas tran vdout1_309ck520 FIND v(dout1_309) AT=265.025n

.meas tran vdout1_310ck520 FIND v(dout1_310) AT=265.025n

.meas tran vdout1_311ck520 FIND v(dout1_311) AT=265.025n

.meas tran vdout1_312ck520 FIND v(dout1_312) AT=265.025n

.meas tran vdout1_313ck520 FIND v(dout1_313) AT=265.025n

.meas tran vdout1_314ck520 FIND v(dout1_314) AT=265.025n

.meas tran vdout1_315ck520 FIND v(dout1_315) AT=265.025n

.meas tran vdout1_316ck520 FIND v(dout1_316) AT=265.025n

.meas tran vdout1_317ck520 FIND v(dout1_317) AT=265.025n

.meas tran vdout1_318ck520 FIND v(dout1_318) AT=265.025n

.meas tran vdout1_319ck520 FIND v(dout1_319) AT=265.025n

.meas tran vdout1_320ck520 FIND v(dout1_320) AT=265.025n

.meas tran vdout1_321ck520 FIND v(dout1_321) AT=265.025n

.meas tran vdout1_322ck520 FIND v(dout1_322) AT=265.025n

.meas tran vdout1_323ck520 FIND v(dout1_323) AT=265.025n

.meas tran vdout1_324ck520 FIND v(dout1_324) AT=265.025n

.meas tran vdout1_325ck520 FIND v(dout1_325) AT=265.025n

.meas tran vdout1_326ck520 FIND v(dout1_326) AT=265.025n

.meas tran vdout1_327ck520 FIND v(dout1_327) AT=265.025n

.meas tran vdout1_328ck520 FIND v(dout1_328) AT=265.025n

.meas tran vdout1_329ck520 FIND v(dout1_329) AT=265.025n

.meas tran vdout1_330ck520 FIND v(dout1_330) AT=265.025n

.meas tran vdout1_331ck520 FIND v(dout1_331) AT=265.025n

.meas tran vdout1_332ck520 FIND v(dout1_332) AT=265.025n

.meas tran vdout1_333ck520 FIND v(dout1_333) AT=265.025n

.meas tran vdout1_334ck520 FIND v(dout1_334) AT=265.025n

.meas tran vdout1_335ck520 FIND v(dout1_335) AT=265.025n

.meas tran vdout1_336ck520 FIND v(dout1_336) AT=265.025n

.meas tran vdout1_337ck520 FIND v(dout1_337) AT=265.025n

.meas tran vdout1_338ck520 FIND v(dout1_338) AT=265.025n

.meas tran vdout1_339ck520 FIND v(dout1_339) AT=265.025n

.meas tran vdout1_340ck520 FIND v(dout1_340) AT=265.025n

.meas tran vdout1_341ck520 FIND v(dout1_341) AT=265.025n

.meas tran vdout1_342ck520 FIND v(dout1_342) AT=265.025n

.meas tran vdout1_343ck520 FIND v(dout1_343) AT=265.025n

.meas tran vdout1_344ck520 FIND v(dout1_344) AT=265.025n

.meas tran vdout1_345ck520 FIND v(dout1_345) AT=265.025n

.meas tran vdout1_346ck520 FIND v(dout1_346) AT=265.025n

.meas tran vdout1_347ck520 FIND v(dout1_347) AT=265.025n

.meas tran vdout1_348ck520 FIND v(dout1_348) AT=265.025n

.meas tran vdout1_349ck520 FIND v(dout1_349) AT=265.025n

.meas tran vdout1_350ck520 FIND v(dout1_350) AT=265.025n

.meas tran vdout1_351ck520 FIND v(dout1_351) AT=265.025n

.meas tran vdout1_352ck520 FIND v(dout1_352) AT=265.025n

.meas tran vdout1_353ck520 FIND v(dout1_353) AT=265.025n

.meas tran vdout1_354ck520 FIND v(dout1_354) AT=265.025n

.meas tran vdout1_355ck520 FIND v(dout1_355) AT=265.025n

.meas tran vdout1_356ck520 FIND v(dout1_356) AT=265.025n

.meas tran vdout1_357ck520 FIND v(dout1_357) AT=265.025n

.meas tran vdout1_358ck520 FIND v(dout1_358) AT=265.025n

.meas tran vdout1_359ck520 FIND v(dout1_359) AT=265.025n

.meas tran vdout1_360ck520 FIND v(dout1_360) AT=265.025n

.meas tran vdout1_361ck520 FIND v(dout1_361) AT=265.025n

.meas tran vdout1_362ck520 FIND v(dout1_362) AT=265.025n

.meas tran vdout1_363ck520 FIND v(dout1_363) AT=265.025n

.meas tran vdout1_364ck520 FIND v(dout1_364) AT=265.025n

.meas tran vdout1_365ck520 FIND v(dout1_365) AT=265.025n

.meas tran vdout1_366ck520 FIND v(dout1_366) AT=265.025n

.meas tran vdout1_367ck520 FIND v(dout1_367) AT=265.025n

.meas tran vdout1_368ck520 FIND v(dout1_368) AT=265.025n

.meas tran vdout1_369ck520 FIND v(dout1_369) AT=265.025n

.meas tran vdout1_370ck520 FIND v(dout1_370) AT=265.025n

.meas tran vdout1_371ck520 FIND v(dout1_371) AT=265.025n

.meas tran vdout1_372ck520 FIND v(dout1_372) AT=265.025n

.meas tran vdout1_373ck520 FIND v(dout1_373) AT=265.025n

.meas tran vdout1_374ck520 FIND v(dout1_374) AT=265.025n

.meas tran vdout1_375ck520 FIND v(dout1_375) AT=265.025n

.meas tran vdout1_376ck520 FIND v(dout1_376) AT=265.025n

.meas tran vdout1_377ck520 FIND v(dout1_377) AT=265.025n

.meas tran vdout1_378ck520 FIND v(dout1_378) AT=265.025n

.meas tran vdout1_379ck520 FIND v(dout1_379) AT=265.025n

.meas tran vdout1_380ck520 FIND v(dout1_380) AT=265.025n

.meas tran vdout1_381ck520 FIND v(dout1_381) AT=265.025n

.meas tran vdout1_382ck520 FIND v(dout1_382) AT=265.025n

.meas tran vdout1_383ck520 FIND v(dout1_383) AT=265.025n

.meas tran vdout1_384ck520 FIND v(dout1_384) AT=265.025n

.meas tran vdout1_385ck520 FIND v(dout1_385) AT=265.025n

.meas tran vdout1_386ck520 FIND v(dout1_386) AT=265.025n

.meas tran vdout1_387ck520 FIND v(dout1_387) AT=265.025n

.meas tran vdout1_388ck520 FIND v(dout1_388) AT=265.025n

.meas tran vdout1_389ck520 FIND v(dout1_389) AT=265.025n

.meas tran vdout1_390ck520 FIND v(dout1_390) AT=265.025n

.meas tran vdout1_391ck520 FIND v(dout1_391) AT=265.025n

.meas tran vdout1_392ck520 FIND v(dout1_392) AT=265.025n

.meas tran vdout1_393ck520 FIND v(dout1_393) AT=265.025n

.meas tran vdout1_394ck520 FIND v(dout1_394) AT=265.025n

.meas tran vdout1_395ck520 FIND v(dout1_395) AT=265.025n

.meas tran vdout1_396ck520 FIND v(dout1_396) AT=265.025n

.meas tran vdout1_397ck520 FIND v(dout1_397) AT=265.025n

.meas tran vdout1_398ck520 FIND v(dout1_398) AT=265.025n

.meas tran vdout1_399ck520 FIND v(dout1_399) AT=265.025n

.meas tran vdout1_400ck520 FIND v(dout1_400) AT=265.025n

.meas tran vdout1_401ck520 FIND v(dout1_401) AT=265.025n

.meas tran vdout1_402ck520 FIND v(dout1_402) AT=265.025n

.meas tran vdout1_403ck520 FIND v(dout1_403) AT=265.025n

.meas tran vdout1_404ck520 FIND v(dout1_404) AT=265.025n

.meas tran vdout1_405ck520 FIND v(dout1_405) AT=265.025n

.meas tran vdout1_406ck520 FIND v(dout1_406) AT=265.025n

.meas tran vdout1_407ck520 FIND v(dout1_407) AT=265.025n

.meas tran vdout1_408ck520 FIND v(dout1_408) AT=265.025n

.meas tran vdout1_409ck520 FIND v(dout1_409) AT=265.025n

.meas tran vdout1_410ck520 FIND v(dout1_410) AT=265.025n

.meas tran vdout1_411ck520 FIND v(dout1_411) AT=265.025n

.meas tran vdout1_412ck520 FIND v(dout1_412) AT=265.025n

.meas tran vdout1_413ck520 FIND v(dout1_413) AT=265.025n

.meas tran vdout1_414ck520 FIND v(dout1_414) AT=265.025n

.meas tran vdout1_415ck520 FIND v(dout1_415) AT=265.025n

.meas tran vdout1_416ck520 FIND v(dout1_416) AT=265.025n

.meas tran vdout1_417ck520 FIND v(dout1_417) AT=265.025n

.meas tran vdout1_418ck520 FIND v(dout1_418) AT=265.025n

.meas tran vdout1_419ck520 FIND v(dout1_419) AT=265.025n

.meas tran vdout1_420ck520 FIND v(dout1_420) AT=265.025n

.meas tran vdout1_421ck520 FIND v(dout1_421) AT=265.025n

.meas tran vdout1_422ck520 FIND v(dout1_422) AT=265.025n

.meas tran vdout1_423ck520 FIND v(dout1_423) AT=265.025n

.meas tran vdout1_424ck520 FIND v(dout1_424) AT=265.025n

.meas tran vdout1_425ck520 FIND v(dout1_425) AT=265.025n

.meas tran vdout1_426ck520 FIND v(dout1_426) AT=265.025n

.meas tran vdout1_427ck520 FIND v(dout1_427) AT=265.025n

.meas tran vdout1_428ck520 FIND v(dout1_428) AT=265.025n

.meas tran vdout1_429ck520 FIND v(dout1_429) AT=265.025n

.meas tran vdout1_430ck520 FIND v(dout1_430) AT=265.025n

.meas tran vdout1_431ck520 FIND v(dout1_431) AT=265.025n

.meas tran vdout1_432ck520 FIND v(dout1_432) AT=265.025n

.meas tran vdout1_433ck520 FIND v(dout1_433) AT=265.025n

.meas tran vdout1_434ck520 FIND v(dout1_434) AT=265.025n

.meas tran vdout1_435ck520 FIND v(dout1_435) AT=265.025n

.meas tran vdout1_436ck520 FIND v(dout1_436) AT=265.025n

.meas tran vdout1_437ck520 FIND v(dout1_437) AT=265.025n

.meas tran vdout1_438ck520 FIND v(dout1_438) AT=265.025n

.meas tran vdout1_439ck520 FIND v(dout1_439) AT=265.025n

.meas tran vdout1_440ck520 FIND v(dout1_440) AT=265.025n

.meas tran vdout1_441ck520 FIND v(dout1_441) AT=265.025n

.meas tran vdout1_442ck520 FIND v(dout1_442) AT=265.025n

.meas tran vdout1_443ck520 FIND v(dout1_443) AT=265.025n

.meas tran vdout1_444ck520 FIND v(dout1_444) AT=265.025n

.meas tran vdout1_445ck520 FIND v(dout1_445) AT=265.025n

.meas tran vdout1_446ck520 FIND v(dout1_446) AT=265.025n

.meas tran vdout1_447ck520 FIND v(dout1_447) AT=265.025n

.meas tran vdout1_448ck520 FIND v(dout1_448) AT=265.025n

.meas tran vdout1_449ck520 FIND v(dout1_449) AT=265.025n

.meas tran vdout1_450ck520 FIND v(dout1_450) AT=265.025n

.meas tran vdout1_451ck520 FIND v(dout1_451) AT=265.025n

.meas tran vdout1_452ck520 FIND v(dout1_452) AT=265.025n

.meas tran vdout1_453ck520 FIND v(dout1_453) AT=265.025n

.meas tran vdout1_454ck520 FIND v(dout1_454) AT=265.025n

.meas tran vdout1_455ck520 FIND v(dout1_455) AT=265.025n

.meas tran vdout1_456ck520 FIND v(dout1_456) AT=265.025n

.meas tran vdout1_457ck520 FIND v(dout1_457) AT=265.025n

.meas tran vdout1_458ck520 FIND v(dout1_458) AT=265.025n

.meas tran vdout1_459ck520 FIND v(dout1_459) AT=265.025n

.meas tran vdout1_460ck520 FIND v(dout1_460) AT=265.025n

.meas tran vdout1_461ck520 FIND v(dout1_461) AT=265.025n

.meas tran vdout1_462ck520 FIND v(dout1_462) AT=265.025n

.meas tran vdout1_463ck520 FIND v(dout1_463) AT=265.025n

.meas tran vdout1_464ck520 FIND v(dout1_464) AT=265.025n

.meas tran vdout1_465ck520 FIND v(dout1_465) AT=265.025n

.meas tran vdout1_466ck520 FIND v(dout1_466) AT=265.025n

.meas tran vdout1_467ck520 FIND v(dout1_467) AT=265.025n

.meas tran vdout1_468ck520 FIND v(dout1_468) AT=265.025n

.meas tran vdout1_469ck520 FIND v(dout1_469) AT=265.025n

.meas tran vdout1_470ck520 FIND v(dout1_470) AT=265.025n

.meas tran vdout1_471ck520 FIND v(dout1_471) AT=265.025n

.meas tran vdout1_472ck520 FIND v(dout1_472) AT=265.025n

.meas tran vdout1_473ck520 FIND v(dout1_473) AT=265.025n

.meas tran vdout1_474ck520 FIND v(dout1_474) AT=265.025n

.meas tran vdout1_475ck520 FIND v(dout1_475) AT=265.025n

.meas tran vdout1_476ck520 FIND v(dout1_476) AT=265.025n

.meas tran vdout1_477ck520 FIND v(dout1_477) AT=265.025n

.meas tran vdout1_478ck520 FIND v(dout1_478) AT=265.025n

.meas tran vdout1_479ck520 FIND v(dout1_479) AT=265.025n

.meas tran vdout1_480ck520 FIND v(dout1_480) AT=265.025n

.meas tran vdout1_481ck520 FIND v(dout1_481) AT=265.025n

.meas tran vdout1_482ck520 FIND v(dout1_482) AT=265.025n

.meas tran vdout1_483ck520 FIND v(dout1_483) AT=265.025n

.meas tran vdout1_484ck520 FIND v(dout1_484) AT=265.025n

.meas tran vdout1_485ck520 FIND v(dout1_485) AT=265.025n

.meas tran vdout1_486ck520 FIND v(dout1_486) AT=265.025n

.meas tran vdout1_487ck520 FIND v(dout1_487) AT=265.025n

.meas tran vdout1_488ck520 FIND v(dout1_488) AT=265.025n

.meas tran vdout1_489ck520 FIND v(dout1_489) AT=265.025n

.meas tran vdout1_490ck520 FIND v(dout1_490) AT=265.025n

.meas tran vdout1_491ck520 FIND v(dout1_491) AT=265.025n

.meas tran vdout1_492ck520 FIND v(dout1_492) AT=265.025n

.meas tran vdout1_493ck520 FIND v(dout1_493) AT=265.025n

.meas tran vdout1_494ck520 FIND v(dout1_494) AT=265.025n

.meas tran vdout1_495ck520 FIND v(dout1_495) AT=265.025n

.meas tran vdout1_496ck520 FIND v(dout1_496) AT=265.025n

.meas tran vdout1_497ck520 FIND v(dout1_497) AT=265.025n

.meas tran vdout1_498ck520 FIND v(dout1_498) AT=265.025n

.meas tran vdout1_499ck520 FIND v(dout1_499) AT=265.025n

.meas tran vdout1_500ck520 FIND v(dout1_500) AT=265.025n

.meas tran vdout1_501ck520 FIND v(dout1_501) AT=265.025n

.meas tran vdout1_502ck520 FIND v(dout1_502) AT=265.025n

.meas tran vdout1_503ck520 FIND v(dout1_503) AT=265.025n

.meas tran vdout1_504ck520 FIND v(dout1_504) AT=265.025n

.meas tran vdout1_505ck520 FIND v(dout1_505) AT=265.025n

.meas tran vdout1_506ck520 FIND v(dout1_506) AT=265.025n

.meas tran vdout1_507ck520 FIND v(dout1_507) AT=265.025n

.meas tran vdout1_508ck520 FIND v(dout1_508) AT=265.025n

.meas tran vdout1_509ck520 FIND v(dout1_509) AT=265.025n

.meas tran vdout1_510ck520 FIND v(dout1_510) AT=265.025n

.meas tran vdout1_511ck520 FIND v(dout1_511) AT=265.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_22ck530 FIND v(dout1_22) AT=270.025n

.meas tran vdout1_23ck530 FIND v(dout1_23) AT=270.025n

.meas tran vdout1_24ck530 FIND v(dout1_24) AT=270.025n

.meas tran vdout1_25ck530 FIND v(dout1_25) AT=270.025n

.meas tran vdout1_26ck530 FIND v(dout1_26) AT=270.025n

.meas tran vdout1_27ck530 FIND v(dout1_27) AT=270.025n

.meas tran vdout1_28ck530 FIND v(dout1_28) AT=270.025n

.meas tran vdout1_29ck530 FIND v(dout1_29) AT=270.025n

.meas tran vdout1_30ck530 FIND v(dout1_30) AT=270.025n

.meas tran vdout1_31ck530 FIND v(dout1_31) AT=270.025n

.meas tran vdout1_32ck530 FIND v(dout1_32) AT=270.025n

.meas tran vdout1_33ck530 FIND v(dout1_33) AT=270.025n

.meas tran vdout1_34ck530 FIND v(dout1_34) AT=270.025n

.meas tran vdout1_35ck530 FIND v(dout1_35) AT=270.025n

.meas tran vdout1_36ck530 FIND v(dout1_36) AT=270.025n

.meas tran vdout1_37ck530 FIND v(dout1_37) AT=270.025n

.meas tran vdout1_38ck530 FIND v(dout1_38) AT=270.025n

.meas tran vdout1_39ck530 FIND v(dout1_39) AT=270.025n

.meas tran vdout1_40ck530 FIND v(dout1_40) AT=270.025n

.meas tran vdout1_41ck530 FIND v(dout1_41) AT=270.025n

.meas tran vdout1_42ck530 FIND v(dout1_42) AT=270.025n

.meas tran vdout1_43ck530 FIND v(dout1_43) AT=270.025n

.meas tran vdout1_44ck530 FIND v(dout1_44) AT=270.025n

.meas tran vdout1_45ck530 FIND v(dout1_45) AT=270.025n

.meas tran vdout1_46ck530 FIND v(dout1_46) AT=270.025n

.meas tran vdout1_47ck530 FIND v(dout1_47) AT=270.025n

.meas tran vdout1_48ck530 FIND v(dout1_48) AT=270.025n

.meas tran vdout1_49ck530 FIND v(dout1_49) AT=270.025n

.meas tran vdout1_50ck530 FIND v(dout1_50) AT=270.025n

.meas tran vdout1_51ck530 FIND v(dout1_51) AT=270.025n

.meas tran vdout1_52ck530 FIND v(dout1_52) AT=270.025n

.meas tran vdout1_53ck530 FIND v(dout1_53) AT=270.025n

.meas tran vdout1_54ck530 FIND v(dout1_54) AT=270.025n

.meas tran vdout1_55ck530 FIND v(dout1_55) AT=270.025n

.meas tran vdout1_56ck530 FIND v(dout1_56) AT=270.025n

.meas tran vdout1_57ck530 FIND v(dout1_57) AT=270.025n

.meas tran vdout1_58ck530 FIND v(dout1_58) AT=270.025n

.meas tran vdout1_59ck530 FIND v(dout1_59) AT=270.025n

.meas tran vdout1_60ck530 FIND v(dout1_60) AT=270.025n

.meas tran vdout1_61ck530 FIND v(dout1_61) AT=270.025n

.meas tran vdout1_62ck530 FIND v(dout1_62) AT=270.025n

.meas tran vdout1_63ck530 FIND v(dout1_63) AT=270.025n

.meas tran vdout1_64ck530 FIND v(dout1_64) AT=270.025n

.meas tran vdout1_65ck530 FIND v(dout1_65) AT=270.025n

.meas tran vdout1_66ck530 FIND v(dout1_66) AT=270.025n

.meas tran vdout1_67ck530 FIND v(dout1_67) AT=270.025n

.meas tran vdout1_68ck530 FIND v(dout1_68) AT=270.025n

.meas tran vdout1_69ck530 FIND v(dout1_69) AT=270.025n

.meas tran vdout1_70ck530 FIND v(dout1_70) AT=270.025n

.meas tran vdout1_71ck530 FIND v(dout1_71) AT=270.025n

.meas tran vdout1_72ck530 FIND v(dout1_72) AT=270.025n

.meas tran vdout1_73ck530 FIND v(dout1_73) AT=270.025n

.meas tran vdout1_74ck530 FIND v(dout1_74) AT=270.025n

.meas tran vdout1_75ck530 FIND v(dout1_75) AT=270.025n

.meas tran vdout1_76ck530 FIND v(dout1_76) AT=270.025n

.meas tran vdout1_77ck530 FIND v(dout1_77) AT=270.025n

.meas tran vdout1_78ck530 FIND v(dout1_78) AT=270.025n

.meas tran vdout1_79ck530 FIND v(dout1_79) AT=270.025n

.meas tran vdout1_80ck530 FIND v(dout1_80) AT=270.025n

.meas tran vdout1_81ck530 FIND v(dout1_81) AT=270.025n

.meas tran vdout1_82ck530 FIND v(dout1_82) AT=270.025n

.meas tran vdout1_83ck530 FIND v(dout1_83) AT=270.025n

.meas tran vdout1_84ck530 FIND v(dout1_84) AT=270.025n

.meas tran vdout1_85ck530 FIND v(dout1_85) AT=270.025n

.meas tran vdout1_86ck530 FIND v(dout1_86) AT=270.025n

.meas tran vdout1_87ck530 FIND v(dout1_87) AT=270.025n

.meas tran vdout1_88ck530 FIND v(dout1_88) AT=270.025n

.meas tran vdout1_89ck530 FIND v(dout1_89) AT=270.025n

.meas tran vdout1_90ck530 FIND v(dout1_90) AT=270.025n

.meas tran vdout1_91ck530 FIND v(dout1_91) AT=270.025n

.meas tran vdout1_92ck530 FIND v(dout1_92) AT=270.025n

.meas tran vdout1_93ck530 FIND v(dout1_93) AT=270.025n

.meas tran vdout1_94ck530 FIND v(dout1_94) AT=270.025n

.meas tran vdout1_95ck530 FIND v(dout1_95) AT=270.025n

.meas tran vdout1_96ck530 FIND v(dout1_96) AT=270.025n

.meas tran vdout1_97ck530 FIND v(dout1_97) AT=270.025n

.meas tran vdout1_98ck530 FIND v(dout1_98) AT=270.025n

.meas tran vdout1_99ck530 FIND v(dout1_99) AT=270.025n

.meas tran vdout1_100ck530 FIND v(dout1_100) AT=270.025n

.meas tran vdout1_101ck530 FIND v(dout1_101) AT=270.025n

.meas tran vdout1_102ck530 FIND v(dout1_102) AT=270.025n

.meas tran vdout1_103ck530 FIND v(dout1_103) AT=270.025n

.meas tran vdout1_104ck530 FIND v(dout1_104) AT=270.025n

.meas tran vdout1_105ck530 FIND v(dout1_105) AT=270.025n

.meas tran vdout1_106ck530 FIND v(dout1_106) AT=270.025n

.meas tran vdout1_107ck530 FIND v(dout1_107) AT=270.025n

.meas tran vdout1_108ck530 FIND v(dout1_108) AT=270.025n

.meas tran vdout1_109ck530 FIND v(dout1_109) AT=270.025n

.meas tran vdout1_110ck530 FIND v(dout1_110) AT=270.025n

.meas tran vdout1_111ck530 FIND v(dout1_111) AT=270.025n

.meas tran vdout1_112ck530 FIND v(dout1_112) AT=270.025n

.meas tran vdout1_113ck530 FIND v(dout1_113) AT=270.025n

.meas tran vdout1_114ck530 FIND v(dout1_114) AT=270.025n

.meas tran vdout1_115ck530 FIND v(dout1_115) AT=270.025n

.meas tran vdout1_116ck530 FIND v(dout1_116) AT=270.025n

.meas tran vdout1_117ck530 FIND v(dout1_117) AT=270.025n

.meas tran vdout1_118ck530 FIND v(dout1_118) AT=270.025n

.meas tran vdout1_119ck530 FIND v(dout1_119) AT=270.025n

.meas tran vdout1_120ck530 FIND v(dout1_120) AT=270.025n

.meas tran vdout1_121ck530 FIND v(dout1_121) AT=270.025n

.meas tran vdout1_122ck530 FIND v(dout1_122) AT=270.025n

.meas tran vdout1_123ck530 FIND v(dout1_123) AT=270.025n

.meas tran vdout1_124ck530 FIND v(dout1_124) AT=270.025n

.meas tran vdout1_125ck530 FIND v(dout1_125) AT=270.025n

.meas tran vdout1_126ck530 FIND v(dout1_126) AT=270.025n

.meas tran vdout1_127ck530 FIND v(dout1_127) AT=270.025n

.meas tran vdout1_128ck530 FIND v(dout1_128) AT=270.025n

.meas tran vdout1_129ck530 FIND v(dout1_129) AT=270.025n

.meas tran vdout1_130ck530 FIND v(dout1_130) AT=270.025n

.meas tran vdout1_131ck530 FIND v(dout1_131) AT=270.025n

.meas tran vdout1_132ck530 FIND v(dout1_132) AT=270.025n

.meas tran vdout1_133ck530 FIND v(dout1_133) AT=270.025n

.meas tran vdout1_134ck530 FIND v(dout1_134) AT=270.025n

.meas tran vdout1_135ck530 FIND v(dout1_135) AT=270.025n

.meas tran vdout1_136ck530 FIND v(dout1_136) AT=270.025n

.meas tran vdout1_137ck530 FIND v(dout1_137) AT=270.025n

.meas tran vdout1_138ck530 FIND v(dout1_138) AT=270.025n

.meas tran vdout1_139ck530 FIND v(dout1_139) AT=270.025n

.meas tran vdout1_140ck530 FIND v(dout1_140) AT=270.025n

.meas tran vdout1_141ck530 FIND v(dout1_141) AT=270.025n

.meas tran vdout1_142ck530 FIND v(dout1_142) AT=270.025n

.meas tran vdout1_143ck530 FIND v(dout1_143) AT=270.025n

.meas tran vdout1_144ck530 FIND v(dout1_144) AT=270.025n

.meas tran vdout1_145ck530 FIND v(dout1_145) AT=270.025n

.meas tran vdout1_146ck530 FIND v(dout1_146) AT=270.025n

.meas tran vdout1_147ck530 FIND v(dout1_147) AT=270.025n

.meas tran vdout1_148ck530 FIND v(dout1_148) AT=270.025n

.meas tran vdout1_149ck530 FIND v(dout1_149) AT=270.025n

.meas tran vdout1_150ck530 FIND v(dout1_150) AT=270.025n

.meas tran vdout1_151ck530 FIND v(dout1_151) AT=270.025n

.meas tran vdout1_152ck530 FIND v(dout1_152) AT=270.025n

.meas tran vdout1_153ck530 FIND v(dout1_153) AT=270.025n

.meas tran vdout1_154ck530 FIND v(dout1_154) AT=270.025n

.meas tran vdout1_155ck530 FIND v(dout1_155) AT=270.025n

.meas tran vdout1_156ck530 FIND v(dout1_156) AT=270.025n

.meas tran vdout1_157ck530 FIND v(dout1_157) AT=270.025n

.meas tran vdout1_158ck530 FIND v(dout1_158) AT=270.025n

.meas tran vdout1_159ck530 FIND v(dout1_159) AT=270.025n

.meas tran vdout1_160ck530 FIND v(dout1_160) AT=270.025n

.meas tran vdout1_161ck530 FIND v(dout1_161) AT=270.025n

.meas tran vdout1_162ck530 FIND v(dout1_162) AT=270.025n

.meas tran vdout1_163ck530 FIND v(dout1_163) AT=270.025n

.meas tran vdout1_164ck530 FIND v(dout1_164) AT=270.025n

.meas tran vdout1_165ck530 FIND v(dout1_165) AT=270.025n

.meas tran vdout1_166ck530 FIND v(dout1_166) AT=270.025n

.meas tran vdout1_167ck530 FIND v(dout1_167) AT=270.025n

.meas tran vdout1_168ck530 FIND v(dout1_168) AT=270.025n

.meas tran vdout1_169ck530 FIND v(dout1_169) AT=270.025n

.meas tran vdout1_170ck530 FIND v(dout1_170) AT=270.025n

.meas tran vdout1_171ck530 FIND v(dout1_171) AT=270.025n

.meas tran vdout1_172ck530 FIND v(dout1_172) AT=270.025n

.meas tran vdout1_173ck530 FIND v(dout1_173) AT=270.025n

.meas tran vdout1_174ck530 FIND v(dout1_174) AT=270.025n

.meas tran vdout1_175ck530 FIND v(dout1_175) AT=270.025n

.meas tran vdout1_176ck530 FIND v(dout1_176) AT=270.025n

.meas tran vdout1_177ck530 FIND v(dout1_177) AT=270.025n

.meas tran vdout1_178ck530 FIND v(dout1_178) AT=270.025n

.meas tran vdout1_179ck530 FIND v(dout1_179) AT=270.025n

.meas tran vdout1_180ck530 FIND v(dout1_180) AT=270.025n

.meas tran vdout1_181ck530 FIND v(dout1_181) AT=270.025n

.meas tran vdout1_182ck530 FIND v(dout1_182) AT=270.025n

.meas tran vdout1_183ck530 FIND v(dout1_183) AT=270.025n

.meas tran vdout1_184ck530 FIND v(dout1_184) AT=270.025n

.meas tran vdout1_185ck530 FIND v(dout1_185) AT=270.025n

.meas tran vdout1_186ck530 FIND v(dout1_186) AT=270.025n

.meas tran vdout1_187ck530 FIND v(dout1_187) AT=270.025n

.meas tran vdout1_188ck530 FIND v(dout1_188) AT=270.025n

.meas tran vdout1_189ck530 FIND v(dout1_189) AT=270.025n

.meas tran vdout1_190ck530 FIND v(dout1_190) AT=270.025n

.meas tran vdout1_191ck530 FIND v(dout1_191) AT=270.025n

.meas tran vdout1_192ck530 FIND v(dout1_192) AT=270.025n

.meas tran vdout1_193ck530 FIND v(dout1_193) AT=270.025n

.meas tran vdout1_194ck530 FIND v(dout1_194) AT=270.025n

.meas tran vdout1_195ck530 FIND v(dout1_195) AT=270.025n

.meas tran vdout1_196ck530 FIND v(dout1_196) AT=270.025n

.meas tran vdout1_197ck530 FIND v(dout1_197) AT=270.025n

.meas tran vdout1_198ck530 FIND v(dout1_198) AT=270.025n

.meas tran vdout1_199ck530 FIND v(dout1_199) AT=270.025n

.meas tran vdout1_200ck530 FIND v(dout1_200) AT=270.025n

.meas tran vdout1_201ck530 FIND v(dout1_201) AT=270.025n

.meas tran vdout1_202ck530 FIND v(dout1_202) AT=270.025n

.meas tran vdout1_203ck530 FIND v(dout1_203) AT=270.025n

.meas tran vdout1_204ck530 FIND v(dout1_204) AT=270.025n

.meas tran vdout1_205ck530 FIND v(dout1_205) AT=270.025n

.meas tran vdout1_206ck530 FIND v(dout1_206) AT=270.025n

.meas tran vdout1_207ck530 FIND v(dout1_207) AT=270.025n

.meas tran vdout1_208ck530 FIND v(dout1_208) AT=270.025n

.meas tran vdout1_209ck530 FIND v(dout1_209) AT=270.025n

.meas tran vdout1_210ck530 FIND v(dout1_210) AT=270.025n

.meas tran vdout1_211ck530 FIND v(dout1_211) AT=270.025n

.meas tran vdout1_212ck530 FIND v(dout1_212) AT=270.025n

.meas tran vdout1_213ck530 FIND v(dout1_213) AT=270.025n

.meas tran vdout1_214ck530 FIND v(dout1_214) AT=270.025n

.meas tran vdout1_215ck530 FIND v(dout1_215) AT=270.025n

.meas tran vdout1_216ck530 FIND v(dout1_216) AT=270.025n

.meas tran vdout1_217ck530 FIND v(dout1_217) AT=270.025n

.meas tran vdout1_218ck530 FIND v(dout1_218) AT=270.025n

.meas tran vdout1_219ck530 FIND v(dout1_219) AT=270.025n

.meas tran vdout1_220ck530 FIND v(dout1_220) AT=270.025n

.meas tran vdout1_221ck530 FIND v(dout1_221) AT=270.025n

.meas tran vdout1_222ck530 FIND v(dout1_222) AT=270.025n

.meas tran vdout1_223ck530 FIND v(dout1_223) AT=270.025n

.meas tran vdout1_224ck530 FIND v(dout1_224) AT=270.025n

.meas tran vdout1_225ck530 FIND v(dout1_225) AT=270.025n

.meas tran vdout1_226ck530 FIND v(dout1_226) AT=270.025n

.meas tran vdout1_227ck530 FIND v(dout1_227) AT=270.025n

.meas tran vdout1_228ck530 FIND v(dout1_228) AT=270.025n

.meas tran vdout1_229ck530 FIND v(dout1_229) AT=270.025n

.meas tran vdout1_230ck530 FIND v(dout1_230) AT=270.025n

.meas tran vdout1_231ck530 FIND v(dout1_231) AT=270.025n

.meas tran vdout1_232ck530 FIND v(dout1_232) AT=270.025n

.meas tran vdout1_233ck530 FIND v(dout1_233) AT=270.025n

.meas tran vdout1_234ck530 FIND v(dout1_234) AT=270.025n

.meas tran vdout1_235ck530 FIND v(dout1_235) AT=270.025n

.meas tran vdout1_236ck530 FIND v(dout1_236) AT=270.025n

.meas tran vdout1_237ck530 FIND v(dout1_237) AT=270.025n

.meas tran vdout1_238ck530 FIND v(dout1_238) AT=270.025n

.meas tran vdout1_239ck530 FIND v(dout1_239) AT=270.025n

.meas tran vdout1_240ck530 FIND v(dout1_240) AT=270.025n

.meas tran vdout1_241ck530 FIND v(dout1_241) AT=270.025n

.meas tran vdout1_242ck530 FIND v(dout1_242) AT=270.025n

.meas tran vdout1_243ck530 FIND v(dout1_243) AT=270.025n

.meas tran vdout1_244ck530 FIND v(dout1_244) AT=270.025n

.meas tran vdout1_245ck530 FIND v(dout1_245) AT=270.025n

.meas tran vdout1_246ck530 FIND v(dout1_246) AT=270.025n

.meas tran vdout1_247ck530 FIND v(dout1_247) AT=270.025n

.meas tran vdout1_248ck530 FIND v(dout1_248) AT=270.025n

.meas tran vdout1_249ck530 FIND v(dout1_249) AT=270.025n

.meas tran vdout1_250ck530 FIND v(dout1_250) AT=270.025n

.meas tran vdout1_251ck530 FIND v(dout1_251) AT=270.025n

.meas tran vdout1_252ck530 FIND v(dout1_252) AT=270.025n

.meas tran vdout1_253ck530 FIND v(dout1_253) AT=270.025n

.meas tran vdout1_254ck530 FIND v(dout1_254) AT=270.025n

.meas tran vdout1_255ck530 FIND v(dout1_255) AT=270.025n

.meas tran vdout1_256ck530 FIND v(dout1_256) AT=270.025n

.meas tran vdout1_257ck530 FIND v(dout1_257) AT=270.025n

.meas tran vdout1_258ck530 FIND v(dout1_258) AT=270.025n

.meas tran vdout1_259ck530 FIND v(dout1_259) AT=270.025n

.meas tran vdout1_260ck530 FIND v(dout1_260) AT=270.025n

.meas tran vdout1_261ck530 FIND v(dout1_261) AT=270.025n

.meas tran vdout1_262ck530 FIND v(dout1_262) AT=270.025n

.meas tran vdout1_263ck530 FIND v(dout1_263) AT=270.025n

.meas tran vdout1_264ck530 FIND v(dout1_264) AT=270.025n

.meas tran vdout1_265ck530 FIND v(dout1_265) AT=270.025n

.meas tran vdout1_266ck530 FIND v(dout1_266) AT=270.025n

.meas tran vdout1_267ck530 FIND v(dout1_267) AT=270.025n

.meas tran vdout1_268ck530 FIND v(dout1_268) AT=270.025n

.meas tran vdout1_269ck530 FIND v(dout1_269) AT=270.025n

.meas tran vdout1_270ck530 FIND v(dout1_270) AT=270.025n

.meas tran vdout1_271ck530 FIND v(dout1_271) AT=270.025n

.meas tran vdout1_272ck530 FIND v(dout1_272) AT=270.025n

.meas tran vdout1_273ck530 FIND v(dout1_273) AT=270.025n

.meas tran vdout1_274ck530 FIND v(dout1_274) AT=270.025n

.meas tran vdout1_275ck530 FIND v(dout1_275) AT=270.025n

.meas tran vdout1_276ck530 FIND v(dout1_276) AT=270.025n

.meas tran vdout1_277ck530 FIND v(dout1_277) AT=270.025n

.meas tran vdout1_278ck530 FIND v(dout1_278) AT=270.025n

.meas tran vdout1_279ck530 FIND v(dout1_279) AT=270.025n

.meas tran vdout1_280ck530 FIND v(dout1_280) AT=270.025n

.meas tran vdout1_281ck530 FIND v(dout1_281) AT=270.025n

.meas tran vdout1_282ck530 FIND v(dout1_282) AT=270.025n

.meas tran vdout1_283ck530 FIND v(dout1_283) AT=270.025n

.meas tran vdout1_284ck530 FIND v(dout1_284) AT=270.025n

.meas tran vdout1_285ck530 FIND v(dout1_285) AT=270.025n

.meas tran vdout1_286ck530 FIND v(dout1_286) AT=270.025n

.meas tran vdout1_287ck530 FIND v(dout1_287) AT=270.025n

.meas tran vdout1_288ck530 FIND v(dout1_288) AT=270.025n

.meas tran vdout1_289ck530 FIND v(dout1_289) AT=270.025n

.meas tran vdout1_290ck530 FIND v(dout1_290) AT=270.025n

.meas tran vdout1_291ck530 FIND v(dout1_291) AT=270.025n

.meas tran vdout1_292ck530 FIND v(dout1_292) AT=270.025n

.meas tran vdout1_293ck530 FIND v(dout1_293) AT=270.025n

.meas tran vdout1_294ck530 FIND v(dout1_294) AT=270.025n

.meas tran vdout1_295ck530 FIND v(dout1_295) AT=270.025n

.meas tran vdout1_296ck530 FIND v(dout1_296) AT=270.025n

.meas tran vdout1_297ck530 FIND v(dout1_297) AT=270.025n

.meas tran vdout1_298ck530 FIND v(dout1_298) AT=270.025n

.meas tran vdout1_299ck530 FIND v(dout1_299) AT=270.025n

.meas tran vdout1_300ck530 FIND v(dout1_300) AT=270.025n

.meas tran vdout1_301ck530 FIND v(dout1_301) AT=270.025n

.meas tran vdout1_302ck530 FIND v(dout1_302) AT=270.025n

.meas tran vdout1_303ck530 FIND v(dout1_303) AT=270.025n

.meas tran vdout1_304ck530 FIND v(dout1_304) AT=270.025n

.meas tran vdout1_305ck530 FIND v(dout1_305) AT=270.025n

.meas tran vdout1_306ck530 FIND v(dout1_306) AT=270.025n

.meas tran vdout1_307ck530 FIND v(dout1_307) AT=270.025n

.meas tran vdout1_308ck530 FIND v(dout1_308) AT=270.025n

.meas tran vdout1_309ck530 FIND v(dout1_309) AT=270.025n

.meas tran vdout1_310ck530 FIND v(dout1_310) AT=270.025n

.meas tran vdout1_311ck530 FIND v(dout1_311) AT=270.025n

.meas tran vdout1_312ck530 FIND v(dout1_312) AT=270.025n

.meas tran vdout1_313ck530 FIND v(dout1_313) AT=270.025n

.meas tran vdout1_314ck530 FIND v(dout1_314) AT=270.025n

.meas tran vdout1_315ck530 FIND v(dout1_315) AT=270.025n

.meas tran vdout1_316ck530 FIND v(dout1_316) AT=270.025n

.meas tran vdout1_317ck530 FIND v(dout1_317) AT=270.025n

.meas tran vdout1_318ck530 FIND v(dout1_318) AT=270.025n

.meas tran vdout1_319ck530 FIND v(dout1_319) AT=270.025n

.meas tran vdout1_320ck530 FIND v(dout1_320) AT=270.025n

.meas tran vdout1_321ck530 FIND v(dout1_321) AT=270.025n

.meas tran vdout1_322ck530 FIND v(dout1_322) AT=270.025n

.meas tran vdout1_323ck530 FIND v(dout1_323) AT=270.025n

.meas tran vdout1_324ck530 FIND v(dout1_324) AT=270.025n

.meas tran vdout1_325ck530 FIND v(dout1_325) AT=270.025n

.meas tran vdout1_326ck530 FIND v(dout1_326) AT=270.025n

.meas tran vdout1_327ck530 FIND v(dout1_327) AT=270.025n

.meas tran vdout1_328ck530 FIND v(dout1_328) AT=270.025n

.meas tran vdout1_329ck530 FIND v(dout1_329) AT=270.025n

.meas tran vdout1_330ck530 FIND v(dout1_330) AT=270.025n

.meas tran vdout1_331ck530 FIND v(dout1_331) AT=270.025n

.meas tran vdout1_332ck530 FIND v(dout1_332) AT=270.025n

.meas tran vdout1_333ck530 FIND v(dout1_333) AT=270.025n

.meas tran vdout1_334ck530 FIND v(dout1_334) AT=270.025n

.meas tran vdout1_335ck530 FIND v(dout1_335) AT=270.025n

.meas tran vdout1_336ck530 FIND v(dout1_336) AT=270.025n

.meas tran vdout1_337ck530 FIND v(dout1_337) AT=270.025n

.meas tran vdout1_338ck530 FIND v(dout1_338) AT=270.025n

.meas tran vdout1_339ck530 FIND v(dout1_339) AT=270.025n

.meas tran vdout1_340ck530 FIND v(dout1_340) AT=270.025n

.meas tran vdout1_341ck530 FIND v(dout1_341) AT=270.025n

.meas tran vdout1_342ck530 FIND v(dout1_342) AT=270.025n

.meas tran vdout1_343ck530 FIND v(dout1_343) AT=270.025n

.meas tran vdout1_344ck530 FIND v(dout1_344) AT=270.025n

.meas tran vdout1_345ck530 FIND v(dout1_345) AT=270.025n

.meas tran vdout1_346ck530 FIND v(dout1_346) AT=270.025n

.meas tran vdout1_347ck530 FIND v(dout1_347) AT=270.025n

.meas tran vdout1_348ck530 FIND v(dout1_348) AT=270.025n

.meas tran vdout1_349ck530 FIND v(dout1_349) AT=270.025n

.meas tran vdout1_350ck530 FIND v(dout1_350) AT=270.025n

.meas tran vdout1_351ck530 FIND v(dout1_351) AT=270.025n

.meas tran vdout1_352ck530 FIND v(dout1_352) AT=270.025n

.meas tran vdout1_353ck530 FIND v(dout1_353) AT=270.025n

.meas tran vdout1_354ck530 FIND v(dout1_354) AT=270.025n

.meas tran vdout1_355ck530 FIND v(dout1_355) AT=270.025n

.meas tran vdout1_356ck530 FIND v(dout1_356) AT=270.025n

.meas tran vdout1_357ck530 FIND v(dout1_357) AT=270.025n

.meas tran vdout1_358ck530 FIND v(dout1_358) AT=270.025n

.meas tran vdout1_359ck530 FIND v(dout1_359) AT=270.025n

.meas tran vdout1_360ck530 FIND v(dout1_360) AT=270.025n

.meas tran vdout1_361ck530 FIND v(dout1_361) AT=270.025n

.meas tran vdout1_362ck530 FIND v(dout1_362) AT=270.025n

.meas tran vdout1_363ck530 FIND v(dout1_363) AT=270.025n

.meas tran vdout1_364ck530 FIND v(dout1_364) AT=270.025n

.meas tran vdout1_365ck530 FIND v(dout1_365) AT=270.025n

.meas tran vdout1_366ck530 FIND v(dout1_366) AT=270.025n

.meas tran vdout1_367ck530 FIND v(dout1_367) AT=270.025n

.meas tran vdout1_368ck530 FIND v(dout1_368) AT=270.025n

.meas tran vdout1_369ck530 FIND v(dout1_369) AT=270.025n

.meas tran vdout1_370ck530 FIND v(dout1_370) AT=270.025n

.meas tran vdout1_371ck530 FIND v(dout1_371) AT=270.025n

.meas tran vdout1_372ck530 FIND v(dout1_372) AT=270.025n

.meas tran vdout1_373ck530 FIND v(dout1_373) AT=270.025n

.meas tran vdout1_374ck530 FIND v(dout1_374) AT=270.025n

.meas tran vdout1_375ck530 FIND v(dout1_375) AT=270.025n

.meas tran vdout1_376ck530 FIND v(dout1_376) AT=270.025n

.meas tran vdout1_377ck530 FIND v(dout1_377) AT=270.025n

.meas tran vdout1_378ck530 FIND v(dout1_378) AT=270.025n

.meas tran vdout1_379ck530 FIND v(dout1_379) AT=270.025n

.meas tran vdout1_380ck530 FIND v(dout1_380) AT=270.025n

.meas tran vdout1_381ck530 FIND v(dout1_381) AT=270.025n

.meas tran vdout1_382ck530 FIND v(dout1_382) AT=270.025n

.meas tran vdout1_383ck530 FIND v(dout1_383) AT=270.025n

.meas tran vdout1_384ck530 FIND v(dout1_384) AT=270.025n

.meas tran vdout1_385ck530 FIND v(dout1_385) AT=270.025n

.meas tran vdout1_386ck530 FIND v(dout1_386) AT=270.025n

.meas tran vdout1_387ck530 FIND v(dout1_387) AT=270.025n

.meas tran vdout1_388ck530 FIND v(dout1_388) AT=270.025n

.meas tran vdout1_389ck530 FIND v(dout1_389) AT=270.025n

.meas tran vdout1_390ck530 FIND v(dout1_390) AT=270.025n

.meas tran vdout1_391ck530 FIND v(dout1_391) AT=270.025n

.meas tran vdout1_392ck530 FIND v(dout1_392) AT=270.025n

.meas tran vdout1_393ck530 FIND v(dout1_393) AT=270.025n

.meas tran vdout1_394ck530 FIND v(dout1_394) AT=270.025n

.meas tran vdout1_395ck530 FIND v(dout1_395) AT=270.025n

.meas tran vdout1_396ck530 FIND v(dout1_396) AT=270.025n

.meas tran vdout1_397ck530 FIND v(dout1_397) AT=270.025n

.meas tran vdout1_398ck530 FIND v(dout1_398) AT=270.025n

.meas tran vdout1_399ck530 FIND v(dout1_399) AT=270.025n

.meas tran vdout1_400ck530 FIND v(dout1_400) AT=270.025n

.meas tran vdout1_401ck530 FIND v(dout1_401) AT=270.025n

.meas tran vdout1_402ck530 FIND v(dout1_402) AT=270.025n

.meas tran vdout1_403ck530 FIND v(dout1_403) AT=270.025n

.meas tran vdout1_404ck530 FIND v(dout1_404) AT=270.025n

.meas tran vdout1_405ck530 FIND v(dout1_405) AT=270.025n

.meas tran vdout1_406ck530 FIND v(dout1_406) AT=270.025n

.meas tran vdout1_407ck530 FIND v(dout1_407) AT=270.025n

.meas tran vdout1_408ck530 FIND v(dout1_408) AT=270.025n

.meas tran vdout1_409ck530 FIND v(dout1_409) AT=270.025n

.meas tran vdout1_410ck530 FIND v(dout1_410) AT=270.025n

.meas tran vdout1_411ck530 FIND v(dout1_411) AT=270.025n

.meas tran vdout1_412ck530 FIND v(dout1_412) AT=270.025n

.meas tran vdout1_413ck530 FIND v(dout1_413) AT=270.025n

.meas tran vdout1_414ck530 FIND v(dout1_414) AT=270.025n

.meas tran vdout1_415ck530 FIND v(dout1_415) AT=270.025n

.meas tran vdout1_416ck530 FIND v(dout1_416) AT=270.025n

.meas tran vdout1_417ck530 FIND v(dout1_417) AT=270.025n

.meas tran vdout1_418ck530 FIND v(dout1_418) AT=270.025n

.meas tran vdout1_419ck530 FIND v(dout1_419) AT=270.025n

.meas tran vdout1_420ck530 FIND v(dout1_420) AT=270.025n

.meas tran vdout1_421ck530 FIND v(dout1_421) AT=270.025n

.meas tran vdout1_422ck530 FIND v(dout1_422) AT=270.025n

.meas tran vdout1_423ck530 FIND v(dout1_423) AT=270.025n

.meas tran vdout1_424ck530 FIND v(dout1_424) AT=270.025n

.meas tran vdout1_425ck530 FIND v(dout1_425) AT=270.025n

.meas tran vdout1_426ck530 FIND v(dout1_426) AT=270.025n

.meas tran vdout1_427ck530 FIND v(dout1_427) AT=270.025n

.meas tran vdout1_428ck530 FIND v(dout1_428) AT=270.025n

.meas tran vdout1_429ck530 FIND v(dout1_429) AT=270.025n

.meas tran vdout1_430ck530 FIND v(dout1_430) AT=270.025n

.meas tran vdout1_431ck530 FIND v(dout1_431) AT=270.025n

.meas tran vdout1_432ck530 FIND v(dout1_432) AT=270.025n

.meas tran vdout1_433ck530 FIND v(dout1_433) AT=270.025n

.meas tran vdout1_434ck530 FIND v(dout1_434) AT=270.025n

.meas tran vdout1_435ck530 FIND v(dout1_435) AT=270.025n

.meas tran vdout1_436ck530 FIND v(dout1_436) AT=270.025n

.meas tran vdout1_437ck530 FIND v(dout1_437) AT=270.025n

.meas tran vdout1_438ck530 FIND v(dout1_438) AT=270.025n

.meas tran vdout1_439ck530 FIND v(dout1_439) AT=270.025n

.meas tran vdout1_440ck530 FIND v(dout1_440) AT=270.025n

.meas tran vdout1_441ck530 FIND v(dout1_441) AT=270.025n

.meas tran vdout1_442ck530 FIND v(dout1_442) AT=270.025n

.meas tran vdout1_443ck530 FIND v(dout1_443) AT=270.025n

.meas tran vdout1_444ck530 FIND v(dout1_444) AT=270.025n

.meas tran vdout1_445ck530 FIND v(dout1_445) AT=270.025n

.meas tran vdout1_446ck530 FIND v(dout1_446) AT=270.025n

.meas tran vdout1_447ck530 FIND v(dout1_447) AT=270.025n

.meas tran vdout1_448ck530 FIND v(dout1_448) AT=270.025n

.meas tran vdout1_449ck530 FIND v(dout1_449) AT=270.025n

.meas tran vdout1_450ck530 FIND v(dout1_450) AT=270.025n

.meas tran vdout1_451ck530 FIND v(dout1_451) AT=270.025n

.meas tran vdout1_452ck530 FIND v(dout1_452) AT=270.025n

.meas tran vdout1_453ck530 FIND v(dout1_453) AT=270.025n

.meas tran vdout1_454ck530 FIND v(dout1_454) AT=270.025n

.meas tran vdout1_455ck530 FIND v(dout1_455) AT=270.025n

.meas tran vdout1_456ck530 FIND v(dout1_456) AT=270.025n

.meas tran vdout1_457ck530 FIND v(dout1_457) AT=270.025n

.meas tran vdout1_458ck530 FIND v(dout1_458) AT=270.025n

.meas tran vdout1_459ck530 FIND v(dout1_459) AT=270.025n

.meas tran vdout1_460ck530 FIND v(dout1_460) AT=270.025n

.meas tran vdout1_461ck530 FIND v(dout1_461) AT=270.025n

.meas tran vdout1_462ck530 FIND v(dout1_462) AT=270.025n

.meas tran vdout1_463ck530 FIND v(dout1_463) AT=270.025n

.meas tran vdout1_464ck530 FIND v(dout1_464) AT=270.025n

.meas tran vdout1_465ck530 FIND v(dout1_465) AT=270.025n

.meas tran vdout1_466ck530 FIND v(dout1_466) AT=270.025n

.meas tran vdout1_467ck530 FIND v(dout1_467) AT=270.025n

.meas tran vdout1_468ck530 FIND v(dout1_468) AT=270.025n

.meas tran vdout1_469ck530 FIND v(dout1_469) AT=270.025n

.meas tran vdout1_470ck530 FIND v(dout1_470) AT=270.025n

.meas tran vdout1_471ck530 FIND v(dout1_471) AT=270.025n

.meas tran vdout1_472ck530 FIND v(dout1_472) AT=270.025n

.meas tran vdout1_473ck530 FIND v(dout1_473) AT=270.025n

.meas tran vdout1_474ck530 FIND v(dout1_474) AT=270.025n

.meas tran vdout1_475ck530 FIND v(dout1_475) AT=270.025n

.meas tran vdout1_476ck530 FIND v(dout1_476) AT=270.025n

.meas tran vdout1_477ck530 FIND v(dout1_477) AT=270.025n

.meas tran vdout1_478ck530 FIND v(dout1_478) AT=270.025n

.meas tran vdout1_479ck530 FIND v(dout1_479) AT=270.025n

.meas tran vdout1_480ck530 FIND v(dout1_480) AT=270.025n

.meas tran vdout1_481ck530 FIND v(dout1_481) AT=270.025n

.meas tran vdout1_482ck530 FIND v(dout1_482) AT=270.025n

.meas tran vdout1_483ck530 FIND v(dout1_483) AT=270.025n

.meas tran vdout1_484ck530 FIND v(dout1_484) AT=270.025n

.meas tran vdout1_485ck530 FIND v(dout1_485) AT=270.025n

.meas tran vdout1_486ck530 FIND v(dout1_486) AT=270.025n

.meas tran vdout1_487ck530 FIND v(dout1_487) AT=270.025n

.meas tran vdout1_488ck530 FIND v(dout1_488) AT=270.025n

.meas tran vdout1_489ck530 FIND v(dout1_489) AT=270.025n

.meas tran vdout1_490ck530 FIND v(dout1_490) AT=270.025n

.meas tran vdout1_491ck530 FIND v(dout1_491) AT=270.025n

.meas tran vdout1_492ck530 FIND v(dout1_492) AT=270.025n

.meas tran vdout1_493ck530 FIND v(dout1_493) AT=270.025n

.meas tran vdout1_494ck530 FIND v(dout1_494) AT=270.025n

.meas tran vdout1_495ck530 FIND v(dout1_495) AT=270.025n

.meas tran vdout1_496ck530 FIND v(dout1_496) AT=270.025n

.meas tran vdout1_497ck530 FIND v(dout1_497) AT=270.025n

.meas tran vdout1_498ck530 FIND v(dout1_498) AT=270.025n

.meas tran vdout1_499ck530 FIND v(dout1_499) AT=270.025n

.meas tran vdout1_500ck530 FIND v(dout1_500) AT=270.025n

.meas tran vdout1_501ck530 FIND v(dout1_501) AT=270.025n

.meas tran vdout1_502ck530 FIND v(dout1_502) AT=270.025n

.meas tran vdout1_503ck530 FIND v(dout1_503) AT=270.025n

.meas tran vdout1_504ck530 FIND v(dout1_504) AT=270.025n

.meas tran vdout1_505ck530 FIND v(dout1_505) AT=270.025n

.meas tran vdout1_506ck530 FIND v(dout1_506) AT=270.025n

.meas tran vdout1_507ck530 FIND v(dout1_507) AT=270.025n

.meas tran vdout1_508ck530 FIND v(dout1_508) AT=270.025n

.meas tran vdout1_509ck530 FIND v(dout1_509) AT=270.025n

.meas tran vdout1_510ck530 FIND v(dout1_510) AT=270.025n

.meas tran vdout1_511ck530 FIND v(dout1_511) AT=270.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_32ck600 FIND v(dout1_32) AT=305.025n

.meas tran vdout1_33ck600 FIND v(dout1_33) AT=305.025n

.meas tran vdout1_34ck600 FIND v(dout1_34) AT=305.025n

.meas tran vdout1_35ck600 FIND v(dout1_35) AT=305.025n

.meas tran vdout1_36ck600 FIND v(dout1_36) AT=305.025n

.meas tran vdout1_37ck600 FIND v(dout1_37) AT=305.025n

.meas tran vdout1_38ck600 FIND v(dout1_38) AT=305.025n

.meas tran vdout1_39ck600 FIND v(dout1_39) AT=305.025n

.meas tran vdout1_40ck600 FIND v(dout1_40) AT=305.025n

.meas tran vdout1_41ck600 FIND v(dout1_41) AT=305.025n

.meas tran vdout1_42ck600 FIND v(dout1_42) AT=305.025n

.meas tran vdout1_43ck600 FIND v(dout1_43) AT=305.025n

.meas tran vdout1_44ck600 FIND v(dout1_44) AT=305.025n

.meas tran vdout1_45ck600 FIND v(dout1_45) AT=305.025n

.meas tran vdout1_46ck600 FIND v(dout1_46) AT=305.025n

.meas tran vdout1_47ck600 FIND v(dout1_47) AT=305.025n

.meas tran vdout1_48ck600 FIND v(dout1_48) AT=305.025n

.meas tran vdout1_49ck600 FIND v(dout1_49) AT=305.025n

.meas tran vdout1_50ck600 FIND v(dout1_50) AT=305.025n

.meas tran vdout1_51ck600 FIND v(dout1_51) AT=305.025n

.meas tran vdout1_52ck600 FIND v(dout1_52) AT=305.025n

.meas tran vdout1_53ck600 FIND v(dout1_53) AT=305.025n

.meas tran vdout1_54ck600 FIND v(dout1_54) AT=305.025n

.meas tran vdout1_55ck600 FIND v(dout1_55) AT=305.025n

.meas tran vdout1_56ck600 FIND v(dout1_56) AT=305.025n

.meas tran vdout1_57ck600 FIND v(dout1_57) AT=305.025n

.meas tran vdout1_58ck600 FIND v(dout1_58) AT=305.025n

.meas tran vdout1_59ck600 FIND v(dout1_59) AT=305.025n

.meas tran vdout1_60ck600 FIND v(dout1_60) AT=305.025n

.meas tran vdout1_61ck600 FIND v(dout1_61) AT=305.025n

.meas tran vdout1_62ck600 FIND v(dout1_62) AT=305.025n

.meas tran vdout1_63ck600 FIND v(dout1_63) AT=305.025n

.meas tran vdout1_64ck600 FIND v(dout1_64) AT=305.025n

.meas tran vdout1_65ck600 FIND v(dout1_65) AT=305.025n

.meas tran vdout1_66ck600 FIND v(dout1_66) AT=305.025n

.meas tran vdout1_67ck600 FIND v(dout1_67) AT=305.025n

.meas tran vdout1_68ck600 FIND v(dout1_68) AT=305.025n

.meas tran vdout1_69ck600 FIND v(dout1_69) AT=305.025n

.meas tran vdout1_70ck600 FIND v(dout1_70) AT=305.025n

.meas tran vdout1_71ck600 FIND v(dout1_71) AT=305.025n

.meas tran vdout1_72ck600 FIND v(dout1_72) AT=305.025n

.meas tran vdout1_73ck600 FIND v(dout1_73) AT=305.025n

.meas tran vdout1_74ck600 FIND v(dout1_74) AT=305.025n

.meas tran vdout1_75ck600 FIND v(dout1_75) AT=305.025n

.meas tran vdout1_76ck600 FIND v(dout1_76) AT=305.025n

.meas tran vdout1_77ck600 FIND v(dout1_77) AT=305.025n

.meas tran vdout1_78ck600 FIND v(dout1_78) AT=305.025n

.meas tran vdout1_79ck600 FIND v(dout1_79) AT=305.025n

.meas tran vdout1_80ck600 FIND v(dout1_80) AT=305.025n

.meas tran vdout1_81ck600 FIND v(dout1_81) AT=305.025n

.meas tran vdout1_82ck600 FIND v(dout1_82) AT=305.025n

.meas tran vdout1_83ck600 FIND v(dout1_83) AT=305.025n

.meas tran vdout1_84ck600 FIND v(dout1_84) AT=305.025n

.meas tran vdout1_85ck600 FIND v(dout1_85) AT=305.025n

.meas tran vdout1_86ck600 FIND v(dout1_86) AT=305.025n

.meas tran vdout1_87ck600 FIND v(dout1_87) AT=305.025n

.meas tran vdout1_88ck600 FIND v(dout1_88) AT=305.025n

.meas tran vdout1_89ck600 FIND v(dout1_89) AT=305.025n

.meas tran vdout1_90ck600 FIND v(dout1_90) AT=305.025n

.meas tran vdout1_91ck600 FIND v(dout1_91) AT=305.025n

.meas tran vdout1_92ck600 FIND v(dout1_92) AT=305.025n

.meas tran vdout1_93ck600 FIND v(dout1_93) AT=305.025n

.meas tran vdout1_94ck600 FIND v(dout1_94) AT=305.025n

.meas tran vdout1_95ck600 FIND v(dout1_95) AT=305.025n

.meas tran vdout1_96ck600 FIND v(dout1_96) AT=305.025n

.meas tran vdout1_97ck600 FIND v(dout1_97) AT=305.025n

.meas tran vdout1_98ck600 FIND v(dout1_98) AT=305.025n

.meas tran vdout1_99ck600 FIND v(dout1_99) AT=305.025n

.meas tran vdout1_100ck600 FIND v(dout1_100) AT=305.025n

.meas tran vdout1_101ck600 FIND v(dout1_101) AT=305.025n

.meas tran vdout1_102ck600 FIND v(dout1_102) AT=305.025n

.meas tran vdout1_103ck600 FIND v(dout1_103) AT=305.025n

.meas tran vdout1_104ck600 FIND v(dout1_104) AT=305.025n

.meas tran vdout1_105ck600 FIND v(dout1_105) AT=305.025n

.meas tran vdout1_106ck600 FIND v(dout1_106) AT=305.025n

.meas tran vdout1_107ck600 FIND v(dout1_107) AT=305.025n

.meas tran vdout1_108ck600 FIND v(dout1_108) AT=305.025n

.meas tran vdout1_109ck600 FIND v(dout1_109) AT=305.025n

.meas tran vdout1_110ck600 FIND v(dout1_110) AT=305.025n

.meas tran vdout1_111ck600 FIND v(dout1_111) AT=305.025n

.meas tran vdout1_112ck600 FIND v(dout1_112) AT=305.025n

.meas tran vdout1_113ck600 FIND v(dout1_113) AT=305.025n

.meas tran vdout1_114ck600 FIND v(dout1_114) AT=305.025n

.meas tran vdout1_115ck600 FIND v(dout1_115) AT=305.025n

.meas tran vdout1_116ck600 FIND v(dout1_116) AT=305.025n

.meas tran vdout1_117ck600 FIND v(dout1_117) AT=305.025n

.meas tran vdout1_118ck600 FIND v(dout1_118) AT=305.025n

.meas tran vdout1_119ck600 FIND v(dout1_119) AT=305.025n

.meas tran vdout1_120ck600 FIND v(dout1_120) AT=305.025n

.meas tran vdout1_121ck600 FIND v(dout1_121) AT=305.025n

.meas tran vdout1_122ck600 FIND v(dout1_122) AT=305.025n

.meas tran vdout1_123ck600 FIND v(dout1_123) AT=305.025n

.meas tran vdout1_124ck600 FIND v(dout1_124) AT=305.025n

.meas tran vdout1_125ck600 FIND v(dout1_125) AT=305.025n

.meas tran vdout1_126ck600 FIND v(dout1_126) AT=305.025n

.meas tran vdout1_127ck600 FIND v(dout1_127) AT=305.025n

.meas tran vdout1_128ck600 FIND v(dout1_128) AT=305.025n

.meas tran vdout1_129ck600 FIND v(dout1_129) AT=305.025n

.meas tran vdout1_130ck600 FIND v(dout1_130) AT=305.025n

.meas tran vdout1_131ck600 FIND v(dout1_131) AT=305.025n

.meas tran vdout1_132ck600 FIND v(dout1_132) AT=305.025n

.meas tran vdout1_133ck600 FIND v(dout1_133) AT=305.025n

.meas tran vdout1_134ck600 FIND v(dout1_134) AT=305.025n

.meas tran vdout1_135ck600 FIND v(dout1_135) AT=305.025n

.meas tran vdout1_136ck600 FIND v(dout1_136) AT=305.025n

.meas tran vdout1_137ck600 FIND v(dout1_137) AT=305.025n

.meas tran vdout1_138ck600 FIND v(dout1_138) AT=305.025n

.meas tran vdout1_139ck600 FIND v(dout1_139) AT=305.025n

.meas tran vdout1_140ck600 FIND v(dout1_140) AT=305.025n

.meas tran vdout1_141ck600 FIND v(dout1_141) AT=305.025n

.meas tran vdout1_142ck600 FIND v(dout1_142) AT=305.025n

.meas tran vdout1_143ck600 FIND v(dout1_143) AT=305.025n

.meas tran vdout1_144ck600 FIND v(dout1_144) AT=305.025n

.meas tran vdout1_145ck600 FIND v(dout1_145) AT=305.025n

.meas tran vdout1_146ck600 FIND v(dout1_146) AT=305.025n

.meas tran vdout1_147ck600 FIND v(dout1_147) AT=305.025n

.meas tran vdout1_148ck600 FIND v(dout1_148) AT=305.025n

.meas tran vdout1_149ck600 FIND v(dout1_149) AT=305.025n

.meas tran vdout1_150ck600 FIND v(dout1_150) AT=305.025n

.meas tran vdout1_151ck600 FIND v(dout1_151) AT=305.025n

.meas tran vdout1_152ck600 FIND v(dout1_152) AT=305.025n

.meas tran vdout1_153ck600 FIND v(dout1_153) AT=305.025n

.meas tran vdout1_154ck600 FIND v(dout1_154) AT=305.025n

.meas tran vdout1_155ck600 FIND v(dout1_155) AT=305.025n

.meas tran vdout1_156ck600 FIND v(dout1_156) AT=305.025n

.meas tran vdout1_157ck600 FIND v(dout1_157) AT=305.025n

.meas tran vdout1_158ck600 FIND v(dout1_158) AT=305.025n

.meas tran vdout1_159ck600 FIND v(dout1_159) AT=305.025n

.meas tran vdout1_160ck600 FIND v(dout1_160) AT=305.025n

.meas tran vdout1_161ck600 FIND v(dout1_161) AT=305.025n

.meas tran vdout1_162ck600 FIND v(dout1_162) AT=305.025n

.meas tran vdout1_163ck600 FIND v(dout1_163) AT=305.025n

.meas tran vdout1_164ck600 FIND v(dout1_164) AT=305.025n

.meas tran vdout1_165ck600 FIND v(dout1_165) AT=305.025n

.meas tran vdout1_166ck600 FIND v(dout1_166) AT=305.025n

.meas tran vdout1_167ck600 FIND v(dout1_167) AT=305.025n

.meas tran vdout1_168ck600 FIND v(dout1_168) AT=305.025n

.meas tran vdout1_169ck600 FIND v(dout1_169) AT=305.025n

.meas tran vdout1_170ck600 FIND v(dout1_170) AT=305.025n

.meas tran vdout1_171ck600 FIND v(dout1_171) AT=305.025n

.meas tran vdout1_172ck600 FIND v(dout1_172) AT=305.025n

.meas tran vdout1_173ck600 FIND v(dout1_173) AT=305.025n

.meas tran vdout1_174ck600 FIND v(dout1_174) AT=305.025n

.meas tran vdout1_175ck600 FIND v(dout1_175) AT=305.025n

.meas tran vdout1_176ck600 FIND v(dout1_176) AT=305.025n

.meas tran vdout1_177ck600 FIND v(dout1_177) AT=305.025n

.meas tran vdout1_178ck600 FIND v(dout1_178) AT=305.025n

.meas tran vdout1_179ck600 FIND v(dout1_179) AT=305.025n

.meas tran vdout1_180ck600 FIND v(dout1_180) AT=305.025n

.meas tran vdout1_181ck600 FIND v(dout1_181) AT=305.025n

.meas tran vdout1_182ck600 FIND v(dout1_182) AT=305.025n

.meas tran vdout1_183ck600 FIND v(dout1_183) AT=305.025n

.meas tran vdout1_184ck600 FIND v(dout1_184) AT=305.025n

.meas tran vdout1_185ck600 FIND v(dout1_185) AT=305.025n

.meas tran vdout1_186ck600 FIND v(dout1_186) AT=305.025n

.meas tran vdout1_187ck600 FIND v(dout1_187) AT=305.025n

.meas tran vdout1_188ck600 FIND v(dout1_188) AT=305.025n

.meas tran vdout1_189ck600 FIND v(dout1_189) AT=305.025n

.meas tran vdout1_190ck600 FIND v(dout1_190) AT=305.025n

.meas tran vdout1_191ck600 FIND v(dout1_191) AT=305.025n

.meas tran vdout1_192ck600 FIND v(dout1_192) AT=305.025n

.meas tran vdout1_193ck600 FIND v(dout1_193) AT=305.025n

.meas tran vdout1_194ck600 FIND v(dout1_194) AT=305.025n

.meas tran vdout1_195ck600 FIND v(dout1_195) AT=305.025n

.meas tran vdout1_196ck600 FIND v(dout1_196) AT=305.025n

.meas tran vdout1_197ck600 FIND v(dout1_197) AT=305.025n

.meas tran vdout1_198ck600 FIND v(dout1_198) AT=305.025n

.meas tran vdout1_199ck600 FIND v(dout1_199) AT=305.025n

.meas tran vdout1_200ck600 FIND v(dout1_200) AT=305.025n

.meas tran vdout1_201ck600 FIND v(dout1_201) AT=305.025n

.meas tran vdout1_202ck600 FIND v(dout1_202) AT=305.025n

.meas tran vdout1_203ck600 FIND v(dout1_203) AT=305.025n

.meas tran vdout1_204ck600 FIND v(dout1_204) AT=305.025n

.meas tran vdout1_205ck600 FIND v(dout1_205) AT=305.025n

.meas tran vdout1_206ck600 FIND v(dout1_206) AT=305.025n

.meas tran vdout1_207ck600 FIND v(dout1_207) AT=305.025n

.meas tran vdout1_208ck600 FIND v(dout1_208) AT=305.025n

.meas tran vdout1_209ck600 FIND v(dout1_209) AT=305.025n

.meas tran vdout1_210ck600 FIND v(dout1_210) AT=305.025n

.meas tran vdout1_211ck600 FIND v(dout1_211) AT=305.025n

.meas tran vdout1_212ck600 FIND v(dout1_212) AT=305.025n

.meas tran vdout1_213ck600 FIND v(dout1_213) AT=305.025n

.meas tran vdout1_214ck600 FIND v(dout1_214) AT=305.025n

.meas tran vdout1_215ck600 FIND v(dout1_215) AT=305.025n

.meas tran vdout1_216ck600 FIND v(dout1_216) AT=305.025n

.meas tran vdout1_217ck600 FIND v(dout1_217) AT=305.025n

.meas tran vdout1_218ck600 FIND v(dout1_218) AT=305.025n

.meas tran vdout1_219ck600 FIND v(dout1_219) AT=305.025n

.meas tran vdout1_220ck600 FIND v(dout1_220) AT=305.025n

.meas tran vdout1_221ck600 FIND v(dout1_221) AT=305.025n

.meas tran vdout1_222ck600 FIND v(dout1_222) AT=305.025n

.meas tran vdout1_223ck600 FIND v(dout1_223) AT=305.025n

.meas tran vdout1_224ck600 FIND v(dout1_224) AT=305.025n

.meas tran vdout1_225ck600 FIND v(dout1_225) AT=305.025n

.meas tran vdout1_226ck600 FIND v(dout1_226) AT=305.025n

.meas tran vdout1_227ck600 FIND v(dout1_227) AT=305.025n

.meas tran vdout1_228ck600 FIND v(dout1_228) AT=305.025n

.meas tran vdout1_229ck600 FIND v(dout1_229) AT=305.025n

.meas tran vdout1_230ck600 FIND v(dout1_230) AT=305.025n

.meas tran vdout1_231ck600 FIND v(dout1_231) AT=305.025n

.meas tran vdout1_232ck600 FIND v(dout1_232) AT=305.025n

.meas tran vdout1_233ck600 FIND v(dout1_233) AT=305.025n

.meas tran vdout1_234ck600 FIND v(dout1_234) AT=305.025n

.meas tran vdout1_235ck600 FIND v(dout1_235) AT=305.025n

.meas tran vdout1_236ck600 FIND v(dout1_236) AT=305.025n

.meas tran vdout1_237ck600 FIND v(dout1_237) AT=305.025n

.meas tran vdout1_238ck600 FIND v(dout1_238) AT=305.025n

.meas tran vdout1_239ck600 FIND v(dout1_239) AT=305.025n

.meas tran vdout1_240ck600 FIND v(dout1_240) AT=305.025n

.meas tran vdout1_241ck600 FIND v(dout1_241) AT=305.025n

.meas tran vdout1_242ck600 FIND v(dout1_242) AT=305.025n

.meas tran vdout1_243ck600 FIND v(dout1_243) AT=305.025n

.meas tran vdout1_244ck600 FIND v(dout1_244) AT=305.025n

.meas tran vdout1_245ck600 FIND v(dout1_245) AT=305.025n

.meas tran vdout1_246ck600 FIND v(dout1_246) AT=305.025n

.meas tran vdout1_247ck600 FIND v(dout1_247) AT=305.025n

.meas tran vdout1_248ck600 FIND v(dout1_248) AT=305.025n

.meas tran vdout1_249ck600 FIND v(dout1_249) AT=305.025n

.meas tran vdout1_250ck600 FIND v(dout1_250) AT=305.025n

.meas tran vdout1_251ck600 FIND v(dout1_251) AT=305.025n

.meas tran vdout1_252ck600 FIND v(dout1_252) AT=305.025n

.meas tran vdout1_253ck600 FIND v(dout1_253) AT=305.025n

.meas tran vdout1_254ck600 FIND v(dout1_254) AT=305.025n

.meas tran vdout1_255ck600 FIND v(dout1_255) AT=305.025n

.meas tran vdout1_256ck600 FIND v(dout1_256) AT=305.025n

.meas tran vdout1_257ck600 FIND v(dout1_257) AT=305.025n

.meas tran vdout1_258ck600 FIND v(dout1_258) AT=305.025n

.meas tran vdout1_259ck600 FIND v(dout1_259) AT=305.025n

.meas tran vdout1_260ck600 FIND v(dout1_260) AT=305.025n

.meas tran vdout1_261ck600 FIND v(dout1_261) AT=305.025n

.meas tran vdout1_262ck600 FIND v(dout1_262) AT=305.025n

.meas tran vdout1_263ck600 FIND v(dout1_263) AT=305.025n

.meas tran vdout1_264ck600 FIND v(dout1_264) AT=305.025n

.meas tran vdout1_265ck600 FIND v(dout1_265) AT=305.025n

.meas tran vdout1_266ck600 FIND v(dout1_266) AT=305.025n

.meas tran vdout1_267ck600 FIND v(dout1_267) AT=305.025n

.meas tran vdout1_268ck600 FIND v(dout1_268) AT=305.025n

.meas tran vdout1_269ck600 FIND v(dout1_269) AT=305.025n

.meas tran vdout1_270ck600 FIND v(dout1_270) AT=305.025n

.meas tran vdout1_271ck600 FIND v(dout1_271) AT=305.025n

.meas tran vdout1_272ck600 FIND v(dout1_272) AT=305.025n

.meas tran vdout1_273ck600 FIND v(dout1_273) AT=305.025n

.meas tran vdout1_274ck600 FIND v(dout1_274) AT=305.025n

.meas tran vdout1_275ck600 FIND v(dout1_275) AT=305.025n

.meas tran vdout1_276ck600 FIND v(dout1_276) AT=305.025n

.meas tran vdout1_277ck600 FIND v(dout1_277) AT=305.025n

.meas tran vdout1_278ck600 FIND v(dout1_278) AT=305.025n

.meas tran vdout1_279ck600 FIND v(dout1_279) AT=305.025n

.meas tran vdout1_280ck600 FIND v(dout1_280) AT=305.025n

.meas tran vdout1_281ck600 FIND v(dout1_281) AT=305.025n

.meas tran vdout1_282ck600 FIND v(dout1_282) AT=305.025n

.meas tran vdout1_283ck600 FIND v(dout1_283) AT=305.025n

.meas tran vdout1_284ck600 FIND v(dout1_284) AT=305.025n

.meas tran vdout1_285ck600 FIND v(dout1_285) AT=305.025n

.meas tran vdout1_286ck600 FIND v(dout1_286) AT=305.025n

.meas tran vdout1_287ck600 FIND v(dout1_287) AT=305.025n

.meas tran vdout1_288ck600 FIND v(dout1_288) AT=305.025n

.meas tran vdout1_289ck600 FIND v(dout1_289) AT=305.025n

.meas tran vdout1_290ck600 FIND v(dout1_290) AT=305.025n

.meas tran vdout1_291ck600 FIND v(dout1_291) AT=305.025n

.meas tran vdout1_292ck600 FIND v(dout1_292) AT=305.025n

.meas tran vdout1_293ck600 FIND v(dout1_293) AT=305.025n

.meas tran vdout1_294ck600 FIND v(dout1_294) AT=305.025n

.meas tran vdout1_295ck600 FIND v(dout1_295) AT=305.025n

.meas tran vdout1_296ck600 FIND v(dout1_296) AT=305.025n

.meas tran vdout1_297ck600 FIND v(dout1_297) AT=305.025n

.meas tran vdout1_298ck600 FIND v(dout1_298) AT=305.025n

.meas tran vdout1_299ck600 FIND v(dout1_299) AT=305.025n

.meas tran vdout1_300ck600 FIND v(dout1_300) AT=305.025n

.meas tran vdout1_301ck600 FIND v(dout1_301) AT=305.025n

.meas tran vdout1_302ck600 FIND v(dout1_302) AT=305.025n

.meas tran vdout1_303ck600 FIND v(dout1_303) AT=305.025n

.meas tran vdout1_304ck600 FIND v(dout1_304) AT=305.025n

.meas tran vdout1_305ck600 FIND v(dout1_305) AT=305.025n

.meas tran vdout1_306ck600 FIND v(dout1_306) AT=305.025n

.meas tran vdout1_307ck600 FIND v(dout1_307) AT=305.025n

.meas tran vdout1_308ck600 FIND v(dout1_308) AT=305.025n

.meas tran vdout1_309ck600 FIND v(dout1_309) AT=305.025n

.meas tran vdout1_310ck600 FIND v(dout1_310) AT=305.025n

.meas tran vdout1_311ck600 FIND v(dout1_311) AT=305.025n

.meas tran vdout1_312ck600 FIND v(dout1_312) AT=305.025n

.meas tran vdout1_313ck600 FIND v(dout1_313) AT=305.025n

.meas tran vdout1_314ck600 FIND v(dout1_314) AT=305.025n

.meas tran vdout1_315ck600 FIND v(dout1_315) AT=305.025n

.meas tran vdout1_316ck600 FIND v(dout1_316) AT=305.025n

.meas tran vdout1_317ck600 FIND v(dout1_317) AT=305.025n

.meas tran vdout1_318ck600 FIND v(dout1_318) AT=305.025n

.meas tran vdout1_319ck600 FIND v(dout1_319) AT=305.025n

.meas tran vdout1_320ck600 FIND v(dout1_320) AT=305.025n

.meas tran vdout1_321ck600 FIND v(dout1_321) AT=305.025n

.meas tran vdout1_322ck600 FIND v(dout1_322) AT=305.025n

.meas tran vdout1_323ck600 FIND v(dout1_323) AT=305.025n

.meas tran vdout1_324ck600 FIND v(dout1_324) AT=305.025n

.meas tran vdout1_325ck600 FIND v(dout1_325) AT=305.025n

.meas tran vdout1_326ck600 FIND v(dout1_326) AT=305.025n

.meas tran vdout1_327ck600 FIND v(dout1_327) AT=305.025n

.meas tran vdout1_328ck600 FIND v(dout1_328) AT=305.025n

.meas tran vdout1_329ck600 FIND v(dout1_329) AT=305.025n

.meas tran vdout1_330ck600 FIND v(dout1_330) AT=305.025n

.meas tran vdout1_331ck600 FIND v(dout1_331) AT=305.025n

.meas tran vdout1_332ck600 FIND v(dout1_332) AT=305.025n

.meas tran vdout1_333ck600 FIND v(dout1_333) AT=305.025n

.meas tran vdout1_334ck600 FIND v(dout1_334) AT=305.025n

.meas tran vdout1_335ck600 FIND v(dout1_335) AT=305.025n

.meas tran vdout1_336ck600 FIND v(dout1_336) AT=305.025n

.meas tran vdout1_337ck600 FIND v(dout1_337) AT=305.025n

.meas tran vdout1_338ck600 FIND v(dout1_338) AT=305.025n

.meas tran vdout1_339ck600 FIND v(dout1_339) AT=305.025n

.meas tran vdout1_340ck600 FIND v(dout1_340) AT=305.025n

.meas tran vdout1_341ck600 FIND v(dout1_341) AT=305.025n

.meas tran vdout1_342ck600 FIND v(dout1_342) AT=305.025n

.meas tran vdout1_343ck600 FIND v(dout1_343) AT=305.025n

.meas tran vdout1_344ck600 FIND v(dout1_344) AT=305.025n

.meas tran vdout1_345ck600 FIND v(dout1_345) AT=305.025n

.meas tran vdout1_346ck600 FIND v(dout1_346) AT=305.025n

.meas tran vdout1_347ck600 FIND v(dout1_347) AT=305.025n

.meas tran vdout1_348ck600 FIND v(dout1_348) AT=305.025n

.meas tran vdout1_349ck600 FIND v(dout1_349) AT=305.025n

.meas tran vdout1_350ck600 FIND v(dout1_350) AT=305.025n

.meas tran vdout1_351ck600 FIND v(dout1_351) AT=305.025n

.meas tran vdout1_352ck600 FIND v(dout1_352) AT=305.025n

.meas tran vdout1_353ck600 FIND v(dout1_353) AT=305.025n

.meas tran vdout1_354ck600 FIND v(dout1_354) AT=305.025n

.meas tran vdout1_355ck600 FIND v(dout1_355) AT=305.025n

.meas tran vdout1_356ck600 FIND v(dout1_356) AT=305.025n

.meas tran vdout1_357ck600 FIND v(dout1_357) AT=305.025n

.meas tran vdout1_358ck600 FIND v(dout1_358) AT=305.025n

.meas tran vdout1_359ck600 FIND v(dout1_359) AT=305.025n

.meas tran vdout1_360ck600 FIND v(dout1_360) AT=305.025n

.meas tran vdout1_361ck600 FIND v(dout1_361) AT=305.025n

.meas tran vdout1_362ck600 FIND v(dout1_362) AT=305.025n

.meas tran vdout1_363ck600 FIND v(dout1_363) AT=305.025n

.meas tran vdout1_364ck600 FIND v(dout1_364) AT=305.025n

.meas tran vdout1_365ck600 FIND v(dout1_365) AT=305.025n

.meas tran vdout1_366ck600 FIND v(dout1_366) AT=305.025n

.meas tran vdout1_367ck600 FIND v(dout1_367) AT=305.025n

.meas tran vdout1_368ck600 FIND v(dout1_368) AT=305.025n

.meas tran vdout1_369ck600 FIND v(dout1_369) AT=305.025n

.meas tran vdout1_370ck600 FIND v(dout1_370) AT=305.025n

.meas tran vdout1_371ck600 FIND v(dout1_371) AT=305.025n

.meas tran vdout1_372ck600 FIND v(dout1_372) AT=305.025n

.meas tran vdout1_373ck600 FIND v(dout1_373) AT=305.025n

.meas tran vdout1_374ck600 FIND v(dout1_374) AT=305.025n

.meas tran vdout1_375ck600 FIND v(dout1_375) AT=305.025n

.meas tran vdout1_376ck600 FIND v(dout1_376) AT=305.025n

.meas tran vdout1_377ck600 FIND v(dout1_377) AT=305.025n

.meas tran vdout1_378ck600 FIND v(dout1_378) AT=305.025n

.meas tran vdout1_379ck600 FIND v(dout1_379) AT=305.025n

.meas tran vdout1_380ck600 FIND v(dout1_380) AT=305.025n

.meas tran vdout1_381ck600 FIND v(dout1_381) AT=305.025n

.meas tran vdout1_382ck600 FIND v(dout1_382) AT=305.025n

.meas tran vdout1_383ck600 FIND v(dout1_383) AT=305.025n

.meas tran vdout1_384ck600 FIND v(dout1_384) AT=305.025n

.meas tran vdout1_385ck600 FIND v(dout1_385) AT=305.025n

.meas tran vdout1_386ck600 FIND v(dout1_386) AT=305.025n

.meas tran vdout1_387ck600 FIND v(dout1_387) AT=305.025n

.meas tran vdout1_388ck600 FIND v(dout1_388) AT=305.025n

.meas tran vdout1_389ck600 FIND v(dout1_389) AT=305.025n

.meas tran vdout1_390ck600 FIND v(dout1_390) AT=305.025n

.meas tran vdout1_391ck600 FIND v(dout1_391) AT=305.025n

.meas tran vdout1_392ck600 FIND v(dout1_392) AT=305.025n

.meas tran vdout1_393ck600 FIND v(dout1_393) AT=305.025n

.meas tran vdout1_394ck600 FIND v(dout1_394) AT=305.025n

.meas tran vdout1_395ck600 FIND v(dout1_395) AT=305.025n

.meas tran vdout1_396ck600 FIND v(dout1_396) AT=305.025n

.meas tran vdout1_397ck600 FIND v(dout1_397) AT=305.025n

.meas tran vdout1_398ck600 FIND v(dout1_398) AT=305.025n

.meas tran vdout1_399ck600 FIND v(dout1_399) AT=305.025n

.meas tran vdout1_400ck600 FIND v(dout1_400) AT=305.025n

.meas tran vdout1_401ck600 FIND v(dout1_401) AT=305.025n

.meas tran vdout1_402ck600 FIND v(dout1_402) AT=305.025n

.meas tran vdout1_403ck600 FIND v(dout1_403) AT=305.025n

.meas tran vdout1_404ck600 FIND v(dout1_404) AT=305.025n

.meas tran vdout1_405ck600 FIND v(dout1_405) AT=305.025n

.meas tran vdout1_406ck600 FIND v(dout1_406) AT=305.025n

.meas tran vdout1_407ck600 FIND v(dout1_407) AT=305.025n

.meas tran vdout1_408ck600 FIND v(dout1_408) AT=305.025n

.meas tran vdout1_409ck600 FIND v(dout1_409) AT=305.025n

.meas tran vdout1_410ck600 FIND v(dout1_410) AT=305.025n

.meas tran vdout1_411ck600 FIND v(dout1_411) AT=305.025n

.meas tran vdout1_412ck600 FIND v(dout1_412) AT=305.025n

.meas tran vdout1_413ck600 FIND v(dout1_413) AT=305.025n

.meas tran vdout1_414ck600 FIND v(dout1_414) AT=305.025n

.meas tran vdout1_415ck600 FIND v(dout1_415) AT=305.025n

.meas tran vdout1_416ck600 FIND v(dout1_416) AT=305.025n

.meas tran vdout1_417ck600 FIND v(dout1_417) AT=305.025n

.meas tran vdout1_418ck600 FIND v(dout1_418) AT=305.025n

.meas tran vdout1_419ck600 FIND v(dout1_419) AT=305.025n

.meas tran vdout1_420ck600 FIND v(dout1_420) AT=305.025n

.meas tran vdout1_421ck600 FIND v(dout1_421) AT=305.025n

.meas tran vdout1_422ck600 FIND v(dout1_422) AT=305.025n

.meas tran vdout1_423ck600 FIND v(dout1_423) AT=305.025n

.meas tran vdout1_424ck600 FIND v(dout1_424) AT=305.025n

.meas tran vdout1_425ck600 FIND v(dout1_425) AT=305.025n

.meas tran vdout1_426ck600 FIND v(dout1_426) AT=305.025n

.meas tran vdout1_427ck600 FIND v(dout1_427) AT=305.025n

.meas tran vdout1_428ck600 FIND v(dout1_428) AT=305.025n

.meas tran vdout1_429ck600 FIND v(dout1_429) AT=305.025n

.meas tran vdout1_430ck600 FIND v(dout1_430) AT=305.025n

.meas tran vdout1_431ck600 FIND v(dout1_431) AT=305.025n

.meas tran vdout1_432ck600 FIND v(dout1_432) AT=305.025n

.meas tran vdout1_433ck600 FIND v(dout1_433) AT=305.025n

.meas tran vdout1_434ck600 FIND v(dout1_434) AT=305.025n

.meas tran vdout1_435ck600 FIND v(dout1_435) AT=305.025n

.meas tran vdout1_436ck600 FIND v(dout1_436) AT=305.025n

.meas tran vdout1_437ck600 FIND v(dout1_437) AT=305.025n

.meas tran vdout1_438ck600 FIND v(dout1_438) AT=305.025n

.meas tran vdout1_439ck600 FIND v(dout1_439) AT=305.025n

.meas tran vdout1_440ck600 FIND v(dout1_440) AT=305.025n

.meas tran vdout1_441ck600 FIND v(dout1_441) AT=305.025n

.meas tran vdout1_442ck600 FIND v(dout1_442) AT=305.025n

.meas tran vdout1_443ck600 FIND v(dout1_443) AT=305.025n

.meas tran vdout1_444ck600 FIND v(dout1_444) AT=305.025n

.meas tran vdout1_445ck600 FIND v(dout1_445) AT=305.025n

.meas tran vdout1_446ck600 FIND v(dout1_446) AT=305.025n

.meas tran vdout1_447ck600 FIND v(dout1_447) AT=305.025n

.meas tran vdout1_448ck600 FIND v(dout1_448) AT=305.025n

.meas tran vdout1_449ck600 FIND v(dout1_449) AT=305.025n

.meas tran vdout1_450ck600 FIND v(dout1_450) AT=305.025n

.meas tran vdout1_451ck600 FIND v(dout1_451) AT=305.025n

.meas tran vdout1_452ck600 FIND v(dout1_452) AT=305.025n

.meas tran vdout1_453ck600 FIND v(dout1_453) AT=305.025n

.meas tran vdout1_454ck600 FIND v(dout1_454) AT=305.025n

.meas tran vdout1_455ck600 FIND v(dout1_455) AT=305.025n

.meas tran vdout1_456ck600 FIND v(dout1_456) AT=305.025n

.meas tran vdout1_457ck600 FIND v(dout1_457) AT=305.025n

.meas tran vdout1_458ck600 FIND v(dout1_458) AT=305.025n

.meas tran vdout1_459ck600 FIND v(dout1_459) AT=305.025n

.meas tran vdout1_460ck600 FIND v(dout1_460) AT=305.025n

.meas tran vdout1_461ck600 FIND v(dout1_461) AT=305.025n

.meas tran vdout1_462ck600 FIND v(dout1_462) AT=305.025n

.meas tran vdout1_463ck600 FIND v(dout1_463) AT=305.025n

.meas tran vdout1_464ck600 FIND v(dout1_464) AT=305.025n

.meas tran vdout1_465ck600 FIND v(dout1_465) AT=305.025n

.meas tran vdout1_466ck600 FIND v(dout1_466) AT=305.025n

.meas tran vdout1_467ck600 FIND v(dout1_467) AT=305.025n

.meas tran vdout1_468ck600 FIND v(dout1_468) AT=305.025n

.meas tran vdout1_469ck600 FIND v(dout1_469) AT=305.025n

.meas tran vdout1_470ck600 FIND v(dout1_470) AT=305.025n

.meas tran vdout1_471ck600 FIND v(dout1_471) AT=305.025n

.meas tran vdout1_472ck600 FIND v(dout1_472) AT=305.025n

.meas tran vdout1_473ck600 FIND v(dout1_473) AT=305.025n

.meas tran vdout1_474ck600 FIND v(dout1_474) AT=305.025n

.meas tran vdout1_475ck600 FIND v(dout1_475) AT=305.025n

.meas tran vdout1_476ck600 FIND v(dout1_476) AT=305.025n

.meas tran vdout1_477ck600 FIND v(dout1_477) AT=305.025n

.meas tran vdout1_478ck600 FIND v(dout1_478) AT=305.025n

.meas tran vdout1_479ck600 FIND v(dout1_479) AT=305.025n

.meas tran vdout1_480ck600 FIND v(dout1_480) AT=305.025n

.meas tran vdout1_481ck600 FIND v(dout1_481) AT=305.025n

.meas tran vdout1_482ck600 FIND v(dout1_482) AT=305.025n

.meas tran vdout1_483ck600 FIND v(dout1_483) AT=305.025n

.meas tran vdout1_484ck600 FIND v(dout1_484) AT=305.025n

.meas tran vdout1_485ck600 FIND v(dout1_485) AT=305.025n

.meas tran vdout1_486ck600 FIND v(dout1_486) AT=305.025n

.meas tran vdout1_487ck600 FIND v(dout1_487) AT=305.025n

.meas tran vdout1_488ck600 FIND v(dout1_488) AT=305.025n

.meas tran vdout1_489ck600 FIND v(dout1_489) AT=305.025n

.meas tran vdout1_490ck600 FIND v(dout1_490) AT=305.025n

.meas tran vdout1_491ck600 FIND v(dout1_491) AT=305.025n

.meas tran vdout1_492ck600 FIND v(dout1_492) AT=305.025n

.meas tran vdout1_493ck600 FIND v(dout1_493) AT=305.025n

.meas tran vdout1_494ck600 FIND v(dout1_494) AT=305.025n

.meas tran vdout1_495ck600 FIND v(dout1_495) AT=305.025n

.meas tran vdout1_496ck600 FIND v(dout1_496) AT=305.025n

.meas tran vdout1_497ck600 FIND v(dout1_497) AT=305.025n

.meas tran vdout1_498ck600 FIND v(dout1_498) AT=305.025n

.meas tran vdout1_499ck600 FIND v(dout1_499) AT=305.025n

.meas tran vdout1_500ck600 FIND v(dout1_500) AT=305.025n

.meas tran vdout1_501ck600 FIND v(dout1_501) AT=305.025n

.meas tran vdout1_502ck600 FIND v(dout1_502) AT=305.025n

.meas tran vdout1_503ck600 FIND v(dout1_503) AT=305.025n

.meas tran vdout1_504ck600 FIND v(dout1_504) AT=305.025n

.meas tran vdout1_505ck600 FIND v(dout1_505) AT=305.025n

.meas tran vdout1_506ck600 FIND v(dout1_506) AT=305.025n

.meas tran vdout1_507ck600 FIND v(dout1_507) AT=305.025n

.meas tran vdout1_508ck600 FIND v(dout1_508) AT=305.025n

.meas tran vdout1_509ck600 FIND v(dout1_509) AT=305.025n

.meas tran vdout1_510ck600 FIND v(dout1_510) AT=305.025n

.meas tran vdout1_511ck600 FIND v(dout1_511) AT=305.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_22ck610 FIND v(dout1_22) AT=310.025n

.meas tran vdout1_23ck610 FIND v(dout1_23) AT=310.025n

.meas tran vdout1_24ck610 FIND v(dout1_24) AT=310.025n

.meas tran vdout1_25ck610 FIND v(dout1_25) AT=310.025n

.meas tran vdout1_26ck610 FIND v(dout1_26) AT=310.025n

.meas tran vdout1_27ck610 FIND v(dout1_27) AT=310.025n

.meas tran vdout1_28ck610 FIND v(dout1_28) AT=310.025n

.meas tran vdout1_29ck610 FIND v(dout1_29) AT=310.025n

.meas tran vdout1_30ck610 FIND v(dout1_30) AT=310.025n

.meas tran vdout1_31ck610 FIND v(dout1_31) AT=310.025n

.meas tran vdout1_32ck610 FIND v(dout1_32) AT=310.025n

.meas tran vdout1_33ck610 FIND v(dout1_33) AT=310.025n

.meas tran vdout1_34ck610 FIND v(dout1_34) AT=310.025n

.meas tran vdout1_35ck610 FIND v(dout1_35) AT=310.025n

.meas tran vdout1_36ck610 FIND v(dout1_36) AT=310.025n

.meas tran vdout1_37ck610 FIND v(dout1_37) AT=310.025n

.meas tran vdout1_38ck610 FIND v(dout1_38) AT=310.025n

.meas tran vdout1_39ck610 FIND v(dout1_39) AT=310.025n

.meas tran vdout1_40ck610 FIND v(dout1_40) AT=310.025n

.meas tran vdout1_41ck610 FIND v(dout1_41) AT=310.025n

.meas tran vdout1_42ck610 FIND v(dout1_42) AT=310.025n

.meas tran vdout1_43ck610 FIND v(dout1_43) AT=310.025n

.meas tran vdout1_44ck610 FIND v(dout1_44) AT=310.025n

.meas tran vdout1_45ck610 FIND v(dout1_45) AT=310.025n

.meas tran vdout1_46ck610 FIND v(dout1_46) AT=310.025n

.meas tran vdout1_47ck610 FIND v(dout1_47) AT=310.025n

.meas tran vdout1_48ck610 FIND v(dout1_48) AT=310.025n

.meas tran vdout1_49ck610 FIND v(dout1_49) AT=310.025n

.meas tran vdout1_50ck610 FIND v(dout1_50) AT=310.025n

.meas tran vdout1_51ck610 FIND v(dout1_51) AT=310.025n

.meas tran vdout1_52ck610 FIND v(dout1_52) AT=310.025n

.meas tran vdout1_53ck610 FIND v(dout1_53) AT=310.025n

.meas tran vdout1_54ck610 FIND v(dout1_54) AT=310.025n

.meas tran vdout1_55ck610 FIND v(dout1_55) AT=310.025n

.meas tran vdout1_56ck610 FIND v(dout1_56) AT=310.025n

.meas tran vdout1_57ck610 FIND v(dout1_57) AT=310.025n

.meas tran vdout1_58ck610 FIND v(dout1_58) AT=310.025n

.meas tran vdout1_59ck610 FIND v(dout1_59) AT=310.025n

.meas tran vdout1_60ck610 FIND v(dout1_60) AT=310.025n

.meas tran vdout1_61ck610 FIND v(dout1_61) AT=310.025n

.meas tran vdout1_62ck610 FIND v(dout1_62) AT=310.025n

.meas tran vdout1_63ck610 FIND v(dout1_63) AT=310.025n

.meas tran vdout1_64ck610 FIND v(dout1_64) AT=310.025n

.meas tran vdout1_65ck610 FIND v(dout1_65) AT=310.025n

.meas tran vdout1_66ck610 FIND v(dout1_66) AT=310.025n

.meas tran vdout1_67ck610 FIND v(dout1_67) AT=310.025n

.meas tran vdout1_68ck610 FIND v(dout1_68) AT=310.025n

.meas tran vdout1_69ck610 FIND v(dout1_69) AT=310.025n

.meas tran vdout1_70ck610 FIND v(dout1_70) AT=310.025n

.meas tran vdout1_71ck610 FIND v(dout1_71) AT=310.025n

.meas tran vdout1_72ck610 FIND v(dout1_72) AT=310.025n

.meas tran vdout1_73ck610 FIND v(dout1_73) AT=310.025n

.meas tran vdout1_74ck610 FIND v(dout1_74) AT=310.025n

.meas tran vdout1_75ck610 FIND v(dout1_75) AT=310.025n

.meas tran vdout1_76ck610 FIND v(dout1_76) AT=310.025n

.meas tran vdout1_77ck610 FIND v(dout1_77) AT=310.025n

.meas tran vdout1_78ck610 FIND v(dout1_78) AT=310.025n

.meas tran vdout1_79ck610 FIND v(dout1_79) AT=310.025n

.meas tran vdout1_80ck610 FIND v(dout1_80) AT=310.025n

.meas tran vdout1_81ck610 FIND v(dout1_81) AT=310.025n

.meas tran vdout1_82ck610 FIND v(dout1_82) AT=310.025n

.meas tran vdout1_83ck610 FIND v(dout1_83) AT=310.025n

.meas tran vdout1_84ck610 FIND v(dout1_84) AT=310.025n

.meas tran vdout1_85ck610 FIND v(dout1_85) AT=310.025n

.meas tran vdout1_86ck610 FIND v(dout1_86) AT=310.025n

.meas tran vdout1_87ck610 FIND v(dout1_87) AT=310.025n

.meas tran vdout1_88ck610 FIND v(dout1_88) AT=310.025n

.meas tran vdout1_89ck610 FIND v(dout1_89) AT=310.025n

.meas tran vdout1_90ck610 FIND v(dout1_90) AT=310.025n

.meas tran vdout1_91ck610 FIND v(dout1_91) AT=310.025n

.meas tran vdout1_92ck610 FIND v(dout1_92) AT=310.025n

.meas tran vdout1_93ck610 FIND v(dout1_93) AT=310.025n

.meas tran vdout1_94ck610 FIND v(dout1_94) AT=310.025n

.meas tran vdout1_95ck610 FIND v(dout1_95) AT=310.025n

.meas tran vdout1_96ck610 FIND v(dout1_96) AT=310.025n

.meas tran vdout1_97ck610 FIND v(dout1_97) AT=310.025n

.meas tran vdout1_98ck610 FIND v(dout1_98) AT=310.025n

.meas tran vdout1_99ck610 FIND v(dout1_99) AT=310.025n

.meas tran vdout1_100ck610 FIND v(dout1_100) AT=310.025n

.meas tran vdout1_101ck610 FIND v(dout1_101) AT=310.025n

.meas tran vdout1_102ck610 FIND v(dout1_102) AT=310.025n

.meas tran vdout1_103ck610 FIND v(dout1_103) AT=310.025n

.meas tran vdout1_104ck610 FIND v(dout1_104) AT=310.025n

.meas tran vdout1_105ck610 FIND v(dout1_105) AT=310.025n

.meas tran vdout1_106ck610 FIND v(dout1_106) AT=310.025n

.meas tran vdout1_107ck610 FIND v(dout1_107) AT=310.025n

.meas tran vdout1_108ck610 FIND v(dout1_108) AT=310.025n

.meas tran vdout1_109ck610 FIND v(dout1_109) AT=310.025n

.meas tran vdout1_110ck610 FIND v(dout1_110) AT=310.025n

.meas tran vdout1_111ck610 FIND v(dout1_111) AT=310.025n

.meas tran vdout1_112ck610 FIND v(dout1_112) AT=310.025n

.meas tran vdout1_113ck610 FIND v(dout1_113) AT=310.025n

.meas tran vdout1_114ck610 FIND v(dout1_114) AT=310.025n

.meas tran vdout1_115ck610 FIND v(dout1_115) AT=310.025n

.meas tran vdout1_116ck610 FIND v(dout1_116) AT=310.025n

.meas tran vdout1_117ck610 FIND v(dout1_117) AT=310.025n

.meas tran vdout1_118ck610 FIND v(dout1_118) AT=310.025n

.meas tran vdout1_119ck610 FIND v(dout1_119) AT=310.025n

.meas tran vdout1_120ck610 FIND v(dout1_120) AT=310.025n

.meas tran vdout1_121ck610 FIND v(dout1_121) AT=310.025n

.meas tran vdout1_122ck610 FIND v(dout1_122) AT=310.025n

.meas tran vdout1_123ck610 FIND v(dout1_123) AT=310.025n

.meas tran vdout1_124ck610 FIND v(dout1_124) AT=310.025n

.meas tran vdout1_125ck610 FIND v(dout1_125) AT=310.025n

.meas tran vdout1_126ck610 FIND v(dout1_126) AT=310.025n

.meas tran vdout1_127ck610 FIND v(dout1_127) AT=310.025n

.meas tran vdout1_128ck610 FIND v(dout1_128) AT=310.025n

.meas tran vdout1_129ck610 FIND v(dout1_129) AT=310.025n

.meas tran vdout1_130ck610 FIND v(dout1_130) AT=310.025n

.meas tran vdout1_131ck610 FIND v(dout1_131) AT=310.025n

.meas tran vdout1_132ck610 FIND v(dout1_132) AT=310.025n

.meas tran vdout1_133ck610 FIND v(dout1_133) AT=310.025n

.meas tran vdout1_134ck610 FIND v(dout1_134) AT=310.025n

.meas tran vdout1_135ck610 FIND v(dout1_135) AT=310.025n

.meas tran vdout1_136ck610 FIND v(dout1_136) AT=310.025n

.meas tran vdout1_137ck610 FIND v(dout1_137) AT=310.025n

.meas tran vdout1_138ck610 FIND v(dout1_138) AT=310.025n

.meas tran vdout1_139ck610 FIND v(dout1_139) AT=310.025n

.meas tran vdout1_140ck610 FIND v(dout1_140) AT=310.025n

.meas tran vdout1_141ck610 FIND v(dout1_141) AT=310.025n

.meas tran vdout1_142ck610 FIND v(dout1_142) AT=310.025n

.meas tran vdout1_143ck610 FIND v(dout1_143) AT=310.025n

.meas tran vdout1_144ck610 FIND v(dout1_144) AT=310.025n

.meas tran vdout1_145ck610 FIND v(dout1_145) AT=310.025n

.meas tran vdout1_146ck610 FIND v(dout1_146) AT=310.025n

.meas tran vdout1_147ck610 FIND v(dout1_147) AT=310.025n

.meas tran vdout1_148ck610 FIND v(dout1_148) AT=310.025n

.meas tran vdout1_149ck610 FIND v(dout1_149) AT=310.025n

.meas tran vdout1_150ck610 FIND v(dout1_150) AT=310.025n

.meas tran vdout1_151ck610 FIND v(dout1_151) AT=310.025n

.meas tran vdout1_152ck610 FIND v(dout1_152) AT=310.025n

.meas tran vdout1_153ck610 FIND v(dout1_153) AT=310.025n

.meas tran vdout1_154ck610 FIND v(dout1_154) AT=310.025n

.meas tran vdout1_155ck610 FIND v(dout1_155) AT=310.025n

.meas tran vdout1_156ck610 FIND v(dout1_156) AT=310.025n

.meas tran vdout1_157ck610 FIND v(dout1_157) AT=310.025n

.meas tran vdout1_158ck610 FIND v(dout1_158) AT=310.025n

.meas tran vdout1_159ck610 FIND v(dout1_159) AT=310.025n

.meas tran vdout1_160ck610 FIND v(dout1_160) AT=310.025n

.meas tran vdout1_161ck610 FIND v(dout1_161) AT=310.025n

.meas tran vdout1_162ck610 FIND v(dout1_162) AT=310.025n

.meas tran vdout1_163ck610 FIND v(dout1_163) AT=310.025n

.meas tran vdout1_164ck610 FIND v(dout1_164) AT=310.025n

.meas tran vdout1_165ck610 FIND v(dout1_165) AT=310.025n

.meas tran vdout1_166ck610 FIND v(dout1_166) AT=310.025n

.meas tran vdout1_167ck610 FIND v(dout1_167) AT=310.025n

.meas tran vdout1_168ck610 FIND v(dout1_168) AT=310.025n

.meas tran vdout1_169ck610 FIND v(dout1_169) AT=310.025n

.meas tran vdout1_170ck610 FIND v(dout1_170) AT=310.025n

.meas tran vdout1_171ck610 FIND v(dout1_171) AT=310.025n

.meas tran vdout1_172ck610 FIND v(dout1_172) AT=310.025n

.meas tran vdout1_173ck610 FIND v(dout1_173) AT=310.025n

.meas tran vdout1_174ck610 FIND v(dout1_174) AT=310.025n

.meas tran vdout1_175ck610 FIND v(dout1_175) AT=310.025n

.meas tran vdout1_176ck610 FIND v(dout1_176) AT=310.025n

.meas tran vdout1_177ck610 FIND v(dout1_177) AT=310.025n

.meas tran vdout1_178ck610 FIND v(dout1_178) AT=310.025n

.meas tran vdout1_179ck610 FIND v(dout1_179) AT=310.025n

.meas tran vdout1_180ck610 FIND v(dout1_180) AT=310.025n

.meas tran vdout1_181ck610 FIND v(dout1_181) AT=310.025n

.meas tran vdout1_182ck610 FIND v(dout1_182) AT=310.025n

.meas tran vdout1_183ck610 FIND v(dout1_183) AT=310.025n

.meas tran vdout1_184ck610 FIND v(dout1_184) AT=310.025n

.meas tran vdout1_185ck610 FIND v(dout1_185) AT=310.025n

.meas tran vdout1_186ck610 FIND v(dout1_186) AT=310.025n

.meas tran vdout1_187ck610 FIND v(dout1_187) AT=310.025n

.meas tran vdout1_188ck610 FIND v(dout1_188) AT=310.025n

.meas tran vdout1_189ck610 FIND v(dout1_189) AT=310.025n

.meas tran vdout1_190ck610 FIND v(dout1_190) AT=310.025n

.meas tran vdout1_191ck610 FIND v(dout1_191) AT=310.025n

.meas tran vdout1_192ck610 FIND v(dout1_192) AT=310.025n

.meas tran vdout1_193ck610 FIND v(dout1_193) AT=310.025n

.meas tran vdout1_194ck610 FIND v(dout1_194) AT=310.025n

.meas tran vdout1_195ck610 FIND v(dout1_195) AT=310.025n

.meas tran vdout1_196ck610 FIND v(dout1_196) AT=310.025n

.meas tran vdout1_197ck610 FIND v(dout1_197) AT=310.025n

.meas tran vdout1_198ck610 FIND v(dout1_198) AT=310.025n

.meas tran vdout1_199ck610 FIND v(dout1_199) AT=310.025n

.meas tran vdout1_200ck610 FIND v(dout1_200) AT=310.025n

.meas tran vdout1_201ck610 FIND v(dout1_201) AT=310.025n

.meas tran vdout1_202ck610 FIND v(dout1_202) AT=310.025n

.meas tran vdout1_203ck610 FIND v(dout1_203) AT=310.025n

.meas tran vdout1_204ck610 FIND v(dout1_204) AT=310.025n

.meas tran vdout1_205ck610 FIND v(dout1_205) AT=310.025n

.meas tran vdout1_206ck610 FIND v(dout1_206) AT=310.025n

.meas tran vdout1_207ck610 FIND v(dout1_207) AT=310.025n

.meas tran vdout1_208ck610 FIND v(dout1_208) AT=310.025n

.meas tran vdout1_209ck610 FIND v(dout1_209) AT=310.025n

.meas tran vdout1_210ck610 FIND v(dout1_210) AT=310.025n

.meas tran vdout1_211ck610 FIND v(dout1_211) AT=310.025n

.meas tran vdout1_212ck610 FIND v(dout1_212) AT=310.025n

.meas tran vdout1_213ck610 FIND v(dout1_213) AT=310.025n

.meas tran vdout1_214ck610 FIND v(dout1_214) AT=310.025n

.meas tran vdout1_215ck610 FIND v(dout1_215) AT=310.025n

.meas tran vdout1_216ck610 FIND v(dout1_216) AT=310.025n

.meas tran vdout1_217ck610 FIND v(dout1_217) AT=310.025n

.meas tran vdout1_218ck610 FIND v(dout1_218) AT=310.025n

.meas tran vdout1_219ck610 FIND v(dout1_219) AT=310.025n

.meas tran vdout1_220ck610 FIND v(dout1_220) AT=310.025n

.meas tran vdout1_221ck610 FIND v(dout1_221) AT=310.025n

.meas tran vdout1_222ck610 FIND v(dout1_222) AT=310.025n

.meas tran vdout1_223ck610 FIND v(dout1_223) AT=310.025n

.meas tran vdout1_224ck610 FIND v(dout1_224) AT=310.025n

.meas tran vdout1_225ck610 FIND v(dout1_225) AT=310.025n

.meas tran vdout1_226ck610 FIND v(dout1_226) AT=310.025n

.meas tran vdout1_227ck610 FIND v(dout1_227) AT=310.025n

.meas tran vdout1_228ck610 FIND v(dout1_228) AT=310.025n

.meas tran vdout1_229ck610 FIND v(dout1_229) AT=310.025n

.meas tran vdout1_230ck610 FIND v(dout1_230) AT=310.025n

.meas tran vdout1_231ck610 FIND v(dout1_231) AT=310.025n

.meas tran vdout1_232ck610 FIND v(dout1_232) AT=310.025n

.meas tran vdout1_233ck610 FIND v(dout1_233) AT=310.025n

.meas tran vdout1_234ck610 FIND v(dout1_234) AT=310.025n

.meas tran vdout1_235ck610 FIND v(dout1_235) AT=310.025n

.meas tran vdout1_236ck610 FIND v(dout1_236) AT=310.025n

.meas tran vdout1_237ck610 FIND v(dout1_237) AT=310.025n

.meas tran vdout1_238ck610 FIND v(dout1_238) AT=310.025n

.meas tran vdout1_239ck610 FIND v(dout1_239) AT=310.025n

.meas tran vdout1_240ck610 FIND v(dout1_240) AT=310.025n

.meas tran vdout1_241ck610 FIND v(dout1_241) AT=310.025n

.meas tran vdout1_242ck610 FIND v(dout1_242) AT=310.025n

.meas tran vdout1_243ck610 FIND v(dout1_243) AT=310.025n

.meas tran vdout1_244ck610 FIND v(dout1_244) AT=310.025n

.meas tran vdout1_245ck610 FIND v(dout1_245) AT=310.025n

.meas tran vdout1_246ck610 FIND v(dout1_246) AT=310.025n

.meas tran vdout1_247ck610 FIND v(dout1_247) AT=310.025n

.meas tran vdout1_248ck610 FIND v(dout1_248) AT=310.025n

.meas tran vdout1_249ck610 FIND v(dout1_249) AT=310.025n

.meas tran vdout1_250ck610 FIND v(dout1_250) AT=310.025n

.meas tran vdout1_251ck610 FIND v(dout1_251) AT=310.025n

.meas tran vdout1_252ck610 FIND v(dout1_252) AT=310.025n

.meas tran vdout1_253ck610 FIND v(dout1_253) AT=310.025n

.meas tran vdout1_254ck610 FIND v(dout1_254) AT=310.025n

.meas tran vdout1_255ck610 FIND v(dout1_255) AT=310.025n

.meas tran vdout1_256ck610 FIND v(dout1_256) AT=310.025n

.meas tran vdout1_257ck610 FIND v(dout1_257) AT=310.025n

.meas tran vdout1_258ck610 FIND v(dout1_258) AT=310.025n

.meas tran vdout1_259ck610 FIND v(dout1_259) AT=310.025n

.meas tran vdout1_260ck610 FIND v(dout1_260) AT=310.025n

.meas tran vdout1_261ck610 FIND v(dout1_261) AT=310.025n

.meas tran vdout1_262ck610 FIND v(dout1_262) AT=310.025n

.meas tran vdout1_263ck610 FIND v(dout1_263) AT=310.025n

.meas tran vdout1_264ck610 FIND v(dout1_264) AT=310.025n

.meas tran vdout1_265ck610 FIND v(dout1_265) AT=310.025n

.meas tran vdout1_266ck610 FIND v(dout1_266) AT=310.025n

.meas tran vdout1_267ck610 FIND v(dout1_267) AT=310.025n

.meas tran vdout1_268ck610 FIND v(dout1_268) AT=310.025n

.meas tran vdout1_269ck610 FIND v(dout1_269) AT=310.025n

.meas tran vdout1_270ck610 FIND v(dout1_270) AT=310.025n

.meas tran vdout1_271ck610 FIND v(dout1_271) AT=310.025n

.meas tran vdout1_272ck610 FIND v(dout1_272) AT=310.025n

.meas tran vdout1_273ck610 FIND v(dout1_273) AT=310.025n

.meas tran vdout1_274ck610 FIND v(dout1_274) AT=310.025n

.meas tran vdout1_275ck610 FIND v(dout1_275) AT=310.025n

.meas tran vdout1_276ck610 FIND v(dout1_276) AT=310.025n

.meas tran vdout1_277ck610 FIND v(dout1_277) AT=310.025n

.meas tran vdout1_278ck610 FIND v(dout1_278) AT=310.025n

.meas tran vdout1_279ck610 FIND v(dout1_279) AT=310.025n

.meas tran vdout1_280ck610 FIND v(dout1_280) AT=310.025n

.meas tran vdout1_281ck610 FIND v(dout1_281) AT=310.025n

.meas tran vdout1_282ck610 FIND v(dout1_282) AT=310.025n

.meas tran vdout1_283ck610 FIND v(dout1_283) AT=310.025n

.meas tran vdout1_284ck610 FIND v(dout1_284) AT=310.025n

.meas tran vdout1_285ck610 FIND v(dout1_285) AT=310.025n

.meas tran vdout1_286ck610 FIND v(dout1_286) AT=310.025n

.meas tran vdout1_287ck610 FIND v(dout1_287) AT=310.025n

.meas tran vdout1_288ck610 FIND v(dout1_288) AT=310.025n

.meas tran vdout1_289ck610 FIND v(dout1_289) AT=310.025n

.meas tran vdout1_290ck610 FIND v(dout1_290) AT=310.025n

.meas tran vdout1_291ck610 FIND v(dout1_291) AT=310.025n

.meas tran vdout1_292ck610 FIND v(dout1_292) AT=310.025n

.meas tran vdout1_293ck610 FIND v(dout1_293) AT=310.025n

.meas tran vdout1_294ck610 FIND v(dout1_294) AT=310.025n

.meas tran vdout1_295ck610 FIND v(dout1_295) AT=310.025n

.meas tran vdout1_296ck610 FIND v(dout1_296) AT=310.025n

.meas tran vdout1_297ck610 FIND v(dout1_297) AT=310.025n

.meas tran vdout1_298ck610 FIND v(dout1_298) AT=310.025n

.meas tran vdout1_299ck610 FIND v(dout1_299) AT=310.025n

.meas tran vdout1_300ck610 FIND v(dout1_300) AT=310.025n

.meas tran vdout1_301ck610 FIND v(dout1_301) AT=310.025n

.meas tran vdout1_302ck610 FIND v(dout1_302) AT=310.025n

.meas tran vdout1_303ck610 FIND v(dout1_303) AT=310.025n

.meas tran vdout1_304ck610 FIND v(dout1_304) AT=310.025n

.meas tran vdout1_305ck610 FIND v(dout1_305) AT=310.025n

.meas tran vdout1_306ck610 FIND v(dout1_306) AT=310.025n

.meas tran vdout1_307ck610 FIND v(dout1_307) AT=310.025n

.meas tran vdout1_308ck610 FIND v(dout1_308) AT=310.025n

.meas tran vdout1_309ck610 FIND v(dout1_309) AT=310.025n

.meas tran vdout1_310ck610 FIND v(dout1_310) AT=310.025n

.meas tran vdout1_311ck610 FIND v(dout1_311) AT=310.025n

.meas tran vdout1_312ck610 FIND v(dout1_312) AT=310.025n

.meas tran vdout1_313ck610 FIND v(dout1_313) AT=310.025n

.meas tran vdout1_314ck610 FIND v(dout1_314) AT=310.025n

.meas tran vdout1_315ck610 FIND v(dout1_315) AT=310.025n

.meas tran vdout1_316ck610 FIND v(dout1_316) AT=310.025n

.meas tran vdout1_317ck610 FIND v(dout1_317) AT=310.025n

.meas tran vdout1_318ck610 FIND v(dout1_318) AT=310.025n

.meas tran vdout1_319ck610 FIND v(dout1_319) AT=310.025n

.meas tran vdout1_320ck610 FIND v(dout1_320) AT=310.025n

.meas tran vdout1_321ck610 FIND v(dout1_321) AT=310.025n

.meas tran vdout1_322ck610 FIND v(dout1_322) AT=310.025n

.meas tran vdout1_323ck610 FIND v(dout1_323) AT=310.025n

.meas tran vdout1_324ck610 FIND v(dout1_324) AT=310.025n

.meas tran vdout1_325ck610 FIND v(dout1_325) AT=310.025n

.meas tran vdout1_326ck610 FIND v(dout1_326) AT=310.025n

.meas tran vdout1_327ck610 FIND v(dout1_327) AT=310.025n

.meas tran vdout1_328ck610 FIND v(dout1_328) AT=310.025n

.meas tran vdout1_329ck610 FIND v(dout1_329) AT=310.025n

.meas tran vdout1_330ck610 FIND v(dout1_330) AT=310.025n

.meas tran vdout1_331ck610 FIND v(dout1_331) AT=310.025n

.meas tran vdout1_332ck610 FIND v(dout1_332) AT=310.025n

.meas tran vdout1_333ck610 FIND v(dout1_333) AT=310.025n

.meas tran vdout1_334ck610 FIND v(dout1_334) AT=310.025n

.meas tran vdout1_335ck610 FIND v(dout1_335) AT=310.025n

.meas tran vdout1_336ck610 FIND v(dout1_336) AT=310.025n

.meas tran vdout1_337ck610 FIND v(dout1_337) AT=310.025n

.meas tran vdout1_338ck610 FIND v(dout1_338) AT=310.025n

.meas tran vdout1_339ck610 FIND v(dout1_339) AT=310.025n

.meas tran vdout1_340ck610 FIND v(dout1_340) AT=310.025n

.meas tran vdout1_341ck610 FIND v(dout1_341) AT=310.025n

.meas tran vdout1_342ck610 FIND v(dout1_342) AT=310.025n

.meas tran vdout1_343ck610 FIND v(dout1_343) AT=310.025n

.meas tran vdout1_344ck610 FIND v(dout1_344) AT=310.025n

.meas tran vdout1_345ck610 FIND v(dout1_345) AT=310.025n

.meas tran vdout1_346ck610 FIND v(dout1_346) AT=310.025n

.meas tran vdout1_347ck610 FIND v(dout1_347) AT=310.025n

.meas tran vdout1_348ck610 FIND v(dout1_348) AT=310.025n

.meas tran vdout1_349ck610 FIND v(dout1_349) AT=310.025n

.meas tran vdout1_350ck610 FIND v(dout1_350) AT=310.025n

.meas tran vdout1_351ck610 FIND v(dout1_351) AT=310.025n

.meas tran vdout1_352ck610 FIND v(dout1_352) AT=310.025n

.meas tran vdout1_353ck610 FIND v(dout1_353) AT=310.025n

.meas tran vdout1_354ck610 FIND v(dout1_354) AT=310.025n

.meas tran vdout1_355ck610 FIND v(dout1_355) AT=310.025n

.meas tran vdout1_356ck610 FIND v(dout1_356) AT=310.025n

.meas tran vdout1_357ck610 FIND v(dout1_357) AT=310.025n

.meas tran vdout1_358ck610 FIND v(dout1_358) AT=310.025n

.meas tran vdout1_359ck610 FIND v(dout1_359) AT=310.025n

.meas tran vdout1_360ck610 FIND v(dout1_360) AT=310.025n

.meas tran vdout1_361ck610 FIND v(dout1_361) AT=310.025n

.meas tran vdout1_362ck610 FIND v(dout1_362) AT=310.025n

.meas tran vdout1_363ck610 FIND v(dout1_363) AT=310.025n

.meas tran vdout1_364ck610 FIND v(dout1_364) AT=310.025n

.meas tran vdout1_365ck610 FIND v(dout1_365) AT=310.025n

.meas tran vdout1_366ck610 FIND v(dout1_366) AT=310.025n

.meas tran vdout1_367ck610 FIND v(dout1_367) AT=310.025n

.meas tran vdout1_368ck610 FIND v(dout1_368) AT=310.025n

.meas tran vdout1_369ck610 FIND v(dout1_369) AT=310.025n

.meas tran vdout1_370ck610 FIND v(dout1_370) AT=310.025n

.meas tran vdout1_371ck610 FIND v(dout1_371) AT=310.025n

.meas tran vdout1_372ck610 FIND v(dout1_372) AT=310.025n

.meas tran vdout1_373ck610 FIND v(dout1_373) AT=310.025n

.meas tran vdout1_374ck610 FIND v(dout1_374) AT=310.025n

.meas tran vdout1_375ck610 FIND v(dout1_375) AT=310.025n

.meas tran vdout1_376ck610 FIND v(dout1_376) AT=310.025n

.meas tran vdout1_377ck610 FIND v(dout1_377) AT=310.025n

.meas tran vdout1_378ck610 FIND v(dout1_378) AT=310.025n

.meas tran vdout1_379ck610 FIND v(dout1_379) AT=310.025n

.meas tran vdout1_380ck610 FIND v(dout1_380) AT=310.025n

.meas tran vdout1_381ck610 FIND v(dout1_381) AT=310.025n

.meas tran vdout1_382ck610 FIND v(dout1_382) AT=310.025n

.meas tran vdout1_383ck610 FIND v(dout1_383) AT=310.025n

.meas tran vdout1_384ck610 FIND v(dout1_384) AT=310.025n

.meas tran vdout1_385ck610 FIND v(dout1_385) AT=310.025n

.meas tran vdout1_386ck610 FIND v(dout1_386) AT=310.025n

.meas tran vdout1_387ck610 FIND v(dout1_387) AT=310.025n

.meas tran vdout1_388ck610 FIND v(dout1_388) AT=310.025n

.meas tran vdout1_389ck610 FIND v(dout1_389) AT=310.025n

.meas tran vdout1_390ck610 FIND v(dout1_390) AT=310.025n

.meas tran vdout1_391ck610 FIND v(dout1_391) AT=310.025n

.meas tran vdout1_392ck610 FIND v(dout1_392) AT=310.025n

.meas tran vdout1_393ck610 FIND v(dout1_393) AT=310.025n

.meas tran vdout1_394ck610 FIND v(dout1_394) AT=310.025n

.meas tran vdout1_395ck610 FIND v(dout1_395) AT=310.025n

.meas tran vdout1_396ck610 FIND v(dout1_396) AT=310.025n

.meas tran vdout1_397ck610 FIND v(dout1_397) AT=310.025n

.meas tran vdout1_398ck610 FIND v(dout1_398) AT=310.025n

.meas tran vdout1_399ck610 FIND v(dout1_399) AT=310.025n

.meas tran vdout1_400ck610 FIND v(dout1_400) AT=310.025n

.meas tran vdout1_401ck610 FIND v(dout1_401) AT=310.025n

.meas tran vdout1_402ck610 FIND v(dout1_402) AT=310.025n

.meas tran vdout1_403ck610 FIND v(dout1_403) AT=310.025n

.meas tran vdout1_404ck610 FIND v(dout1_404) AT=310.025n

.meas tran vdout1_405ck610 FIND v(dout1_405) AT=310.025n

.meas tran vdout1_406ck610 FIND v(dout1_406) AT=310.025n

.meas tran vdout1_407ck610 FIND v(dout1_407) AT=310.025n

.meas tran vdout1_408ck610 FIND v(dout1_408) AT=310.025n

.meas tran vdout1_409ck610 FIND v(dout1_409) AT=310.025n

.meas tran vdout1_410ck610 FIND v(dout1_410) AT=310.025n

.meas tran vdout1_411ck610 FIND v(dout1_411) AT=310.025n

.meas tran vdout1_412ck610 FIND v(dout1_412) AT=310.025n

.meas tran vdout1_413ck610 FIND v(dout1_413) AT=310.025n

.meas tran vdout1_414ck610 FIND v(dout1_414) AT=310.025n

.meas tran vdout1_415ck610 FIND v(dout1_415) AT=310.025n

.meas tran vdout1_416ck610 FIND v(dout1_416) AT=310.025n

.meas tran vdout1_417ck610 FIND v(dout1_417) AT=310.025n

.meas tran vdout1_418ck610 FIND v(dout1_418) AT=310.025n

.meas tran vdout1_419ck610 FIND v(dout1_419) AT=310.025n

.meas tran vdout1_420ck610 FIND v(dout1_420) AT=310.025n

.meas tran vdout1_421ck610 FIND v(dout1_421) AT=310.025n

.meas tran vdout1_422ck610 FIND v(dout1_422) AT=310.025n

.meas tran vdout1_423ck610 FIND v(dout1_423) AT=310.025n

.meas tran vdout1_424ck610 FIND v(dout1_424) AT=310.025n

.meas tran vdout1_425ck610 FIND v(dout1_425) AT=310.025n

.meas tran vdout1_426ck610 FIND v(dout1_426) AT=310.025n

.meas tran vdout1_427ck610 FIND v(dout1_427) AT=310.025n

.meas tran vdout1_428ck610 FIND v(dout1_428) AT=310.025n

.meas tran vdout1_429ck610 FIND v(dout1_429) AT=310.025n

.meas tran vdout1_430ck610 FIND v(dout1_430) AT=310.025n

.meas tran vdout1_431ck610 FIND v(dout1_431) AT=310.025n

.meas tran vdout1_432ck610 FIND v(dout1_432) AT=310.025n

.meas tran vdout1_433ck610 FIND v(dout1_433) AT=310.025n

.meas tran vdout1_434ck610 FIND v(dout1_434) AT=310.025n

.meas tran vdout1_435ck610 FIND v(dout1_435) AT=310.025n

.meas tran vdout1_436ck610 FIND v(dout1_436) AT=310.025n

.meas tran vdout1_437ck610 FIND v(dout1_437) AT=310.025n

.meas tran vdout1_438ck610 FIND v(dout1_438) AT=310.025n

.meas tran vdout1_439ck610 FIND v(dout1_439) AT=310.025n

.meas tran vdout1_440ck610 FIND v(dout1_440) AT=310.025n

.meas tran vdout1_441ck610 FIND v(dout1_441) AT=310.025n

.meas tran vdout1_442ck610 FIND v(dout1_442) AT=310.025n

.meas tran vdout1_443ck610 FIND v(dout1_443) AT=310.025n

.meas tran vdout1_444ck610 FIND v(dout1_444) AT=310.025n

.meas tran vdout1_445ck610 FIND v(dout1_445) AT=310.025n

.meas tran vdout1_446ck610 FIND v(dout1_446) AT=310.025n

.meas tran vdout1_447ck610 FIND v(dout1_447) AT=310.025n

.meas tran vdout1_448ck610 FIND v(dout1_448) AT=310.025n

.meas tran vdout1_449ck610 FIND v(dout1_449) AT=310.025n

.meas tran vdout1_450ck610 FIND v(dout1_450) AT=310.025n

.meas tran vdout1_451ck610 FIND v(dout1_451) AT=310.025n

.meas tran vdout1_452ck610 FIND v(dout1_452) AT=310.025n

.meas tran vdout1_453ck610 FIND v(dout1_453) AT=310.025n

.meas tran vdout1_454ck610 FIND v(dout1_454) AT=310.025n

.meas tran vdout1_455ck610 FIND v(dout1_455) AT=310.025n

.meas tran vdout1_456ck610 FIND v(dout1_456) AT=310.025n

.meas tran vdout1_457ck610 FIND v(dout1_457) AT=310.025n

.meas tran vdout1_458ck610 FIND v(dout1_458) AT=310.025n

.meas tran vdout1_459ck610 FIND v(dout1_459) AT=310.025n

.meas tran vdout1_460ck610 FIND v(dout1_460) AT=310.025n

.meas tran vdout1_461ck610 FIND v(dout1_461) AT=310.025n

.meas tran vdout1_462ck610 FIND v(dout1_462) AT=310.025n

.meas tran vdout1_463ck610 FIND v(dout1_463) AT=310.025n

.meas tran vdout1_464ck610 FIND v(dout1_464) AT=310.025n

.meas tran vdout1_465ck610 FIND v(dout1_465) AT=310.025n

.meas tran vdout1_466ck610 FIND v(dout1_466) AT=310.025n

.meas tran vdout1_467ck610 FIND v(dout1_467) AT=310.025n

.meas tran vdout1_468ck610 FIND v(dout1_468) AT=310.025n

.meas tran vdout1_469ck610 FIND v(dout1_469) AT=310.025n

.meas tran vdout1_470ck610 FIND v(dout1_470) AT=310.025n

.meas tran vdout1_471ck610 FIND v(dout1_471) AT=310.025n

.meas tran vdout1_472ck610 FIND v(dout1_472) AT=310.025n

.meas tran vdout1_473ck610 FIND v(dout1_473) AT=310.025n

.meas tran vdout1_474ck610 FIND v(dout1_474) AT=310.025n

.meas tran vdout1_475ck610 FIND v(dout1_475) AT=310.025n

.meas tran vdout1_476ck610 FIND v(dout1_476) AT=310.025n

.meas tran vdout1_477ck610 FIND v(dout1_477) AT=310.025n

.meas tran vdout1_478ck610 FIND v(dout1_478) AT=310.025n

.meas tran vdout1_479ck610 FIND v(dout1_479) AT=310.025n

.meas tran vdout1_480ck610 FIND v(dout1_480) AT=310.025n

.meas tran vdout1_481ck610 FIND v(dout1_481) AT=310.025n

.meas tran vdout1_482ck610 FIND v(dout1_482) AT=310.025n

.meas tran vdout1_483ck610 FIND v(dout1_483) AT=310.025n

.meas tran vdout1_484ck610 FIND v(dout1_484) AT=310.025n

.meas tran vdout1_485ck610 FIND v(dout1_485) AT=310.025n

.meas tran vdout1_486ck610 FIND v(dout1_486) AT=310.025n

.meas tran vdout1_487ck610 FIND v(dout1_487) AT=310.025n

.meas tran vdout1_488ck610 FIND v(dout1_488) AT=310.025n

.meas tran vdout1_489ck610 FIND v(dout1_489) AT=310.025n

.meas tran vdout1_490ck610 FIND v(dout1_490) AT=310.025n

.meas tran vdout1_491ck610 FIND v(dout1_491) AT=310.025n

.meas tran vdout1_492ck610 FIND v(dout1_492) AT=310.025n

.meas tran vdout1_493ck610 FIND v(dout1_493) AT=310.025n

.meas tran vdout1_494ck610 FIND v(dout1_494) AT=310.025n

.meas tran vdout1_495ck610 FIND v(dout1_495) AT=310.025n

.meas tran vdout1_496ck610 FIND v(dout1_496) AT=310.025n

.meas tran vdout1_497ck610 FIND v(dout1_497) AT=310.025n

.meas tran vdout1_498ck610 FIND v(dout1_498) AT=310.025n

.meas tran vdout1_499ck610 FIND v(dout1_499) AT=310.025n

.meas tran vdout1_500ck610 FIND v(dout1_500) AT=310.025n

.meas tran vdout1_501ck610 FIND v(dout1_501) AT=310.025n

.meas tran vdout1_502ck610 FIND v(dout1_502) AT=310.025n

.meas tran vdout1_503ck610 FIND v(dout1_503) AT=310.025n

.meas tran vdout1_504ck610 FIND v(dout1_504) AT=310.025n

.meas tran vdout1_505ck610 FIND v(dout1_505) AT=310.025n

.meas tran vdout1_506ck610 FIND v(dout1_506) AT=310.025n

.meas tran vdout1_507ck610 FIND v(dout1_507) AT=310.025n

.meas tran vdout1_508ck610 FIND v(dout1_508) AT=310.025n

.meas tran vdout1_509ck610 FIND v(dout1_509) AT=310.025n

.meas tran vdout1_510ck610 FIND v(dout1_510) AT=310.025n

.meas tran vdout1_511ck610 FIND v(dout1_511) AT=310.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_19ck650 FIND v(dout1_19) AT=330.025n

.meas tran vdout1_20ck650 FIND v(dout1_20) AT=330.025n

.meas tran vdout1_21ck650 FIND v(dout1_21) AT=330.025n

.meas tran vdout1_22ck650 FIND v(dout1_22) AT=330.025n

.meas tran vdout1_23ck650 FIND v(dout1_23) AT=330.025n

.meas tran vdout1_24ck650 FIND v(dout1_24) AT=330.025n

.meas tran vdout1_25ck650 FIND v(dout1_25) AT=330.025n

.meas tran vdout1_26ck650 FIND v(dout1_26) AT=330.025n

.meas tran vdout1_27ck650 FIND v(dout1_27) AT=330.025n

.meas tran vdout1_28ck650 FIND v(dout1_28) AT=330.025n

.meas tran vdout1_29ck650 FIND v(dout1_29) AT=330.025n

.meas tran vdout1_30ck650 FIND v(dout1_30) AT=330.025n

.meas tran vdout1_31ck650 FIND v(dout1_31) AT=330.025n

.meas tran vdout1_32ck650 FIND v(dout1_32) AT=330.025n

.meas tran vdout1_33ck650 FIND v(dout1_33) AT=330.025n

.meas tran vdout1_34ck650 FIND v(dout1_34) AT=330.025n

.meas tran vdout1_35ck650 FIND v(dout1_35) AT=330.025n

.meas tran vdout1_36ck650 FIND v(dout1_36) AT=330.025n

.meas tran vdout1_37ck650 FIND v(dout1_37) AT=330.025n

.meas tran vdout1_38ck650 FIND v(dout1_38) AT=330.025n

.meas tran vdout1_39ck650 FIND v(dout1_39) AT=330.025n

.meas tran vdout1_40ck650 FIND v(dout1_40) AT=330.025n

.meas tran vdout1_41ck650 FIND v(dout1_41) AT=330.025n

.meas tran vdout1_42ck650 FIND v(dout1_42) AT=330.025n

.meas tran vdout1_43ck650 FIND v(dout1_43) AT=330.025n

.meas tran vdout1_44ck650 FIND v(dout1_44) AT=330.025n

.meas tran vdout1_45ck650 FIND v(dout1_45) AT=330.025n

.meas tran vdout1_46ck650 FIND v(dout1_46) AT=330.025n

.meas tran vdout1_47ck650 FIND v(dout1_47) AT=330.025n

.meas tran vdout1_48ck650 FIND v(dout1_48) AT=330.025n

.meas tran vdout1_49ck650 FIND v(dout1_49) AT=330.025n

.meas tran vdout1_50ck650 FIND v(dout1_50) AT=330.025n

.meas tran vdout1_51ck650 FIND v(dout1_51) AT=330.025n

.meas tran vdout1_52ck650 FIND v(dout1_52) AT=330.025n

.meas tran vdout1_53ck650 FIND v(dout1_53) AT=330.025n

.meas tran vdout1_54ck650 FIND v(dout1_54) AT=330.025n

.meas tran vdout1_55ck650 FIND v(dout1_55) AT=330.025n

.meas tran vdout1_56ck650 FIND v(dout1_56) AT=330.025n

.meas tran vdout1_57ck650 FIND v(dout1_57) AT=330.025n

.meas tran vdout1_58ck650 FIND v(dout1_58) AT=330.025n

.meas tran vdout1_59ck650 FIND v(dout1_59) AT=330.025n

.meas tran vdout1_60ck650 FIND v(dout1_60) AT=330.025n

.meas tran vdout1_61ck650 FIND v(dout1_61) AT=330.025n

.meas tran vdout1_62ck650 FIND v(dout1_62) AT=330.025n

.meas tran vdout1_63ck650 FIND v(dout1_63) AT=330.025n

.meas tran vdout1_64ck650 FIND v(dout1_64) AT=330.025n

.meas tran vdout1_65ck650 FIND v(dout1_65) AT=330.025n

.meas tran vdout1_66ck650 FIND v(dout1_66) AT=330.025n

.meas tran vdout1_67ck650 FIND v(dout1_67) AT=330.025n

.meas tran vdout1_68ck650 FIND v(dout1_68) AT=330.025n

.meas tran vdout1_69ck650 FIND v(dout1_69) AT=330.025n

.meas tran vdout1_70ck650 FIND v(dout1_70) AT=330.025n

.meas tran vdout1_71ck650 FIND v(dout1_71) AT=330.025n

.meas tran vdout1_72ck650 FIND v(dout1_72) AT=330.025n

.meas tran vdout1_73ck650 FIND v(dout1_73) AT=330.025n

.meas tran vdout1_74ck650 FIND v(dout1_74) AT=330.025n

.meas tran vdout1_75ck650 FIND v(dout1_75) AT=330.025n

.meas tran vdout1_76ck650 FIND v(dout1_76) AT=330.025n

.meas tran vdout1_77ck650 FIND v(dout1_77) AT=330.025n

.meas tran vdout1_78ck650 FIND v(dout1_78) AT=330.025n

.meas tran vdout1_79ck650 FIND v(dout1_79) AT=330.025n

.meas tran vdout1_80ck650 FIND v(dout1_80) AT=330.025n

.meas tran vdout1_81ck650 FIND v(dout1_81) AT=330.025n

.meas tran vdout1_82ck650 FIND v(dout1_82) AT=330.025n

.meas tran vdout1_83ck650 FIND v(dout1_83) AT=330.025n

.meas tran vdout1_84ck650 FIND v(dout1_84) AT=330.025n

.meas tran vdout1_85ck650 FIND v(dout1_85) AT=330.025n

.meas tran vdout1_86ck650 FIND v(dout1_86) AT=330.025n

.meas tran vdout1_87ck650 FIND v(dout1_87) AT=330.025n

.meas tran vdout1_88ck650 FIND v(dout1_88) AT=330.025n

.meas tran vdout1_89ck650 FIND v(dout1_89) AT=330.025n

.meas tran vdout1_90ck650 FIND v(dout1_90) AT=330.025n

.meas tran vdout1_91ck650 FIND v(dout1_91) AT=330.025n

.meas tran vdout1_92ck650 FIND v(dout1_92) AT=330.025n

.meas tran vdout1_93ck650 FIND v(dout1_93) AT=330.025n

.meas tran vdout1_94ck650 FIND v(dout1_94) AT=330.025n

.meas tran vdout1_95ck650 FIND v(dout1_95) AT=330.025n

.meas tran vdout1_96ck650 FIND v(dout1_96) AT=330.025n

.meas tran vdout1_97ck650 FIND v(dout1_97) AT=330.025n

.meas tran vdout1_98ck650 FIND v(dout1_98) AT=330.025n

.meas tran vdout1_99ck650 FIND v(dout1_99) AT=330.025n

.meas tran vdout1_100ck650 FIND v(dout1_100) AT=330.025n

.meas tran vdout1_101ck650 FIND v(dout1_101) AT=330.025n

.meas tran vdout1_102ck650 FIND v(dout1_102) AT=330.025n

.meas tran vdout1_103ck650 FIND v(dout1_103) AT=330.025n

.meas tran vdout1_104ck650 FIND v(dout1_104) AT=330.025n

.meas tran vdout1_105ck650 FIND v(dout1_105) AT=330.025n

.meas tran vdout1_106ck650 FIND v(dout1_106) AT=330.025n

.meas tran vdout1_107ck650 FIND v(dout1_107) AT=330.025n

.meas tran vdout1_108ck650 FIND v(dout1_108) AT=330.025n

.meas tran vdout1_109ck650 FIND v(dout1_109) AT=330.025n

.meas tran vdout1_110ck650 FIND v(dout1_110) AT=330.025n

.meas tran vdout1_111ck650 FIND v(dout1_111) AT=330.025n

.meas tran vdout1_112ck650 FIND v(dout1_112) AT=330.025n

.meas tran vdout1_113ck650 FIND v(dout1_113) AT=330.025n

.meas tran vdout1_114ck650 FIND v(dout1_114) AT=330.025n

.meas tran vdout1_115ck650 FIND v(dout1_115) AT=330.025n

.meas tran vdout1_116ck650 FIND v(dout1_116) AT=330.025n

.meas tran vdout1_117ck650 FIND v(dout1_117) AT=330.025n

.meas tran vdout1_118ck650 FIND v(dout1_118) AT=330.025n

.meas tran vdout1_119ck650 FIND v(dout1_119) AT=330.025n

.meas tran vdout1_120ck650 FIND v(dout1_120) AT=330.025n

.meas tran vdout1_121ck650 FIND v(dout1_121) AT=330.025n

.meas tran vdout1_122ck650 FIND v(dout1_122) AT=330.025n

.meas tran vdout1_123ck650 FIND v(dout1_123) AT=330.025n

.meas tran vdout1_124ck650 FIND v(dout1_124) AT=330.025n

.meas tran vdout1_125ck650 FIND v(dout1_125) AT=330.025n

.meas tran vdout1_126ck650 FIND v(dout1_126) AT=330.025n

.meas tran vdout1_127ck650 FIND v(dout1_127) AT=330.025n

.meas tran vdout1_128ck650 FIND v(dout1_128) AT=330.025n

.meas tran vdout1_129ck650 FIND v(dout1_129) AT=330.025n

.meas tran vdout1_130ck650 FIND v(dout1_130) AT=330.025n

.meas tran vdout1_131ck650 FIND v(dout1_131) AT=330.025n

.meas tran vdout1_132ck650 FIND v(dout1_132) AT=330.025n

.meas tran vdout1_133ck650 FIND v(dout1_133) AT=330.025n

.meas tran vdout1_134ck650 FIND v(dout1_134) AT=330.025n

.meas tran vdout1_135ck650 FIND v(dout1_135) AT=330.025n

.meas tran vdout1_136ck650 FIND v(dout1_136) AT=330.025n

.meas tran vdout1_137ck650 FIND v(dout1_137) AT=330.025n

.meas tran vdout1_138ck650 FIND v(dout1_138) AT=330.025n

.meas tran vdout1_139ck650 FIND v(dout1_139) AT=330.025n

.meas tran vdout1_140ck650 FIND v(dout1_140) AT=330.025n

.meas tran vdout1_141ck650 FIND v(dout1_141) AT=330.025n

.meas tran vdout1_142ck650 FIND v(dout1_142) AT=330.025n

.meas tran vdout1_143ck650 FIND v(dout1_143) AT=330.025n

.meas tran vdout1_144ck650 FIND v(dout1_144) AT=330.025n

.meas tran vdout1_145ck650 FIND v(dout1_145) AT=330.025n

.meas tran vdout1_146ck650 FIND v(dout1_146) AT=330.025n

.meas tran vdout1_147ck650 FIND v(dout1_147) AT=330.025n

.meas tran vdout1_148ck650 FIND v(dout1_148) AT=330.025n

.meas tran vdout1_149ck650 FIND v(dout1_149) AT=330.025n

.meas tran vdout1_150ck650 FIND v(dout1_150) AT=330.025n

.meas tran vdout1_151ck650 FIND v(dout1_151) AT=330.025n

.meas tran vdout1_152ck650 FIND v(dout1_152) AT=330.025n

.meas tran vdout1_153ck650 FIND v(dout1_153) AT=330.025n

.meas tran vdout1_154ck650 FIND v(dout1_154) AT=330.025n

.meas tran vdout1_155ck650 FIND v(dout1_155) AT=330.025n

.meas tran vdout1_156ck650 FIND v(dout1_156) AT=330.025n

.meas tran vdout1_157ck650 FIND v(dout1_157) AT=330.025n

.meas tran vdout1_158ck650 FIND v(dout1_158) AT=330.025n

.meas tran vdout1_159ck650 FIND v(dout1_159) AT=330.025n

.meas tran vdout1_160ck650 FIND v(dout1_160) AT=330.025n

.meas tran vdout1_161ck650 FIND v(dout1_161) AT=330.025n

.meas tran vdout1_162ck650 FIND v(dout1_162) AT=330.025n

.meas tran vdout1_163ck650 FIND v(dout1_163) AT=330.025n

.meas tran vdout1_164ck650 FIND v(dout1_164) AT=330.025n

.meas tran vdout1_165ck650 FIND v(dout1_165) AT=330.025n

.meas tran vdout1_166ck650 FIND v(dout1_166) AT=330.025n

.meas tran vdout1_167ck650 FIND v(dout1_167) AT=330.025n

.meas tran vdout1_168ck650 FIND v(dout1_168) AT=330.025n

.meas tran vdout1_169ck650 FIND v(dout1_169) AT=330.025n

.meas tran vdout1_170ck650 FIND v(dout1_170) AT=330.025n

.meas tran vdout1_171ck650 FIND v(dout1_171) AT=330.025n

.meas tran vdout1_172ck650 FIND v(dout1_172) AT=330.025n

.meas tran vdout1_173ck650 FIND v(dout1_173) AT=330.025n

.meas tran vdout1_174ck650 FIND v(dout1_174) AT=330.025n

.meas tran vdout1_175ck650 FIND v(dout1_175) AT=330.025n

.meas tran vdout1_176ck650 FIND v(dout1_176) AT=330.025n

.meas tran vdout1_177ck650 FIND v(dout1_177) AT=330.025n

.meas tran vdout1_178ck650 FIND v(dout1_178) AT=330.025n

.meas tran vdout1_179ck650 FIND v(dout1_179) AT=330.025n

.meas tran vdout1_180ck650 FIND v(dout1_180) AT=330.025n

.meas tran vdout1_181ck650 FIND v(dout1_181) AT=330.025n

.meas tran vdout1_182ck650 FIND v(dout1_182) AT=330.025n

.meas tran vdout1_183ck650 FIND v(dout1_183) AT=330.025n

.meas tran vdout1_184ck650 FIND v(dout1_184) AT=330.025n

.meas tran vdout1_185ck650 FIND v(dout1_185) AT=330.025n

.meas tran vdout1_186ck650 FIND v(dout1_186) AT=330.025n

.meas tran vdout1_187ck650 FIND v(dout1_187) AT=330.025n

.meas tran vdout1_188ck650 FIND v(dout1_188) AT=330.025n

.meas tran vdout1_189ck650 FIND v(dout1_189) AT=330.025n

.meas tran vdout1_190ck650 FIND v(dout1_190) AT=330.025n

.meas tran vdout1_191ck650 FIND v(dout1_191) AT=330.025n

.meas tran vdout1_192ck650 FIND v(dout1_192) AT=330.025n

.meas tran vdout1_193ck650 FIND v(dout1_193) AT=330.025n

.meas tran vdout1_194ck650 FIND v(dout1_194) AT=330.025n

.meas tran vdout1_195ck650 FIND v(dout1_195) AT=330.025n

.meas tran vdout1_196ck650 FIND v(dout1_196) AT=330.025n

.meas tran vdout1_197ck650 FIND v(dout1_197) AT=330.025n

.meas tran vdout1_198ck650 FIND v(dout1_198) AT=330.025n

.meas tran vdout1_199ck650 FIND v(dout1_199) AT=330.025n

.meas tran vdout1_200ck650 FIND v(dout1_200) AT=330.025n

.meas tran vdout1_201ck650 FIND v(dout1_201) AT=330.025n

.meas tran vdout1_202ck650 FIND v(dout1_202) AT=330.025n

.meas tran vdout1_203ck650 FIND v(dout1_203) AT=330.025n

.meas tran vdout1_204ck650 FIND v(dout1_204) AT=330.025n

.meas tran vdout1_205ck650 FIND v(dout1_205) AT=330.025n

.meas tran vdout1_206ck650 FIND v(dout1_206) AT=330.025n

.meas tran vdout1_207ck650 FIND v(dout1_207) AT=330.025n

.meas tran vdout1_208ck650 FIND v(dout1_208) AT=330.025n

.meas tran vdout1_209ck650 FIND v(dout1_209) AT=330.025n

.meas tran vdout1_210ck650 FIND v(dout1_210) AT=330.025n

.meas tran vdout1_211ck650 FIND v(dout1_211) AT=330.025n

.meas tran vdout1_212ck650 FIND v(dout1_212) AT=330.025n

.meas tran vdout1_213ck650 FIND v(dout1_213) AT=330.025n

.meas tran vdout1_214ck650 FIND v(dout1_214) AT=330.025n

.meas tran vdout1_215ck650 FIND v(dout1_215) AT=330.025n

.meas tran vdout1_216ck650 FIND v(dout1_216) AT=330.025n

.meas tran vdout1_217ck650 FIND v(dout1_217) AT=330.025n

.meas tran vdout1_218ck650 FIND v(dout1_218) AT=330.025n

.meas tran vdout1_219ck650 FIND v(dout1_219) AT=330.025n

.meas tran vdout1_220ck650 FIND v(dout1_220) AT=330.025n

.meas tran vdout1_221ck650 FIND v(dout1_221) AT=330.025n

.meas tran vdout1_222ck650 FIND v(dout1_222) AT=330.025n

.meas tran vdout1_223ck650 FIND v(dout1_223) AT=330.025n

.meas tran vdout1_224ck650 FIND v(dout1_224) AT=330.025n

.meas tran vdout1_225ck650 FIND v(dout1_225) AT=330.025n

.meas tran vdout1_226ck650 FIND v(dout1_226) AT=330.025n

.meas tran vdout1_227ck650 FIND v(dout1_227) AT=330.025n

.meas tran vdout1_228ck650 FIND v(dout1_228) AT=330.025n

.meas tran vdout1_229ck650 FIND v(dout1_229) AT=330.025n

.meas tran vdout1_230ck650 FIND v(dout1_230) AT=330.025n

.meas tran vdout1_231ck650 FIND v(dout1_231) AT=330.025n

.meas tran vdout1_232ck650 FIND v(dout1_232) AT=330.025n

.meas tran vdout1_233ck650 FIND v(dout1_233) AT=330.025n

.meas tran vdout1_234ck650 FIND v(dout1_234) AT=330.025n

.meas tran vdout1_235ck650 FIND v(dout1_235) AT=330.025n

.meas tran vdout1_236ck650 FIND v(dout1_236) AT=330.025n

.meas tran vdout1_237ck650 FIND v(dout1_237) AT=330.025n

.meas tran vdout1_238ck650 FIND v(dout1_238) AT=330.025n

.meas tran vdout1_239ck650 FIND v(dout1_239) AT=330.025n

.meas tran vdout1_240ck650 FIND v(dout1_240) AT=330.025n

.meas tran vdout1_241ck650 FIND v(dout1_241) AT=330.025n

.meas tran vdout1_242ck650 FIND v(dout1_242) AT=330.025n

.meas tran vdout1_243ck650 FIND v(dout1_243) AT=330.025n

.meas tran vdout1_244ck650 FIND v(dout1_244) AT=330.025n

.meas tran vdout1_245ck650 FIND v(dout1_245) AT=330.025n

.meas tran vdout1_246ck650 FIND v(dout1_246) AT=330.025n

.meas tran vdout1_247ck650 FIND v(dout1_247) AT=330.025n

.meas tran vdout1_248ck650 FIND v(dout1_248) AT=330.025n

.meas tran vdout1_249ck650 FIND v(dout1_249) AT=330.025n

.meas tran vdout1_250ck650 FIND v(dout1_250) AT=330.025n

.meas tran vdout1_251ck650 FIND v(dout1_251) AT=330.025n

.meas tran vdout1_252ck650 FIND v(dout1_252) AT=330.025n

.meas tran vdout1_253ck650 FIND v(dout1_253) AT=330.025n

.meas tran vdout1_254ck650 FIND v(dout1_254) AT=330.025n

.meas tran vdout1_255ck650 FIND v(dout1_255) AT=330.025n

.meas tran vdout1_256ck650 FIND v(dout1_256) AT=330.025n

.meas tran vdout1_257ck650 FIND v(dout1_257) AT=330.025n

.meas tran vdout1_258ck650 FIND v(dout1_258) AT=330.025n

.meas tran vdout1_259ck650 FIND v(dout1_259) AT=330.025n

.meas tran vdout1_260ck650 FIND v(dout1_260) AT=330.025n

.meas tran vdout1_261ck650 FIND v(dout1_261) AT=330.025n

.meas tran vdout1_262ck650 FIND v(dout1_262) AT=330.025n

.meas tran vdout1_263ck650 FIND v(dout1_263) AT=330.025n

.meas tran vdout1_264ck650 FIND v(dout1_264) AT=330.025n

.meas tran vdout1_265ck650 FIND v(dout1_265) AT=330.025n

.meas tran vdout1_266ck650 FIND v(dout1_266) AT=330.025n

.meas tran vdout1_267ck650 FIND v(dout1_267) AT=330.025n

.meas tran vdout1_268ck650 FIND v(dout1_268) AT=330.025n

.meas tran vdout1_269ck650 FIND v(dout1_269) AT=330.025n

.meas tran vdout1_270ck650 FIND v(dout1_270) AT=330.025n

.meas tran vdout1_271ck650 FIND v(dout1_271) AT=330.025n

.meas tran vdout1_272ck650 FIND v(dout1_272) AT=330.025n

.meas tran vdout1_273ck650 FIND v(dout1_273) AT=330.025n

.meas tran vdout1_274ck650 FIND v(dout1_274) AT=330.025n

.meas tran vdout1_275ck650 FIND v(dout1_275) AT=330.025n

.meas tran vdout1_276ck650 FIND v(dout1_276) AT=330.025n

.meas tran vdout1_277ck650 FIND v(dout1_277) AT=330.025n

.meas tran vdout1_278ck650 FIND v(dout1_278) AT=330.025n

.meas tran vdout1_279ck650 FIND v(dout1_279) AT=330.025n

.meas tran vdout1_280ck650 FIND v(dout1_280) AT=330.025n

.meas tran vdout1_281ck650 FIND v(dout1_281) AT=330.025n

.meas tran vdout1_282ck650 FIND v(dout1_282) AT=330.025n

.meas tran vdout1_283ck650 FIND v(dout1_283) AT=330.025n

.meas tran vdout1_284ck650 FIND v(dout1_284) AT=330.025n

.meas tran vdout1_285ck650 FIND v(dout1_285) AT=330.025n

.meas tran vdout1_286ck650 FIND v(dout1_286) AT=330.025n

.meas tran vdout1_287ck650 FIND v(dout1_287) AT=330.025n

.meas tran vdout1_288ck650 FIND v(dout1_288) AT=330.025n

.meas tran vdout1_289ck650 FIND v(dout1_289) AT=330.025n

.meas tran vdout1_290ck650 FIND v(dout1_290) AT=330.025n

.meas tran vdout1_291ck650 FIND v(dout1_291) AT=330.025n

.meas tran vdout1_292ck650 FIND v(dout1_292) AT=330.025n

.meas tran vdout1_293ck650 FIND v(dout1_293) AT=330.025n

.meas tran vdout1_294ck650 FIND v(dout1_294) AT=330.025n

.meas tran vdout1_295ck650 FIND v(dout1_295) AT=330.025n

.meas tran vdout1_296ck650 FIND v(dout1_296) AT=330.025n

.meas tran vdout1_297ck650 FIND v(dout1_297) AT=330.025n

.meas tran vdout1_298ck650 FIND v(dout1_298) AT=330.025n

.meas tran vdout1_299ck650 FIND v(dout1_299) AT=330.025n

.meas tran vdout1_300ck650 FIND v(dout1_300) AT=330.025n

.meas tran vdout1_301ck650 FIND v(dout1_301) AT=330.025n

.meas tran vdout1_302ck650 FIND v(dout1_302) AT=330.025n

.meas tran vdout1_303ck650 FIND v(dout1_303) AT=330.025n

.meas tran vdout1_304ck650 FIND v(dout1_304) AT=330.025n

.meas tran vdout1_305ck650 FIND v(dout1_305) AT=330.025n

.meas tran vdout1_306ck650 FIND v(dout1_306) AT=330.025n

.meas tran vdout1_307ck650 FIND v(dout1_307) AT=330.025n

.meas tran vdout1_308ck650 FIND v(dout1_308) AT=330.025n

.meas tran vdout1_309ck650 FIND v(dout1_309) AT=330.025n

.meas tran vdout1_310ck650 FIND v(dout1_310) AT=330.025n

.meas tran vdout1_311ck650 FIND v(dout1_311) AT=330.025n

.meas tran vdout1_312ck650 FIND v(dout1_312) AT=330.025n

.meas tran vdout1_313ck650 FIND v(dout1_313) AT=330.025n

.meas tran vdout1_314ck650 FIND v(dout1_314) AT=330.025n

.meas tran vdout1_315ck650 FIND v(dout1_315) AT=330.025n

.meas tran vdout1_316ck650 FIND v(dout1_316) AT=330.025n

.meas tran vdout1_317ck650 FIND v(dout1_317) AT=330.025n

.meas tran vdout1_318ck650 FIND v(dout1_318) AT=330.025n

.meas tran vdout1_319ck650 FIND v(dout1_319) AT=330.025n

.meas tran vdout1_320ck650 FIND v(dout1_320) AT=330.025n

.meas tran vdout1_321ck650 FIND v(dout1_321) AT=330.025n

.meas tran vdout1_322ck650 FIND v(dout1_322) AT=330.025n

.meas tran vdout1_323ck650 FIND v(dout1_323) AT=330.025n

.meas tran vdout1_324ck650 FIND v(dout1_324) AT=330.025n

.meas tran vdout1_325ck650 FIND v(dout1_325) AT=330.025n

.meas tran vdout1_326ck650 FIND v(dout1_326) AT=330.025n

.meas tran vdout1_327ck650 FIND v(dout1_327) AT=330.025n

.meas tran vdout1_328ck650 FIND v(dout1_328) AT=330.025n

.meas tran vdout1_329ck650 FIND v(dout1_329) AT=330.025n

.meas tran vdout1_330ck650 FIND v(dout1_330) AT=330.025n

.meas tran vdout1_331ck650 FIND v(dout1_331) AT=330.025n

.meas tran vdout1_332ck650 FIND v(dout1_332) AT=330.025n

.meas tran vdout1_333ck650 FIND v(dout1_333) AT=330.025n

.meas tran vdout1_334ck650 FIND v(dout1_334) AT=330.025n

.meas tran vdout1_335ck650 FIND v(dout1_335) AT=330.025n

.meas tran vdout1_336ck650 FIND v(dout1_336) AT=330.025n

.meas tran vdout1_337ck650 FIND v(dout1_337) AT=330.025n

.meas tran vdout1_338ck650 FIND v(dout1_338) AT=330.025n

.meas tran vdout1_339ck650 FIND v(dout1_339) AT=330.025n

.meas tran vdout1_340ck650 FIND v(dout1_340) AT=330.025n

.meas tran vdout1_341ck650 FIND v(dout1_341) AT=330.025n

.meas tran vdout1_342ck650 FIND v(dout1_342) AT=330.025n

.meas tran vdout1_343ck650 FIND v(dout1_343) AT=330.025n

.meas tran vdout1_344ck650 FIND v(dout1_344) AT=330.025n

.meas tran vdout1_345ck650 FIND v(dout1_345) AT=330.025n

.meas tran vdout1_346ck650 FIND v(dout1_346) AT=330.025n

.meas tran vdout1_347ck650 FIND v(dout1_347) AT=330.025n

.meas tran vdout1_348ck650 FIND v(dout1_348) AT=330.025n

.meas tran vdout1_349ck650 FIND v(dout1_349) AT=330.025n

.meas tran vdout1_350ck650 FIND v(dout1_350) AT=330.025n

.meas tran vdout1_351ck650 FIND v(dout1_351) AT=330.025n

.meas tran vdout1_352ck650 FIND v(dout1_352) AT=330.025n

.meas tran vdout1_353ck650 FIND v(dout1_353) AT=330.025n

.meas tran vdout1_354ck650 FIND v(dout1_354) AT=330.025n

.meas tran vdout1_355ck650 FIND v(dout1_355) AT=330.025n

.meas tran vdout1_356ck650 FIND v(dout1_356) AT=330.025n

.meas tran vdout1_357ck650 FIND v(dout1_357) AT=330.025n

.meas tran vdout1_358ck650 FIND v(dout1_358) AT=330.025n

.meas tran vdout1_359ck650 FIND v(dout1_359) AT=330.025n

.meas tran vdout1_360ck650 FIND v(dout1_360) AT=330.025n

.meas tran vdout1_361ck650 FIND v(dout1_361) AT=330.025n

.meas tran vdout1_362ck650 FIND v(dout1_362) AT=330.025n

.meas tran vdout1_363ck650 FIND v(dout1_363) AT=330.025n

.meas tran vdout1_364ck650 FIND v(dout1_364) AT=330.025n

.meas tran vdout1_365ck650 FIND v(dout1_365) AT=330.025n

.meas tran vdout1_366ck650 FIND v(dout1_366) AT=330.025n

.meas tran vdout1_367ck650 FIND v(dout1_367) AT=330.025n

.meas tran vdout1_368ck650 FIND v(dout1_368) AT=330.025n

.meas tran vdout1_369ck650 FIND v(dout1_369) AT=330.025n

.meas tran vdout1_370ck650 FIND v(dout1_370) AT=330.025n

.meas tran vdout1_371ck650 FIND v(dout1_371) AT=330.025n

.meas tran vdout1_372ck650 FIND v(dout1_372) AT=330.025n

.meas tran vdout1_373ck650 FIND v(dout1_373) AT=330.025n

.meas tran vdout1_374ck650 FIND v(dout1_374) AT=330.025n

.meas tran vdout1_375ck650 FIND v(dout1_375) AT=330.025n

.meas tran vdout1_376ck650 FIND v(dout1_376) AT=330.025n

.meas tran vdout1_377ck650 FIND v(dout1_377) AT=330.025n

.meas tran vdout1_378ck650 FIND v(dout1_378) AT=330.025n

.meas tran vdout1_379ck650 FIND v(dout1_379) AT=330.025n

.meas tran vdout1_380ck650 FIND v(dout1_380) AT=330.025n

.meas tran vdout1_381ck650 FIND v(dout1_381) AT=330.025n

.meas tran vdout1_382ck650 FIND v(dout1_382) AT=330.025n

.meas tran vdout1_383ck650 FIND v(dout1_383) AT=330.025n

.meas tran vdout1_384ck650 FIND v(dout1_384) AT=330.025n

.meas tran vdout1_385ck650 FIND v(dout1_385) AT=330.025n

.meas tran vdout1_386ck650 FIND v(dout1_386) AT=330.025n

.meas tran vdout1_387ck650 FIND v(dout1_387) AT=330.025n

.meas tran vdout1_388ck650 FIND v(dout1_388) AT=330.025n

.meas tran vdout1_389ck650 FIND v(dout1_389) AT=330.025n

.meas tran vdout1_390ck650 FIND v(dout1_390) AT=330.025n

.meas tran vdout1_391ck650 FIND v(dout1_391) AT=330.025n

.meas tran vdout1_392ck650 FIND v(dout1_392) AT=330.025n

.meas tran vdout1_393ck650 FIND v(dout1_393) AT=330.025n

.meas tran vdout1_394ck650 FIND v(dout1_394) AT=330.025n

.meas tran vdout1_395ck650 FIND v(dout1_395) AT=330.025n

.meas tran vdout1_396ck650 FIND v(dout1_396) AT=330.025n

.meas tran vdout1_397ck650 FIND v(dout1_397) AT=330.025n

.meas tran vdout1_398ck650 FIND v(dout1_398) AT=330.025n

.meas tran vdout1_399ck650 FIND v(dout1_399) AT=330.025n

.meas tran vdout1_400ck650 FIND v(dout1_400) AT=330.025n

.meas tran vdout1_401ck650 FIND v(dout1_401) AT=330.025n

.meas tran vdout1_402ck650 FIND v(dout1_402) AT=330.025n

.meas tran vdout1_403ck650 FIND v(dout1_403) AT=330.025n

.meas tran vdout1_404ck650 FIND v(dout1_404) AT=330.025n

.meas tran vdout1_405ck650 FIND v(dout1_405) AT=330.025n

.meas tran vdout1_406ck650 FIND v(dout1_406) AT=330.025n

.meas tran vdout1_407ck650 FIND v(dout1_407) AT=330.025n

.meas tran vdout1_408ck650 FIND v(dout1_408) AT=330.025n

.meas tran vdout1_409ck650 FIND v(dout1_409) AT=330.025n

.meas tran vdout1_410ck650 FIND v(dout1_410) AT=330.025n

.meas tran vdout1_411ck650 FIND v(dout1_411) AT=330.025n

.meas tran vdout1_412ck650 FIND v(dout1_412) AT=330.025n

.meas tran vdout1_413ck650 FIND v(dout1_413) AT=330.025n

.meas tran vdout1_414ck650 FIND v(dout1_414) AT=330.025n

.meas tran vdout1_415ck650 FIND v(dout1_415) AT=330.025n

.meas tran vdout1_416ck650 FIND v(dout1_416) AT=330.025n

.meas tran vdout1_417ck650 FIND v(dout1_417) AT=330.025n

.meas tran vdout1_418ck650 FIND v(dout1_418) AT=330.025n

.meas tran vdout1_419ck650 FIND v(dout1_419) AT=330.025n

.meas tran vdout1_420ck650 FIND v(dout1_420) AT=330.025n

.meas tran vdout1_421ck650 FIND v(dout1_421) AT=330.025n

.meas tran vdout1_422ck650 FIND v(dout1_422) AT=330.025n

.meas tran vdout1_423ck650 FIND v(dout1_423) AT=330.025n

.meas tran vdout1_424ck650 FIND v(dout1_424) AT=330.025n

.meas tran vdout1_425ck650 FIND v(dout1_425) AT=330.025n

.meas tran vdout1_426ck650 FIND v(dout1_426) AT=330.025n

.meas tran vdout1_427ck650 FIND v(dout1_427) AT=330.025n

.meas tran vdout1_428ck650 FIND v(dout1_428) AT=330.025n

.meas tran vdout1_429ck650 FIND v(dout1_429) AT=330.025n

.meas tran vdout1_430ck650 FIND v(dout1_430) AT=330.025n

.meas tran vdout1_431ck650 FIND v(dout1_431) AT=330.025n

.meas tran vdout1_432ck650 FIND v(dout1_432) AT=330.025n

.meas tran vdout1_433ck650 FIND v(dout1_433) AT=330.025n

.meas tran vdout1_434ck650 FIND v(dout1_434) AT=330.025n

.meas tran vdout1_435ck650 FIND v(dout1_435) AT=330.025n

.meas tran vdout1_436ck650 FIND v(dout1_436) AT=330.025n

.meas tran vdout1_437ck650 FIND v(dout1_437) AT=330.025n

.meas tran vdout1_438ck650 FIND v(dout1_438) AT=330.025n

.meas tran vdout1_439ck650 FIND v(dout1_439) AT=330.025n

.meas tran vdout1_440ck650 FIND v(dout1_440) AT=330.025n

.meas tran vdout1_441ck650 FIND v(dout1_441) AT=330.025n

.meas tran vdout1_442ck650 FIND v(dout1_442) AT=330.025n

.meas tran vdout1_443ck650 FIND v(dout1_443) AT=330.025n

.meas tran vdout1_444ck650 FIND v(dout1_444) AT=330.025n

.meas tran vdout1_445ck650 FIND v(dout1_445) AT=330.025n

.meas tran vdout1_446ck650 FIND v(dout1_446) AT=330.025n

.meas tran vdout1_447ck650 FIND v(dout1_447) AT=330.025n

.meas tran vdout1_448ck650 FIND v(dout1_448) AT=330.025n

.meas tran vdout1_449ck650 FIND v(dout1_449) AT=330.025n

.meas tran vdout1_450ck650 FIND v(dout1_450) AT=330.025n

.meas tran vdout1_451ck650 FIND v(dout1_451) AT=330.025n

.meas tran vdout1_452ck650 FIND v(dout1_452) AT=330.025n

.meas tran vdout1_453ck650 FIND v(dout1_453) AT=330.025n

.meas tran vdout1_454ck650 FIND v(dout1_454) AT=330.025n

.meas tran vdout1_455ck650 FIND v(dout1_455) AT=330.025n

.meas tran vdout1_456ck650 FIND v(dout1_456) AT=330.025n

.meas tran vdout1_457ck650 FIND v(dout1_457) AT=330.025n

.meas tran vdout1_458ck650 FIND v(dout1_458) AT=330.025n

.meas tran vdout1_459ck650 FIND v(dout1_459) AT=330.025n

.meas tran vdout1_460ck650 FIND v(dout1_460) AT=330.025n

.meas tran vdout1_461ck650 FIND v(dout1_461) AT=330.025n

.meas tran vdout1_462ck650 FIND v(dout1_462) AT=330.025n

.meas tran vdout1_463ck650 FIND v(dout1_463) AT=330.025n

.meas tran vdout1_464ck650 FIND v(dout1_464) AT=330.025n

.meas tran vdout1_465ck650 FIND v(dout1_465) AT=330.025n

.meas tran vdout1_466ck650 FIND v(dout1_466) AT=330.025n

.meas tran vdout1_467ck650 FIND v(dout1_467) AT=330.025n

.meas tran vdout1_468ck650 FIND v(dout1_468) AT=330.025n

.meas tran vdout1_469ck650 FIND v(dout1_469) AT=330.025n

.meas tran vdout1_470ck650 FIND v(dout1_470) AT=330.025n

.meas tran vdout1_471ck650 FIND v(dout1_471) AT=330.025n

.meas tran vdout1_472ck650 FIND v(dout1_472) AT=330.025n

.meas tran vdout1_473ck650 FIND v(dout1_473) AT=330.025n

.meas tran vdout1_474ck650 FIND v(dout1_474) AT=330.025n

.meas tran vdout1_475ck650 FIND v(dout1_475) AT=330.025n

.meas tran vdout1_476ck650 FIND v(dout1_476) AT=330.025n

.meas tran vdout1_477ck650 FIND v(dout1_477) AT=330.025n

.meas tran vdout1_478ck650 FIND v(dout1_478) AT=330.025n

.meas tran vdout1_479ck650 FIND v(dout1_479) AT=330.025n

.meas tran vdout1_480ck650 FIND v(dout1_480) AT=330.025n

.meas tran vdout1_481ck650 FIND v(dout1_481) AT=330.025n

.meas tran vdout1_482ck650 FIND v(dout1_482) AT=330.025n

.meas tran vdout1_483ck650 FIND v(dout1_483) AT=330.025n

.meas tran vdout1_484ck650 FIND v(dout1_484) AT=330.025n

.meas tran vdout1_485ck650 FIND v(dout1_485) AT=330.025n

.meas tran vdout1_486ck650 FIND v(dout1_486) AT=330.025n

.meas tran vdout1_487ck650 FIND v(dout1_487) AT=330.025n

.meas tran vdout1_488ck650 FIND v(dout1_488) AT=330.025n

.meas tran vdout1_489ck650 FIND v(dout1_489) AT=330.025n

.meas tran vdout1_490ck650 FIND v(dout1_490) AT=330.025n

.meas tran vdout1_491ck650 FIND v(dout1_491) AT=330.025n

.meas tran vdout1_492ck650 FIND v(dout1_492) AT=330.025n

.meas tran vdout1_493ck650 FIND v(dout1_493) AT=330.025n

.meas tran vdout1_494ck650 FIND v(dout1_494) AT=330.025n

.meas tran vdout1_495ck650 FIND v(dout1_495) AT=330.025n

.meas tran vdout1_496ck650 FIND v(dout1_496) AT=330.025n

.meas tran vdout1_497ck650 FIND v(dout1_497) AT=330.025n

.meas tran vdout1_498ck650 FIND v(dout1_498) AT=330.025n

.meas tran vdout1_499ck650 FIND v(dout1_499) AT=330.025n

.meas tran vdout1_500ck650 FIND v(dout1_500) AT=330.025n

.meas tran vdout1_501ck650 FIND v(dout1_501) AT=330.025n

.meas tran vdout1_502ck650 FIND v(dout1_502) AT=330.025n

.meas tran vdout1_503ck650 FIND v(dout1_503) AT=330.025n

.meas tran vdout1_504ck650 FIND v(dout1_504) AT=330.025n

.meas tran vdout1_505ck650 FIND v(dout1_505) AT=330.025n

.meas tran vdout1_506ck650 FIND v(dout1_506) AT=330.025n

.meas tran vdout1_507ck650 FIND v(dout1_507) AT=330.025n

.meas tran vdout1_508ck650 FIND v(dout1_508) AT=330.025n

.meas tran vdout1_509ck650 FIND v(dout1_509) AT=330.025n

.meas tran vdout1_510ck650 FIND v(dout1_510) AT=330.025n

.meas tran vdout1_511ck650 FIND v(dout1_511) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_22ck660 FIND v(dout1_22) AT=335.025n

.meas tran vdout1_23ck660 FIND v(dout1_23) AT=335.025n

.meas tran vdout1_24ck660 FIND v(dout1_24) AT=335.025n

.meas tran vdout1_25ck660 FIND v(dout1_25) AT=335.025n

.meas tran vdout1_26ck660 FIND v(dout1_26) AT=335.025n

.meas tran vdout1_27ck660 FIND v(dout1_27) AT=335.025n

.meas tran vdout1_28ck660 FIND v(dout1_28) AT=335.025n

.meas tran vdout1_29ck660 FIND v(dout1_29) AT=335.025n

.meas tran vdout1_30ck660 FIND v(dout1_30) AT=335.025n

.meas tran vdout1_31ck660 FIND v(dout1_31) AT=335.025n

.meas tran vdout1_32ck660 FIND v(dout1_32) AT=335.025n

.meas tran vdout1_33ck660 FIND v(dout1_33) AT=335.025n

.meas tran vdout1_34ck660 FIND v(dout1_34) AT=335.025n

.meas tran vdout1_35ck660 FIND v(dout1_35) AT=335.025n

.meas tran vdout1_36ck660 FIND v(dout1_36) AT=335.025n

.meas tran vdout1_37ck660 FIND v(dout1_37) AT=335.025n

.meas tran vdout1_38ck660 FIND v(dout1_38) AT=335.025n

.meas tran vdout1_39ck660 FIND v(dout1_39) AT=335.025n

.meas tran vdout1_40ck660 FIND v(dout1_40) AT=335.025n

.meas tran vdout1_41ck660 FIND v(dout1_41) AT=335.025n

.meas tran vdout1_42ck660 FIND v(dout1_42) AT=335.025n

.meas tran vdout1_43ck660 FIND v(dout1_43) AT=335.025n

.meas tran vdout1_44ck660 FIND v(dout1_44) AT=335.025n

.meas tran vdout1_45ck660 FIND v(dout1_45) AT=335.025n

.meas tran vdout1_46ck660 FIND v(dout1_46) AT=335.025n

.meas tran vdout1_47ck660 FIND v(dout1_47) AT=335.025n

.meas tran vdout1_48ck660 FIND v(dout1_48) AT=335.025n

.meas tran vdout1_49ck660 FIND v(dout1_49) AT=335.025n

.meas tran vdout1_50ck660 FIND v(dout1_50) AT=335.025n

.meas tran vdout1_51ck660 FIND v(dout1_51) AT=335.025n

.meas tran vdout1_52ck660 FIND v(dout1_52) AT=335.025n

.meas tran vdout1_53ck660 FIND v(dout1_53) AT=335.025n

.meas tran vdout1_54ck660 FIND v(dout1_54) AT=335.025n

.meas tran vdout1_55ck660 FIND v(dout1_55) AT=335.025n

.meas tran vdout1_56ck660 FIND v(dout1_56) AT=335.025n

.meas tran vdout1_57ck660 FIND v(dout1_57) AT=335.025n

.meas tran vdout1_58ck660 FIND v(dout1_58) AT=335.025n

.meas tran vdout1_59ck660 FIND v(dout1_59) AT=335.025n

.meas tran vdout1_60ck660 FIND v(dout1_60) AT=335.025n

.meas tran vdout1_61ck660 FIND v(dout1_61) AT=335.025n

.meas tran vdout1_62ck660 FIND v(dout1_62) AT=335.025n

.meas tran vdout1_63ck660 FIND v(dout1_63) AT=335.025n

.meas tran vdout1_64ck660 FIND v(dout1_64) AT=335.025n

.meas tran vdout1_65ck660 FIND v(dout1_65) AT=335.025n

.meas tran vdout1_66ck660 FIND v(dout1_66) AT=335.025n

.meas tran vdout1_67ck660 FIND v(dout1_67) AT=335.025n

.meas tran vdout1_68ck660 FIND v(dout1_68) AT=335.025n

.meas tran vdout1_69ck660 FIND v(dout1_69) AT=335.025n

.meas tran vdout1_70ck660 FIND v(dout1_70) AT=335.025n

.meas tran vdout1_71ck660 FIND v(dout1_71) AT=335.025n

.meas tran vdout1_72ck660 FIND v(dout1_72) AT=335.025n

.meas tran vdout1_73ck660 FIND v(dout1_73) AT=335.025n

.meas tran vdout1_74ck660 FIND v(dout1_74) AT=335.025n

.meas tran vdout1_75ck660 FIND v(dout1_75) AT=335.025n

.meas tran vdout1_76ck660 FIND v(dout1_76) AT=335.025n

.meas tran vdout1_77ck660 FIND v(dout1_77) AT=335.025n

.meas tran vdout1_78ck660 FIND v(dout1_78) AT=335.025n

.meas tran vdout1_79ck660 FIND v(dout1_79) AT=335.025n

.meas tran vdout1_80ck660 FIND v(dout1_80) AT=335.025n

.meas tran vdout1_81ck660 FIND v(dout1_81) AT=335.025n

.meas tran vdout1_82ck660 FIND v(dout1_82) AT=335.025n

.meas tran vdout1_83ck660 FIND v(dout1_83) AT=335.025n

.meas tran vdout1_84ck660 FIND v(dout1_84) AT=335.025n

.meas tran vdout1_85ck660 FIND v(dout1_85) AT=335.025n

.meas tran vdout1_86ck660 FIND v(dout1_86) AT=335.025n

.meas tran vdout1_87ck660 FIND v(dout1_87) AT=335.025n

.meas tran vdout1_88ck660 FIND v(dout1_88) AT=335.025n

.meas tran vdout1_89ck660 FIND v(dout1_89) AT=335.025n

.meas tran vdout1_90ck660 FIND v(dout1_90) AT=335.025n

.meas tran vdout1_91ck660 FIND v(dout1_91) AT=335.025n

.meas tran vdout1_92ck660 FIND v(dout1_92) AT=335.025n

.meas tran vdout1_93ck660 FIND v(dout1_93) AT=335.025n

.meas tran vdout1_94ck660 FIND v(dout1_94) AT=335.025n

.meas tran vdout1_95ck660 FIND v(dout1_95) AT=335.025n

.meas tran vdout1_96ck660 FIND v(dout1_96) AT=335.025n

.meas tran vdout1_97ck660 FIND v(dout1_97) AT=335.025n

.meas tran vdout1_98ck660 FIND v(dout1_98) AT=335.025n

.meas tran vdout1_99ck660 FIND v(dout1_99) AT=335.025n

.meas tran vdout1_100ck660 FIND v(dout1_100) AT=335.025n

.meas tran vdout1_101ck660 FIND v(dout1_101) AT=335.025n

.meas tran vdout1_102ck660 FIND v(dout1_102) AT=335.025n

.meas tran vdout1_103ck660 FIND v(dout1_103) AT=335.025n

.meas tran vdout1_104ck660 FIND v(dout1_104) AT=335.025n

.meas tran vdout1_105ck660 FIND v(dout1_105) AT=335.025n

.meas tran vdout1_106ck660 FIND v(dout1_106) AT=335.025n

.meas tran vdout1_107ck660 FIND v(dout1_107) AT=335.025n

.meas tran vdout1_108ck660 FIND v(dout1_108) AT=335.025n

.meas tran vdout1_109ck660 FIND v(dout1_109) AT=335.025n

.meas tran vdout1_110ck660 FIND v(dout1_110) AT=335.025n

.meas tran vdout1_111ck660 FIND v(dout1_111) AT=335.025n

.meas tran vdout1_112ck660 FIND v(dout1_112) AT=335.025n

.meas tran vdout1_113ck660 FIND v(dout1_113) AT=335.025n

.meas tran vdout1_114ck660 FIND v(dout1_114) AT=335.025n

.meas tran vdout1_115ck660 FIND v(dout1_115) AT=335.025n

.meas tran vdout1_116ck660 FIND v(dout1_116) AT=335.025n

.meas tran vdout1_117ck660 FIND v(dout1_117) AT=335.025n

.meas tran vdout1_118ck660 FIND v(dout1_118) AT=335.025n

.meas tran vdout1_119ck660 FIND v(dout1_119) AT=335.025n

.meas tran vdout1_120ck660 FIND v(dout1_120) AT=335.025n

.meas tran vdout1_121ck660 FIND v(dout1_121) AT=335.025n

.meas tran vdout1_122ck660 FIND v(dout1_122) AT=335.025n

.meas tran vdout1_123ck660 FIND v(dout1_123) AT=335.025n

.meas tran vdout1_124ck660 FIND v(dout1_124) AT=335.025n

.meas tran vdout1_125ck660 FIND v(dout1_125) AT=335.025n

.meas tran vdout1_126ck660 FIND v(dout1_126) AT=335.025n

.meas tran vdout1_127ck660 FIND v(dout1_127) AT=335.025n

.meas tran vdout1_128ck660 FIND v(dout1_128) AT=335.025n

.meas tran vdout1_129ck660 FIND v(dout1_129) AT=335.025n

.meas tran vdout1_130ck660 FIND v(dout1_130) AT=335.025n

.meas tran vdout1_131ck660 FIND v(dout1_131) AT=335.025n

.meas tran vdout1_132ck660 FIND v(dout1_132) AT=335.025n

.meas tran vdout1_133ck660 FIND v(dout1_133) AT=335.025n

.meas tran vdout1_134ck660 FIND v(dout1_134) AT=335.025n

.meas tran vdout1_135ck660 FIND v(dout1_135) AT=335.025n

.meas tran vdout1_136ck660 FIND v(dout1_136) AT=335.025n

.meas tran vdout1_137ck660 FIND v(dout1_137) AT=335.025n

.meas tran vdout1_138ck660 FIND v(dout1_138) AT=335.025n

.meas tran vdout1_139ck660 FIND v(dout1_139) AT=335.025n

.meas tran vdout1_140ck660 FIND v(dout1_140) AT=335.025n

.meas tran vdout1_141ck660 FIND v(dout1_141) AT=335.025n

.meas tran vdout1_142ck660 FIND v(dout1_142) AT=335.025n

.meas tran vdout1_143ck660 FIND v(dout1_143) AT=335.025n

.meas tran vdout1_144ck660 FIND v(dout1_144) AT=335.025n

.meas tran vdout1_145ck660 FIND v(dout1_145) AT=335.025n

.meas tran vdout1_146ck660 FIND v(dout1_146) AT=335.025n

.meas tran vdout1_147ck660 FIND v(dout1_147) AT=335.025n

.meas tran vdout1_148ck660 FIND v(dout1_148) AT=335.025n

.meas tran vdout1_149ck660 FIND v(dout1_149) AT=335.025n

.meas tran vdout1_150ck660 FIND v(dout1_150) AT=335.025n

.meas tran vdout1_151ck660 FIND v(dout1_151) AT=335.025n

.meas tran vdout1_152ck660 FIND v(dout1_152) AT=335.025n

.meas tran vdout1_153ck660 FIND v(dout1_153) AT=335.025n

.meas tran vdout1_154ck660 FIND v(dout1_154) AT=335.025n

.meas tran vdout1_155ck660 FIND v(dout1_155) AT=335.025n

.meas tran vdout1_156ck660 FIND v(dout1_156) AT=335.025n

.meas tran vdout1_157ck660 FIND v(dout1_157) AT=335.025n

.meas tran vdout1_158ck660 FIND v(dout1_158) AT=335.025n

.meas tran vdout1_159ck660 FIND v(dout1_159) AT=335.025n

.meas tran vdout1_160ck660 FIND v(dout1_160) AT=335.025n

.meas tran vdout1_161ck660 FIND v(dout1_161) AT=335.025n

.meas tran vdout1_162ck660 FIND v(dout1_162) AT=335.025n

.meas tran vdout1_163ck660 FIND v(dout1_163) AT=335.025n

.meas tran vdout1_164ck660 FIND v(dout1_164) AT=335.025n

.meas tran vdout1_165ck660 FIND v(dout1_165) AT=335.025n

.meas tran vdout1_166ck660 FIND v(dout1_166) AT=335.025n

.meas tran vdout1_167ck660 FIND v(dout1_167) AT=335.025n

.meas tran vdout1_168ck660 FIND v(dout1_168) AT=335.025n

.meas tran vdout1_169ck660 FIND v(dout1_169) AT=335.025n

.meas tran vdout1_170ck660 FIND v(dout1_170) AT=335.025n

.meas tran vdout1_171ck660 FIND v(dout1_171) AT=335.025n

.meas tran vdout1_172ck660 FIND v(dout1_172) AT=335.025n

.meas tran vdout1_173ck660 FIND v(dout1_173) AT=335.025n

.meas tran vdout1_174ck660 FIND v(dout1_174) AT=335.025n

.meas tran vdout1_175ck660 FIND v(dout1_175) AT=335.025n

.meas tran vdout1_176ck660 FIND v(dout1_176) AT=335.025n

.meas tran vdout1_177ck660 FIND v(dout1_177) AT=335.025n

.meas tran vdout1_178ck660 FIND v(dout1_178) AT=335.025n

.meas tran vdout1_179ck660 FIND v(dout1_179) AT=335.025n

.meas tran vdout1_180ck660 FIND v(dout1_180) AT=335.025n

.meas tran vdout1_181ck660 FIND v(dout1_181) AT=335.025n

.meas tran vdout1_182ck660 FIND v(dout1_182) AT=335.025n

.meas tran vdout1_183ck660 FIND v(dout1_183) AT=335.025n

.meas tran vdout1_184ck660 FIND v(dout1_184) AT=335.025n

.meas tran vdout1_185ck660 FIND v(dout1_185) AT=335.025n

.meas tran vdout1_186ck660 FIND v(dout1_186) AT=335.025n

.meas tran vdout1_187ck660 FIND v(dout1_187) AT=335.025n

.meas tran vdout1_188ck660 FIND v(dout1_188) AT=335.025n

.meas tran vdout1_189ck660 FIND v(dout1_189) AT=335.025n

.meas tran vdout1_190ck660 FIND v(dout1_190) AT=335.025n

.meas tran vdout1_191ck660 FIND v(dout1_191) AT=335.025n

.meas tran vdout1_192ck660 FIND v(dout1_192) AT=335.025n

.meas tran vdout1_193ck660 FIND v(dout1_193) AT=335.025n

.meas tran vdout1_194ck660 FIND v(dout1_194) AT=335.025n

.meas tran vdout1_195ck660 FIND v(dout1_195) AT=335.025n

.meas tran vdout1_196ck660 FIND v(dout1_196) AT=335.025n

.meas tran vdout1_197ck660 FIND v(dout1_197) AT=335.025n

.meas tran vdout1_198ck660 FIND v(dout1_198) AT=335.025n

.meas tran vdout1_199ck660 FIND v(dout1_199) AT=335.025n

.meas tran vdout1_200ck660 FIND v(dout1_200) AT=335.025n

.meas tran vdout1_201ck660 FIND v(dout1_201) AT=335.025n

.meas tran vdout1_202ck660 FIND v(dout1_202) AT=335.025n

.meas tran vdout1_203ck660 FIND v(dout1_203) AT=335.025n

.meas tran vdout1_204ck660 FIND v(dout1_204) AT=335.025n

.meas tran vdout1_205ck660 FIND v(dout1_205) AT=335.025n

.meas tran vdout1_206ck660 FIND v(dout1_206) AT=335.025n

.meas tran vdout1_207ck660 FIND v(dout1_207) AT=335.025n

.meas tran vdout1_208ck660 FIND v(dout1_208) AT=335.025n

.meas tran vdout1_209ck660 FIND v(dout1_209) AT=335.025n

.meas tran vdout1_210ck660 FIND v(dout1_210) AT=335.025n

.meas tran vdout1_211ck660 FIND v(dout1_211) AT=335.025n

.meas tran vdout1_212ck660 FIND v(dout1_212) AT=335.025n

.meas tran vdout1_213ck660 FIND v(dout1_213) AT=335.025n

.meas tran vdout1_214ck660 FIND v(dout1_214) AT=335.025n

.meas tran vdout1_215ck660 FIND v(dout1_215) AT=335.025n

.meas tran vdout1_216ck660 FIND v(dout1_216) AT=335.025n

.meas tran vdout1_217ck660 FIND v(dout1_217) AT=335.025n

.meas tran vdout1_218ck660 FIND v(dout1_218) AT=335.025n

.meas tran vdout1_219ck660 FIND v(dout1_219) AT=335.025n

.meas tran vdout1_220ck660 FIND v(dout1_220) AT=335.025n

.meas tran vdout1_221ck660 FIND v(dout1_221) AT=335.025n

.meas tran vdout1_222ck660 FIND v(dout1_222) AT=335.025n

.meas tran vdout1_223ck660 FIND v(dout1_223) AT=335.025n

.meas tran vdout1_224ck660 FIND v(dout1_224) AT=335.025n

.meas tran vdout1_225ck660 FIND v(dout1_225) AT=335.025n

.meas tran vdout1_226ck660 FIND v(dout1_226) AT=335.025n

.meas tran vdout1_227ck660 FIND v(dout1_227) AT=335.025n

.meas tran vdout1_228ck660 FIND v(dout1_228) AT=335.025n

.meas tran vdout1_229ck660 FIND v(dout1_229) AT=335.025n

.meas tran vdout1_230ck660 FIND v(dout1_230) AT=335.025n

.meas tran vdout1_231ck660 FIND v(dout1_231) AT=335.025n

.meas tran vdout1_232ck660 FIND v(dout1_232) AT=335.025n

.meas tran vdout1_233ck660 FIND v(dout1_233) AT=335.025n

.meas tran vdout1_234ck660 FIND v(dout1_234) AT=335.025n

.meas tran vdout1_235ck660 FIND v(dout1_235) AT=335.025n

.meas tran vdout1_236ck660 FIND v(dout1_236) AT=335.025n

.meas tran vdout1_237ck660 FIND v(dout1_237) AT=335.025n

.meas tran vdout1_238ck660 FIND v(dout1_238) AT=335.025n

.meas tran vdout1_239ck660 FIND v(dout1_239) AT=335.025n

.meas tran vdout1_240ck660 FIND v(dout1_240) AT=335.025n

.meas tran vdout1_241ck660 FIND v(dout1_241) AT=335.025n

.meas tran vdout1_242ck660 FIND v(dout1_242) AT=335.025n

.meas tran vdout1_243ck660 FIND v(dout1_243) AT=335.025n

.meas tran vdout1_244ck660 FIND v(dout1_244) AT=335.025n

.meas tran vdout1_245ck660 FIND v(dout1_245) AT=335.025n

.meas tran vdout1_246ck660 FIND v(dout1_246) AT=335.025n

.meas tran vdout1_247ck660 FIND v(dout1_247) AT=335.025n

.meas tran vdout1_248ck660 FIND v(dout1_248) AT=335.025n

.meas tran vdout1_249ck660 FIND v(dout1_249) AT=335.025n

.meas tran vdout1_250ck660 FIND v(dout1_250) AT=335.025n

.meas tran vdout1_251ck660 FIND v(dout1_251) AT=335.025n

.meas tran vdout1_252ck660 FIND v(dout1_252) AT=335.025n

.meas tran vdout1_253ck660 FIND v(dout1_253) AT=335.025n

.meas tran vdout1_254ck660 FIND v(dout1_254) AT=335.025n

.meas tran vdout1_255ck660 FIND v(dout1_255) AT=335.025n

.meas tran vdout1_256ck660 FIND v(dout1_256) AT=335.025n

.meas tran vdout1_257ck660 FIND v(dout1_257) AT=335.025n

.meas tran vdout1_258ck660 FIND v(dout1_258) AT=335.025n

.meas tran vdout1_259ck660 FIND v(dout1_259) AT=335.025n

.meas tran vdout1_260ck660 FIND v(dout1_260) AT=335.025n

.meas tran vdout1_261ck660 FIND v(dout1_261) AT=335.025n

.meas tran vdout1_262ck660 FIND v(dout1_262) AT=335.025n

.meas tran vdout1_263ck660 FIND v(dout1_263) AT=335.025n

.meas tran vdout1_264ck660 FIND v(dout1_264) AT=335.025n

.meas tran vdout1_265ck660 FIND v(dout1_265) AT=335.025n

.meas tran vdout1_266ck660 FIND v(dout1_266) AT=335.025n

.meas tran vdout1_267ck660 FIND v(dout1_267) AT=335.025n

.meas tran vdout1_268ck660 FIND v(dout1_268) AT=335.025n

.meas tran vdout1_269ck660 FIND v(dout1_269) AT=335.025n

.meas tran vdout1_270ck660 FIND v(dout1_270) AT=335.025n

.meas tran vdout1_271ck660 FIND v(dout1_271) AT=335.025n

.meas tran vdout1_272ck660 FIND v(dout1_272) AT=335.025n

.meas tran vdout1_273ck660 FIND v(dout1_273) AT=335.025n

.meas tran vdout1_274ck660 FIND v(dout1_274) AT=335.025n

.meas tran vdout1_275ck660 FIND v(dout1_275) AT=335.025n

.meas tran vdout1_276ck660 FIND v(dout1_276) AT=335.025n

.meas tran vdout1_277ck660 FIND v(dout1_277) AT=335.025n

.meas tran vdout1_278ck660 FIND v(dout1_278) AT=335.025n

.meas tran vdout1_279ck660 FIND v(dout1_279) AT=335.025n

.meas tran vdout1_280ck660 FIND v(dout1_280) AT=335.025n

.meas tran vdout1_281ck660 FIND v(dout1_281) AT=335.025n

.meas tran vdout1_282ck660 FIND v(dout1_282) AT=335.025n

.meas tran vdout1_283ck660 FIND v(dout1_283) AT=335.025n

.meas tran vdout1_284ck660 FIND v(dout1_284) AT=335.025n

.meas tran vdout1_285ck660 FIND v(dout1_285) AT=335.025n

.meas tran vdout1_286ck660 FIND v(dout1_286) AT=335.025n

.meas tran vdout1_287ck660 FIND v(dout1_287) AT=335.025n

.meas tran vdout1_288ck660 FIND v(dout1_288) AT=335.025n

.meas tran vdout1_289ck660 FIND v(dout1_289) AT=335.025n

.meas tran vdout1_290ck660 FIND v(dout1_290) AT=335.025n

.meas tran vdout1_291ck660 FIND v(dout1_291) AT=335.025n

.meas tran vdout1_292ck660 FIND v(dout1_292) AT=335.025n

.meas tran vdout1_293ck660 FIND v(dout1_293) AT=335.025n

.meas tran vdout1_294ck660 FIND v(dout1_294) AT=335.025n

.meas tran vdout1_295ck660 FIND v(dout1_295) AT=335.025n

.meas tran vdout1_296ck660 FIND v(dout1_296) AT=335.025n

.meas tran vdout1_297ck660 FIND v(dout1_297) AT=335.025n

.meas tran vdout1_298ck660 FIND v(dout1_298) AT=335.025n

.meas tran vdout1_299ck660 FIND v(dout1_299) AT=335.025n

.meas tran vdout1_300ck660 FIND v(dout1_300) AT=335.025n

.meas tran vdout1_301ck660 FIND v(dout1_301) AT=335.025n

.meas tran vdout1_302ck660 FIND v(dout1_302) AT=335.025n

.meas tran vdout1_303ck660 FIND v(dout1_303) AT=335.025n

.meas tran vdout1_304ck660 FIND v(dout1_304) AT=335.025n

.meas tran vdout1_305ck660 FIND v(dout1_305) AT=335.025n

.meas tran vdout1_306ck660 FIND v(dout1_306) AT=335.025n

.meas tran vdout1_307ck660 FIND v(dout1_307) AT=335.025n

.meas tran vdout1_308ck660 FIND v(dout1_308) AT=335.025n

.meas tran vdout1_309ck660 FIND v(dout1_309) AT=335.025n

.meas tran vdout1_310ck660 FIND v(dout1_310) AT=335.025n

.meas tran vdout1_311ck660 FIND v(dout1_311) AT=335.025n

.meas tran vdout1_312ck660 FIND v(dout1_312) AT=335.025n

.meas tran vdout1_313ck660 FIND v(dout1_313) AT=335.025n

.meas tran vdout1_314ck660 FIND v(dout1_314) AT=335.025n

.meas tran vdout1_315ck660 FIND v(dout1_315) AT=335.025n

.meas tran vdout1_316ck660 FIND v(dout1_316) AT=335.025n

.meas tran vdout1_317ck660 FIND v(dout1_317) AT=335.025n

.meas tran vdout1_318ck660 FIND v(dout1_318) AT=335.025n

.meas tran vdout1_319ck660 FIND v(dout1_319) AT=335.025n

.meas tran vdout1_320ck660 FIND v(dout1_320) AT=335.025n

.meas tran vdout1_321ck660 FIND v(dout1_321) AT=335.025n

.meas tran vdout1_322ck660 FIND v(dout1_322) AT=335.025n

.meas tran vdout1_323ck660 FIND v(dout1_323) AT=335.025n

.meas tran vdout1_324ck660 FIND v(dout1_324) AT=335.025n

.meas tran vdout1_325ck660 FIND v(dout1_325) AT=335.025n

.meas tran vdout1_326ck660 FIND v(dout1_326) AT=335.025n

.meas tran vdout1_327ck660 FIND v(dout1_327) AT=335.025n

.meas tran vdout1_328ck660 FIND v(dout1_328) AT=335.025n

.meas tran vdout1_329ck660 FIND v(dout1_329) AT=335.025n

.meas tran vdout1_330ck660 FIND v(dout1_330) AT=335.025n

.meas tran vdout1_331ck660 FIND v(dout1_331) AT=335.025n

.meas tran vdout1_332ck660 FIND v(dout1_332) AT=335.025n

.meas tran vdout1_333ck660 FIND v(dout1_333) AT=335.025n

.meas tran vdout1_334ck660 FIND v(dout1_334) AT=335.025n

.meas tran vdout1_335ck660 FIND v(dout1_335) AT=335.025n

.meas tran vdout1_336ck660 FIND v(dout1_336) AT=335.025n

.meas tran vdout1_337ck660 FIND v(dout1_337) AT=335.025n

.meas tran vdout1_338ck660 FIND v(dout1_338) AT=335.025n

.meas tran vdout1_339ck660 FIND v(dout1_339) AT=335.025n

.meas tran vdout1_340ck660 FIND v(dout1_340) AT=335.025n

.meas tran vdout1_341ck660 FIND v(dout1_341) AT=335.025n

.meas tran vdout1_342ck660 FIND v(dout1_342) AT=335.025n

.meas tran vdout1_343ck660 FIND v(dout1_343) AT=335.025n

.meas tran vdout1_344ck660 FIND v(dout1_344) AT=335.025n

.meas tran vdout1_345ck660 FIND v(dout1_345) AT=335.025n

.meas tran vdout1_346ck660 FIND v(dout1_346) AT=335.025n

.meas tran vdout1_347ck660 FIND v(dout1_347) AT=335.025n

.meas tran vdout1_348ck660 FIND v(dout1_348) AT=335.025n

.meas tran vdout1_349ck660 FIND v(dout1_349) AT=335.025n

.meas tran vdout1_350ck660 FIND v(dout1_350) AT=335.025n

.meas tran vdout1_351ck660 FIND v(dout1_351) AT=335.025n

.meas tran vdout1_352ck660 FIND v(dout1_352) AT=335.025n

.meas tran vdout1_353ck660 FIND v(dout1_353) AT=335.025n

.meas tran vdout1_354ck660 FIND v(dout1_354) AT=335.025n

.meas tran vdout1_355ck660 FIND v(dout1_355) AT=335.025n

.meas tran vdout1_356ck660 FIND v(dout1_356) AT=335.025n

.meas tran vdout1_357ck660 FIND v(dout1_357) AT=335.025n

.meas tran vdout1_358ck660 FIND v(dout1_358) AT=335.025n

.meas tran vdout1_359ck660 FIND v(dout1_359) AT=335.025n

.meas tran vdout1_360ck660 FIND v(dout1_360) AT=335.025n

.meas tran vdout1_361ck660 FIND v(dout1_361) AT=335.025n

.meas tran vdout1_362ck660 FIND v(dout1_362) AT=335.025n

.meas tran vdout1_363ck660 FIND v(dout1_363) AT=335.025n

.meas tran vdout1_364ck660 FIND v(dout1_364) AT=335.025n

.meas tran vdout1_365ck660 FIND v(dout1_365) AT=335.025n

.meas tran vdout1_366ck660 FIND v(dout1_366) AT=335.025n

.meas tran vdout1_367ck660 FIND v(dout1_367) AT=335.025n

.meas tran vdout1_368ck660 FIND v(dout1_368) AT=335.025n

.meas tran vdout1_369ck660 FIND v(dout1_369) AT=335.025n

.meas tran vdout1_370ck660 FIND v(dout1_370) AT=335.025n

.meas tran vdout1_371ck660 FIND v(dout1_371) AT=335.025n

.meas tran vdout1_372ck660 FIND v(dout1_372) AT=335.025n

.meas tran vdout1_373ck660 FIND v(dout1_373) AT=335.025n

.meas tran vdout1_374ck660 FIND v(dout1_374) AT=335.025n

.meas tran vdout1_375ck660 FIND v(dout1_375) AT=335.025n

.meas tran vdout1_376ck660 FIND v(dout1_376) AT=335.025n

.meas tran vdout1_377ck660 FIND v(dout1_377) AT=335.025n

.meas tran vdout1_378ck660 FIND v(dout1_378) AT=335.025n

.meas tran vdout1_379ck660 FIND v(dout1_379) AT=335.025n

.meas tran vdout1_380ck660 FIND v(dout1_380) AT=335.025n

.meas tran vdout1_381ck660 FIND v(dout1_381) AT=335.025n

.meas tran vdout1_382ck660 FIND v(dout1_382) AT=335.025n

.meas tran vdout1_383ck660 FIND v(dout1_383) AT=335.025n

.meas tran vdout1_384ck660 FIND v(dout1_384) AT=335.025n

.meas tran vdout1_385ck660 FIND v(dout1_385) AT=335.025n

.meas tran vdout1_386ck660 FIND v(dout1_386) AT=335.025n

.meas tran vdout1_387ck660 FIND v(dout1_387) AT=335.025n

.meas tran vdout1_388ck660 FIND v(dout1_388) AT=335.025n

.meas tran vdout1_389ck660 FIND v(dout1_389) AT=335.025n

.meas tran vdout1_390ck660 FIND v(dout1_390) AT=335.025n

.meas tran vdout1_391ck660 FIND v(dout1_391) AT=335.025n

.meas tran vdout1_392ck660 FIND v(dout1_392) AT=335.025n

.meas tran vdout1_393ck660 FIND v(dout1_393) AT=335.025n

.meas tran vdout1_394ck660 FIND v(dout1_394) AT=335.025n

.meas tran vdout1_395ck660 FIND v(dout1_395) AT=335.025n

.meas tran vdout1_396ck660 FIND v(dout1_396) AT=335.025n

.meas tran vdout1_397ck660 FIND v(dout1_397) AT=335.025n

.meas tran vdout1_398ck660 FIND v(dout1_398) AT=335.025n

.meas tran vdout1_399ck660 FIND v(dout1_399) AT=335.025n

.meas tran vdout1_400ck660 FIND v(dout1_400) AT=335.025n

.meas tran vdout1_401ck660 FIND v(dout1_401) AT=335.025n

.meas tran vdout1_402ck660 FIND v(dout1_402) AT=335.025n

.meas tran vdout1_403ck660 FIND v(dout1_403) AT=335.025n

.meas tran vdout1_404ck660 FIND v(dout1_404) AT=335.025n

.meas tran vdout1_405ck660 FIND v(dout1_405) AT=335.025n

.meas tran vdout1_406ck660 FIND v(dout1_406) AT=335.025n

.meas tran vdout1_407ck660 FIND v(dout1_407) AT=335.025n

.meas tran vdout1_408ck660 FIND v(dout1_408) AT=335.025n

.meas tran vdout1_409ck660 FIND v(dout1_409) AT=335.025n

.meas tran vdout1_410ck660 FIND v(dout1_410) AT=335.025n

.meas tran vdout1_411ck660 FIND v(dout1_411) AT=335.025n

.meas tran vdout1_412ck660 FIND v(dout1_412) AT=335.025n

.meas tran vdout1_413ck660 FIND v(dout1_413) AT=335.025n

.meas tran vdout1_414ck660 FIND v(dout1_414) AT=335.025n

.meas tran vdout1_415ck660 FIND v(dout1_415) AT=335.025n

.meas tran vdout1_416ck660 FIND v(dout1_416) AT=335.025n

.meas tran vdout1_417ck660 FIND v(dout1_417) AT=335.025n

.meas tran vdout1_418ck660 FIND v(dout1_418) AT=335.025n

.meas tran vdout1_419ck660 FIND v(dout1_419) AT=335.025n

.meas tran vdout1_420ck660 FIND v(dout1_420) AT=335.025n

.meas tran vdout1_421ck660 FIND v(dout1_421) AT=335.025n

.meas tran vdout1_422ck660 FIND v(dout1_422) AT=335.025n

.meas tran vdout1_423ck660 FIND v(dout1_423) AT=335.025n

.meas tran vdout1_424ck660 FIND v(dout1_424) AT=335.025n

.meas tran vdout1_425ck660 FIND v(dout1_425) AT=335.025n

.meas tran vdout1_426ck660 FIND v(dout1_426) AT=335.025n

.meas tran vdout1_427ck660 FIND v(dout1_427) AT=335.025n

.meas tran vdout1_428ck660 FIND v(dout1_428) AT=335.025n

.meas tran vdout1_429ck660 FIND v(dout1_429) AT=335.025n

.meas tran vdout1_430ck660 FIND v(dout1_430) AT=335.025n

.meas tran vdout1_431ck660 FIND v(dout1_431) AT=335.025n

.meas tran vdout1_432ck660 FIND v(dout1_432) AT=335.025n

.meas tran vdout1_433ck660 FIND v(dout1_433) AT=335.025n

.meas tran vdout1_434ck660 FIND v(dout1_434) AT=335.025n

.meas tran vdout1_435ck660 FIND v(dout1_435) AT=335.025n

.meas tran vdout1_436ck660 FIND v(dout1_436) AT=335.025n

.meas tran vdout1_437ck660 FIND v(dout1_437) AT=335.025n

.meas tran vdout1_438ck660 FIND v(dout1_438) AT=335.025n

.meas tran vdout1_439ck660 FIND v(dout1_439) AT=335.025n

.meas tran vdout1_440ck660 FIND v(dout1_440) AT=335.025n

.meas tran vdout1_441ck660 FIND v(dout1_441) AT=335.025n

.meas tran vdout1_442ck660 FIND v(dout1_442) AT=335.025n

.meas tran vdout1_443ck660 FIND v(dout1_443) AT=335.025n

.meas tran vdout1_444ck660 FIND v(dout1_444) AT=335.025n

.meas tran vdout1_445ck660 FIND v(dout1_445) AT=335.025n

.meas tran vdout1_446ck660 FIND v(dout1_446) AT=335.025n

.meas tran vdout1_447ck660 FIND v(dout1_447) AT=335.025n

.meas tran vdout1_448ck660 FIND v(dout1_448) AT=335.025n

.meas tran vdout1_449ck660 FIND v(dout1_449) AT=335.025n

.meas tran vdout1_450ck660 FIND v(dout1_450) AT=335.025n

.meas tran vdout1_451ck660 FIND v(dout1_451) AT=335.025n

.meas tran vdout1_452ck660 FIND v(dout1_452) AT=335.025n

.meas tran vdout1_453ck660 FIND v(dout1_453) AT=335.025n

.meas tran vdout1_454ck660 FIND v(dout1_454) AT=335.025n

.meas tran vdout1_455ck660 FIND v(dout1_455) AT=335.025n

.meas tran vdout1_456ck660 FIND v(dout1_456) AT=335.025n

.meas tran vdout1_457ck660 FIND v(dout1_457) AT=335.025n

.meas tran vdout1_458ck660 FIND v(dout1_458) AT=335.025n

.meas tran vdout1_459ck660 FIND v(dout1_459) AT=335.025n

.meas tran vdout1_460ck660 FIND v(dout1_460) AT=335.025n

.meas tran vdout1_461ck660 FIND v(dout1_461) AT=335.025n

.meas tran vdout1_462ck660 FIND v(dout1_462) AT=335.025n

.meas tran vdout1_463ck660 FIND v(dout1_463) AT=335.025n

.meas tran vdout1_464ck660 FIND v(dout1_464) AT=335.025n

.meas tran vdout1_465ck660 FIND v(dout1_465) AT=335.025n

.meas tran vdout1_466ck660 FIND v(dout1_466) AT=335.025n

.meas tran vdout1_467ck660 FIND v(dout1_467) AT=335.025n

.meas tran vdout1_468ck660 FIND v(dout1_468) AT=335.025n

.meas tran vdout1_469ck660 FIND v(dout1_469) AT=335.025n

.meas tran vdout1_470ck660 FIND v(dout1_470) AT=335.025n

.meas tran vdout1_471ck660 FIND v(dout1_471) AT=335.025n

.meas tran vdout1_472ck660 FIND v(dout1_472) AT=335.025n

.meas tran vdout1_473ck660 FIND v(dout1_473) AT=335.025n

.meas tran vdout1_474ck660 FIND v(dout1_474) AT=335.025n

.meas tran vdout1_475ck660 FIND v(dout1_475) AT=335.025n

.meas tran vdout1_476ck660 FIND v(dout1_476) AT=335.025n

.meas tran vdout1_477ck660 FIND v(dout1_477) AT=335.025n

.meas tran vdout1_478ck660 FIND v(dout1_478) AT=335.025n

.meas tran vdout1_479ck660 FIND v(dout1_479) AT=335.025n

.meas tran vdout1_480ck660 FIND v(dout1_480) AT=335.025n

.meas tran vdout1_481ck660 FIND v(dout1_481) AT=335.025n

.meas tran vdout1_482ck660 FIND v(dout1_482) AT=335.025n

.meas tran vdout1_483ck660 FIND v(dout1_483) AT=335.025n

.meas tran vdout1_484ck660 FIND v(dout1_484) AT=335.025n

.meas tran vdout1_485ck660 FIND v(dout1_485) AT=335.025n

.meas tran vdout1_486ck660 FIND v(dout1_486) AT=335.025n

.meas tran vdout1_487ck660 FIND v(dout1_487) AT=335.025n

.meas tran vdout1_488ck660 FIND v(dout1_488) AT=335.025n

.meas tran vdout1_489ck660 FIND v(dout1_489) AT=335.025n

.meas tran vdout1_490ck660 FIND v(dout1_490) AT=335.025n

.meas tran vdout1_491ck660 FIND v(dout1_491) AT=335.025n

.meas tran vdout1_492ck660 FIND v(dout1_492) AT=335.025n

.meas tran vdout1_493ck660 FIND v(dout1_493) AT=335.025n

.meas tran vdout1_494ck660 FIND v(dout1_494) AT=335.025n

.meas tran vdout1_495ck660 FIND v(dout1_495) AT=335.025n

.meas tran vdout1_496ck660 FIND v(dout1_496) AT=335.025n

.meas tran vdout1_497ck660 FIND v(dout1_497) AT=335.025n

.meas tran vdout1_498ck660 FIND v(dout1_498) AT=335.025n

.meas tran vdout1_499ck660 FIND v(dout1_499) AT=335.025n

.meas tran vdout1_500ck660 FIND v(dout1_500) AT=335.025n

.meas tran vdout1_501ck660 FIND v(dout1_501) AT=335.025n

.meas tran vdout1_502ck660 FIND v(dout1_502) AT=335.025n

.meas tran vdout1_503ck660 FIND v(dout1_503) AT=335.025n

.meas tran vdout1_504ck660 FIND v(dout1_504) AT=335.025n

.meas tran vdout1_505ck660 FIND v(dout1_505) AT=335.025n

.meas tran vdout1_506ck660 FIND v(dout1_506) AT=335.025n

.meas tran vdout1_507ck660 FIND v(dout1_507) AT=335.025n

.meas tran vdout1_508ck660 FIND v(dout1_508) AT=335.025n

.meas tran vdout1_509ck660 FIND v(dout1_509) AT=335.025n

.meas tran vdout1_510ck660 FIND v(dout1_510) AT=335.025n

.meas tran vdout1_511ck660 FIND v(dout1_511) AT=335.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_19ck670 FIND v(dout1_19) AT=340.025n

.meas tran vdout1_20ck670 FIND v(dout1_20) AT=340.025n

.meas tran vdout1_21ck670 FIND v(dout1_21) AT=340.025n

.meas tran vdout1_22ck670 FIND v(dout1_22) AT=340.025n

.meas tran vdout1_23ck670 FIND v(dout1_23) AT=340.025n

.meas tran vdout1_24ck670 FIND v(dout1_24) AT=340.025n

.meas tran vdout1_25ck670 FIND v(dout1_25) AT=340.025n

.meas tran vdout1_26ck670 FIND v(dout1_26) AT=340.025n

.meas tran vdout1_27ck670 FIND v(dout1_27) AT=340.025n

.meas tran vdout1_28ck670 FIND v(dout1_28) AT=340.025n

.meas tran vdout1_29ck670 FIND v(dout1_29) AT=340.025n

.meas tran vdout1_30ck670 FIND v(dout1_30) AT=340.025n

.meas tran vdout1_31ck670 FIND v(dout1_31) AT=340.025n

.meas tran vdout1_32ck670 FIND v(dout1_32) AT=340.025n

.meas tran vdout1_33ck670 FIND v(dout1_33) AT=340.025n

.meas tran vdout1_34ck670 FIND v(dout1_34) AT=340.025n

.meas tran vdout1_35ck670 FIND v(dout1_35) AT=340.025n

.meas tran vdout1_36ck670 FIND v(dout1_36) AT=340.025n

.meas tran vdout1_37ck670 FIND v(dout1_37) AT=340.025n

.meas tran vdout1_38ck670 FIND v(dout1_38) AT=340.025n

.meas tran vdout1_39ck670 FIND v(dout1_39) AT=340.025n

.meas tran vdout1_40ck670 FIND v(dout1_40) AT=340.025n

.meas tran vdout1_41ck670 FIND v(dout1_41) AT=340.025n

.meas tran vdout1_42ck670 FIND v(dout1_42) AT=340.025n

.meas tran vdout1_43ck670 FIND v(dout1_43) AT=340.025n

.meas tran vdout1_44ck670 FIND v(dout1_44) AT=340.025n

.meas tran vdout1_45ck670 FIND v(dout1_45) AT=340.025n

.meas tran vdout1_46ck670 FIND v(dout1_46) AT=340.025n

.meas tran vdout1_47ck670 FIND v(dout1_47) AT=340.025n

.meas tran vdout1_48ck670 FIND v(dout1_48) AT=340.025n

.meas tran vdout1_49ck670 FIND v(dout1_49) AT=340.025n

.meas tran vdout1_50ck670 FIND v(dout1_50) AT=340.025n

.meas tran vdout1_51ck670 FIND v(dout1_51) AT=340.025n

.meas tran vdout1_52ck670 FIND v(dout1_52) AT=340.025n

.meas tran vdout1_53ck670 FIND v(dout1_53) AT=340.025n

.meas tran vdout1_54ck670 FIND v(dout1_54) AT=340.025n

.meas tran vdout1_55ck670 FIND v(dout1_55) AT=340.025n

.meas tran vdout1_56ck670 FIND v(dout1_56) AT=340.025n

.meas tran vdout1_57ck670 FIND v(dout1_57) AT=340.025n

.meas tran vdout1_58ck670 FIND v(dout1_58) AT=340.025n

.meas tran vdout1_59ck670 FIND v(dout1_59) AT=340.025n

.meas tran vdout1_60ck670 FIND v(dout1_60) AT=340.025n

.meas tran vdout1_61ck670 FIND v(dout1_61) AT=340.025n

.meas tran vdout1_62ck670 FIND v(dout1_62) AT=340.025n

.meas tran vdout1_63ck670 FIND v(dout1_63) AT=340.025n

.meas tran vdout1_64ck670 FIND v(dout1_64) AT=340.025n

.meas tran vdout1_65ck670 FIND v(dout1_65) AT=340.025n

.meas tran vdout1_66ck670 FIND v(dout1_66) AT=340.025n

.meas tran vdout1_67ck670 FIND v(dout1_67) AT=340.025n

.meas tran vdout1_68ck670 FIND v(dout1_68) AT=340.025n

.meas tran vdout1_69ck670 FIND v(dout1_69) AT=340.025n

.meas tran vdout1_70ck670 FIND v(dout1_70) AT=340.025n

.meas tran vdout1_71ck670 FIND v(dout1_71) AT=340.025n

.meas tran vdout1_72ck670 FIND v(dout1_72) AT=340.025n

.meas tran vdout1_73ck670 FIND v(dout1_73) AT=340.025n

.meas tran vdout1_74ck670 FIND v(dout1_74) AT=340.025n

.meas tran vdout1_75ck670 FIND v(dout1_75) AT=340.025n

.meas tran vdout1_76ck670 FIND v(dout1_76) AT=340.025n

.meas tran vdout1_77ck670 FIND v(dout1_77) AT=340.025n

.meas tran vdout1_78ck670 FIND v(dout1_78) AT=340.025n

.meas tran vdout1_79ck670 FIND v(dout1_79) AT=340.025n

.meas tran vdout1_80ck670 FIND v(dout1_80) AT=340.025n

.meas tran vdout1_81ck670 FIND v(dout1_81) AT=340.025n

.meas tran vdout1_82ck670 FIND v(dout1_82) AT=340.025n

.meas tran vdout1_83ck670 FIND v(dout1_83) AT=340.025n

.meas tran vdout1_84ck670 FIND v(dout1_84) AT=340.025n

.meas tran vdout1_85ck670 FIND v(dout1_85) AT=340.025n

.meas tran vdout1_86ck670 FIND v(dout1_86) AT=340.025n

.meas tran vdout1_87ck670 FIND v(dout1_87) AT=340.025n

.meas tran vdout1_88ck670 FIND v(dout1_88) AT=340.025n

.meas tran vdout1_89ck670 FIND v(dout1_89) AT=340.025n

.meas tran vdout1_90ck670 FIND v(dout1_90) AT=340.025n

.meas tran vdout1_91ck670 FIND v(dout1_91) AT=340.025n

.meas tran vdout1_92ck670 FIND v(dout1_92) AT=340.025n

.meas tran vdout1_93ck670 FIND v(dout1_93) AT=340.025n

.meas tran vdout1_94ck670 FIND v(dout1_94) AT=340.025n

.meas tran vdout1_95ck670 FIND v(dout1_95) AT=340.025n

.meas tran vdout1_96ck670 FIND v(dout1_96) AT=340.025n

.meas tran vdout1_97ck670 FIND v(dout1_97) AT=340.025n

.meas tran vdout1_98ck670 FIND v(dout1_98) AT=340.025n

.meas tran vdout1_99ck670 FIND v(dout1_99) AT=340.025n

.meas tran vdout1_100ck670 FIND v(dout1_100) AT=340.025n

.meas tran vdout1_101ck670 FIND v(dout1_101) AT=340.025n

.meas tran vdout1_102ck670 FIND v(dout1_102) AT=340.025n

.meas tran vdout1_103ck670 FIND v(dout1_103) AT=340.025n

.meas tran vdout1_104ck670 FIND v(dout1_104) AT=340.025n

.meas tran vdout1_105ck670 FIND v(dout1_105) AT=340.025n

.meas tran vdout1_106ck670 FIND v(dout1_106) AT=340.025n

.meas tran vdout1_107ck670 FIND v(dout1_107) AT=340.025n

.meas tran vdout1_108ck670 FIND v(dout1_108) AT=340.025n

.meas tran vdout1_109ck670 FIND v(dout1_109) AT=340.025n

.meas tran vdout1_110ck670 FIND v(dout1_110) AT=340.025n

.meas tran vdout1_111ck670 FIND v(dout1_111) AT=340.025n

.meas tran vdout1_112ck670 FIND v(dout1_112) AT=340.025n

.meas tran vdout1_113ck670 FIND v(dout1_113) AT=340.025n

.meas tran vdout1_114ck670 FIND v(dout1_114) AT=340.025n

.meas tran vdout1_115ck670 FIND v(dout1_115) AT=340.025n

.meas tran vdout1_116ck670 FIND v(dout1_116) AT=340.025n

.meas tran vdout1_117ck670 FIND v(dout1_117) AT=340.025n

.meas tran vdout1_118ck670 FIND v(dout1_118) AT=340.025n

.meas tran vdout1_119ck670 FIND v(dout1_119) AT=340.025n

.meas tran vdout1_120ck670 FIND v(dout1_120) AT=340.025n

.meas tran vdout1_121ck670 FIND v(dout1_121) AT=340.025n

.meas tran vdout1_122ck670 FIND v(dout1_122) AT=340.025n

.meas tran vdout1_123ck670 FIND v(dout1_123) AT=340.025n

.meas tran vdout1_124ck670 FIND v(dout1_124) AT=340.025n

.meas tran vdout1_125ck670 FIND v(dout1_125) AT=340.025n

.meas tran vdout1_126ck670 FIND v(dout1_126) AT=340.025n

.meas tran vdout1_127ck670 FIND v(dout1_127) AT=340.025n

.meas tran vdout1_128ck670 FIND v(dout1_128) AT=340.025n

.meas tran vdout1_129ck670 FIND v(dout1_129) AT=340.025n

.meas tran vdout1_130ck670 FIND v(dout1_130) AT=340.025n

.meas tran vdout1_131ck670 FIND v(dout1_131) AT=340.025n

.meas tran vdout1_132ck670 FIND v(dout1_132) AT=340.025n

.meas tran vdout1_133ck670 FIND v(dout1_133) AT=340.025n

.meas tran vdout1_134ck670 FIND v(dout1_134) AT=340.025n

.meas tran vdout1_135ck670 FIND v(dout1_135) AT=340.025n

.meas tran vdout1_136ck670 FIND v(dout1_136) AT=340.025n

.meas tran vdout1_137ck670 FIND v(dout1_137) AT=340.025n

.meas tran vdout1_138ck670 FIND v(dout1_138) AT=340.025n

.meas tran vdout1_139ck670 FIND v(dout1_139) AT=340.025n

.meas tran vdout1_140ck670 FIND v(dout1_140) AT=340.025n

.meas tran vdout1_141ck670 FIND v(dout1_141) AT=340.025n

.meas tran vdout1_142ck670 FIND v(dout1_142) AT=340.025n

.meas tran vdout1_143ck670 FIND v(dout1_143) AT=340.025n

.meas tran vdout1_144ck670 FIND v(dout1_144) AT=340.025n

.meas tran vdout1_145ck670 FIND v(dout1_145) AT=340.025n

.meas tran vdout1_146ck670 FIND v(dout1_146) AT=340.025n

.meas tran vdout1_147ck670 FIND v(dout1_147) AT=340.025n

.meas tran vdout1_148ck670 FIND v(dout1_148) AT=340.025n

.meas tran vdout1_149ck670 FIND v(dout1_149) AT=340.025n

.meas tran vdout1_150ck670 FIND v(dout1_150) AT=340.025n

.meas tran vdout1_151ck670 FIND v(dout1_151) AT=340.025n

.meas tran vdout1_152ck670 FIND v(dout1_152) AT=340.025n

.meas tran vdout1_153ck670 FIND v(dout1_153) AT=340.025n

.meas tran vdout1_154ck670 FIND v(dout1_154) AT=340.025n

.meas tran vdout1_155ck670 FIND v(dout1_155) AT=340.025n

.meas tran vdout1_156ck670 FIND v(dout1_156) AT=340.025n

.meas tran vdout1_157ck670 FIND v(dout1_157) AT=340.025n

.meas tran vdout1_158ck670 FIND v(dout1_158) AT=340.025n

.meas tran vdout1_159ck670 FIND v(dout1_159) AT=340.025n

.meas tran vdout1_160ck670 FIND v(dout1_160) AT=340.025n

.meas tran vdout1_161ck670 FIND v(dout1_161) AT=340.025n

.meas tran vdout1_162ck670 FIND v(dout1_162) AT=340.025n

.meas tran vdout1_163ck670 FIND v(dout1_163) AT=340.025n

.meas tran vdout1_164ck670 FIND v(dout1_164) AT=340.025n

.meas tran vdout1_165ck670 FIND v(dout1_165) AT=340.025n

.meas tran vdout1_166ck670 FIND v(dout1_166) AT=340.025n

.meas tran vdout1_167ck670 FIND v(dout1_167) AT=340.025n

.meas tran vdout1_168ck670 FIND v(dout1_168) AT=340.025n

.meas tran vdout1_169ck670 FIND v(dout1_169) AT=340.025n

.meas tran vdout1_170ck670 FIND v(dout1_170) AT=340.025n

.meas tran vdout1_171ck670 FIND v(dout1_171) AT=340.025n

.meas tran vdout1_172ck670 FIND v(dout1_172) AT=340.025n

.meas tran vdout1_173ck670 FIND v(dout1_173) AT=340.025n

.meas tran vdout1_174ck670 FIND v(dout1_174) AT=340.025n

.meas tran vdout1_175ck670 FIND v(dout1_175) AT=340.025n

.meas tran vdout1_176ck670 FIND v(dout1_176) AT=340.025n

.meas tran vdout1_177ck670 FIND v(dout1_177) AT=340.025n

.meas tran vdout1_178ck670 FIND v(dout1_178) AT=340.025n

.meas tran vdout1_179ck670 FIND v(dout1_179) AT=340.025n

.meas tran vdout1_180ck670 FIND v(dout1_180) AT=340.025n

.meas tran vdout1_181ck670 FIND v(dout1_181) AT=340.025n

.meas tran vdout1_182ck670 FIND v(dout1_182) AT=340.025n

.meas tran vdout1_183ck670 FIND v(dout1_183) AT=340.025n

.meas tran vdout1_184ck670 FIND v(dout1_184) AT=340.025n

.meas tran vdout1_185ck670 FIND v(dout1_185) AT=340.025n

.meas tran vdout1_186ck670 FIND v(dout1_186) AT=340.025n

.meas tran vdout1_187ck670 FIND v(dout1_187) AT=340.025n

.meas tran vdout1_188ck670 FIND v(dout1_188) AT=340.025n

.meas tran vdout1_189ck670 FIND v(dout1_189) AT=340.025n

.meas tran vdout1_190ck670 FIND v(dout1_190) AT=340.025n

.meas tran vdout1_191ck670 FIND v(dout1_191) AT=340.025n

.meas tran vdout1_192ck670 FIND v(dout1_192) AT=340.025n

.meas tran vdout1_193ck670 FIND v(dout1_193) AT=340.025n

.meas tran vdout1_194ck670 FIND v(dout1_194) AT=340.025n

.meas tran vdout1_195ck670 FIND v(dout1_195) AT=340.025n

.meas tran vdout1_196ck670 FIND v(dout1_196) AT=340.025n

.meas tran vdout1_197ck670 FIND v(dout1_197) AT=340.025n

.meas tran vdout1_198ck670 FIND v(dout1_198) AT=340.025n

.meas tran vdout1_199ck670 FIND v(dout1_199) AT=340.025n

.meas tran vdout1_200ck670 FIND v(dout1_200) AT=340.025n

.meas tran vdout1_201ck670 FIND v(dout1_201) AT=340.025n

.meas tran vdout1_202ck670 FIND v(dout1_202) AT=340.025n

.meas tran vdout1_203ck670 FIND v(dout1_203) AT=340.025n

.meas tran vdout1_204ck670 FIND v(dout1_204) AT=340.025n

.meas tran vdout1_205ck670 FIND v(dout1_205) AT=340.025n

.meas tran vdout1_206ck670 FIND v(dout1_206) AT=340.025n

.meas tran vdout1_207ck670 FIND v(dout1_207) AT=340.025n

.meas tran vdout1_208ck670 FIND v(dout1_208) AT=340.025n

.meas tran vdout1_209ck670 FIND v(dout1_209) AT=340.025n

.meas tran vdout1_210ck670 FIND v(dout1_210) AT=340.025n

.meas tran vdout1_211ck670 FIND v(dout1_211) AT=340.025n

.meas tran vdout1_212ck670 FIND v(dout1_212) AT=340.025n

.meas tran vdout1_213ck670 FIND v(dout1_213) AT=340.025n

.meas tran vdout1_214ck670 FIND v(dout1_214) AT=340.025n

.meas tran vdout1_215ck670 FIND v(dout1_215) AT=340.025n

.meas tran vdout1_216ck670 FIND v(dout1_216) AT=340.025n

.meas tran vdout1_217ck670 FIND v(dout1_217) AT=340.025n

.meas tran vdout1_218ck670 FIND v(dout1_218) AT=340.025n

.meas tran vdout1_219ck670 FIND v(dout1_219) AT=340.025n

.meas tran vdout1_220ck670 FIND v(dout1_220) AT=340.025n

.meas tran vdout1_221ck670 FIND v(dout1_221) AT=340.025n

.meas tran vdout1_222ck670 FIND v(dout1_222) AT=340.025n

.meas tran vdout1_223ck670 FIND v(dout1_223) AT=340.025n

.meas tran vdout1_224ck670 FIND v(dout1_224) AT=340.025n

.meas tran vdout1_225ck670 FIND v(dout1_225) AT=340.025n

.meas tran vdout1_226ck670 FIND v(dout1_226) AT=340.025n

.meas tran vdout1_227ck670 FIND v(dout1_227) AT=340.025n

.meas tran vdout1_228ck670 FIND v(dout1_228) AT=340.025n

.meas tran vdout1_229ck670 FIND v(dout1_229) AT=340.025n

.meas tran vdout1_230ck670 FIND v(dout1_230) AT=340.025n

.meas tran vdout1_231ck670 FIND v(dout1_231) AT=340.025n

.meas tran vdout1_232ck670 FIND v(dout1_232) AT=340.025n

.meas tran vdout1_233ck670 FIND v(dout1_233) AT=340.025n

.meas tran vdout1_234ck670 FIND v(dout1_234) AT=340.025n

.meas tran vdout1_235ck670 FIND v(dout1_235) AT=340.025n

.meas tran vdout1_236ck670 FIND v(dout1_236) AT=340.025n

.meas tran vdout1_237ck670 FIND v(dout1_237) AT=340.025n

.meas tran vdout1_238ck670 FIND v(dout1_238) AT=340.025n

.meas tran vdout1_239ck670 FIND v(dout1_239) AT=340.025n

.meas tran vdout1_240ck670 FIND v(dout1_240) AT=340.025n

.meas tran vdout1_241ck670 FIND v(dout1_241) AT=340.025n

.meas tran vdout1_242ck670 FIND v(dout1_242) AT=340.025n

.meas tran vdout1_243ck670 FIND v(dout1_243) AT=340.025n

.meas tran vdout1_244ck670 FIND v(dout1_244) AT=340.025n

.meas tran vdout1_245ck670 FIND v(dout1_245) AT=340.025n

.meas tran vdout1_246ck670 FIND v(dout1_246) AT=340.025n

.meas tran vdout1_247ck670 FIND v(dout1_247) AT=340.025n

.meas tran vdout1_248ck670 FIND v(dout1_248) AT=340.025n

.meas tran vdout1_249ck670 FIND v(dout1_249) AT=340.025n

.meas tran vdout1_250ck670 FIND v(dout1_250) AT=340.025n

.meas tran vdout1_251ck670 FIND v(dout1_251) AT=340.025n

.meas tran vdout1_252ck670 FIND v(dout1_252) AT=340.025n

.meas tran vdout1_253ck670 FIND v(dout1_253) AT=340.025n

.meas tran vdout1_254ck670 FIND v(dout1_254) AT=340.025n

.meas tran vdout1_255ck670 FIND v(dout1_255) AT=340.025n

.meas tran vdout1_256ck670 FIND v(dout1_256) AT=340.025n

.meas tran vdout1_257ck670 FIND v(dout1_257) AT=340.025n

.meas tran vdout1_258ck670 FIND v(dout1_258) AT=340.025n

.meas tran vdout1_259ck670 FIND v(dout1_259) AT=340.025n

.meas tran vdout1_260ck670 FIND v(dout1_260) AT=340.025n

.meas tran vdout1_261ck670 FIND v(dout1_261) AT=340.025n

.meas tran vdout1_262ck670 FIND v(dout1_262) AT=340.025n

.meas tran vdout1_263ck670 FIND v(dout1_263) AT=340.025n

.meas tran vdout1_264ck670 FIND v(dout1_264) AT=340.025n

.meas tran vdout1_265ck670 FIND v(dout1_265) AT=340.025n

.meas tran vdout1_266ck670 FIND v(dout1_266) AT=340.025n

.meas tran vdout1_267ck670 FIND v(dout1_267) AT=340.025n

.meas tran vdout1_268ck670 FIND v(dout1_268) AT=340.025n

.meas tran vdout1_269ck670 FIND v(dout1_269) AT=340.025n

.meas tran vdout1_270ck670 FIND v(dout1_270) AT=340.025n

.meas tran vdout1_271ck670 FIND v(dout1_271) AT=340.025n

.meas tran vdout1_272ck670 FIND v(dout1_272) AT=340.025n

.meas tran vdout1_273ck670 FIND v(dout1_273) AT=340.025n

.meas tran vdout1_274ck670 FIND v(dout1_274) AT=340.025n

.meas tran vdout1_275ck670 FIND v(dout1_275) AT=340.025n

.meas tran vdout1_276ck670 FIND v(dout1_276) AT=340.025n

.meas tran vdout1_277ck670 FIND v(dout1_277) AT=340.025n

.meas tran vdout1_278ck670 FIND v(dout1_278) AT=340.025n

.meas tran vdout1_279ck670 FIND v(dout1_279) AT=340.025n

.meas tran vdout1_280ck670 FIND v(dout1_280) AT=340.025n

.meas tran vdout1_281ck670 FIND v(dout1_281) AT=340.025n

.meas tran vdout1_282ck670 FIND v(dout1_282) AT=340.025n

.meas tran vdout1_283ck670 FIND v(dout1_283) AT=340.025n

.meas tran vdout1_284ck670 FIND v(dout1_284) AT=340.025n

.meas tran vdout1_285ck670 FIND v(dout1_285) AT=340.025n

.meas tran vdout1_286ck670 FIND v(dout1_286) AT=340.025n

.meas tran vdout1_287ck670 FIND v(dout1_287) AT=340.025n

.meas tran vdout1_288ck670 FIND v(dout1_288) AT=340.025n

.meas tran vdout1_289ck670 FIND v(dout1_289) AT=340.025n

.meas tran vdout1_290ck670 FIND v(dout1_290) AT=340.025n

.meas tran vdout1_291ck670 FIND v(dout1_291) AT=340.025n

.meas tran vdout1_292ck670 FIND v(dout1_292) AT=340.025n

.meas tran vdout1_293ck670 FIND v(dout1_293) AT=340.025n

.meas tran vdout1_294ck670 FIND v(dout1_294) AT=340.025n

.meas tran vdout1_295ck670 FIND v(dout1_295) AT=340.025n

.meas tran vdout1_296ck670 FIND v(dout1_296) AT=340.025n

.meas tran vdout1_297ck670 FIND v(dout1_297) AT=340.025n

.meas tran vdout1_298ck670 FIND v(dout1_298) AT=340.025n

.meas tran vdout1_299ck670 FIND v(dout1_299) AT=340.025n

.meas tran vdout1_300ck670 FIND v(dout1_300) AT=340.025n

.meas tran vdout1_301ck670 FIND v(dout1_301) AT=340.025n

.meas tran vdout1_302ck670 FIND v(dout1_302) AT=340.025n

.meas tran vdout1_303ck670 FIND v(dout1_303) AT=340.025n

.meas tran vdout1_304ck670 FIND v(dout1_304) AT=340.025n

.meas tran vdout1_305ck670 FIND v(dout1_305) AT=340.025n

.meas tran vdout1_306ck670 FIND v(dout1_306) AT=340.025n

.meas tran vdout1_307ck670 FIND v(dout1_307) AT=340.025n

.meas tran vdout1_308ck670 FIND v(dout1_308) AT=340.025n

.meas tran vdout1_309ck670 FIND v(dout1_309) AT=340.025n

.meas tran vdout1_310ck670 FIND v(dout1_310) AT=340.025n

.meas tran vdout1_311ck670 FIND v(dout1_311) AT=340.025n

.meas tran vdout1_312ck670 FIND v(dout1_312) AT=340.025n

.meas tran vdout1_313ck670 FIND v(dout1_313) AT=340.025n

.meas tran vdout1_314ck670 FIND v(dout1_314) AT=340.025n

.meas tran vdout1_315ck670 FIND v(dout1_315) AT=340.025n

.meas tran vdout1_316ck670 FIND v(dout1_316) AT=340.025n

.meas tran vdout1_317ck670 FIND v(dout1_317) AT=340.025n

.meas tran vdout1_318ck670 FIND v(dout1_318) AT=340.025n

.meas tran vdout1_319ck670 FIND v(dout1_319) AT=340.025n

.meas tran vdout1_320ck670 FIND v(dout1_320) AT=340.025n

.meas tran vdout1_321ck670 FIND v(dout1_321) AT=340.025n

.meas tran vdout1_322ck670 FIND v(dout1_322) AT=340.025n

.meas tran vdout1_323ck670 FIND v(dout1_323) AT=340.025n

.meas tran vdout1_324ck670 FIND v(dout1_324) AT=340.025n

.meas tran vdout1_325ck670 FIND v(dout1_325) AT=340.025n

.meas tran vdout1_326ck670 FIND v(dout1_326) AT=340.025n

.meas tran vdout1_327ck670 FIND v(dout1_327) AT=340.025n

.meas tran vdout1_328ck670 FIND v(dout1_328) AT=340.025n

.meas tran vdout1_329ck670 FIND v(dout1_329) AT=340.025n

.meas tran vdout1_330ck670 FIND v(dout1_330) AT=340.025n

.meas tran vdout1_331ck670 FIND v(dout1_331) AT=340.025n

.meas tran vdout1_332ck670 FIND v(dout1_332) AT=340.025n

.meas tran vdout1_333ck670 FIND v(dout1_333) AT=340.025n

.meas tran vdout1_334ck670 FIND v(dout1_334) AT=340.025n

.meas tran vdout1_335ck670 FIND v(dout1_335) AT=340.025n

.meas tran vdout1_336ck670 FIND v(dout1_336) AT=340.025n

.meas tran vdout1_337ck670 FIND v(dout1_337) AT=340.025n

.meas tran vdout1_338ck670 FIND v(dout1_338) AT=340.025n

.meas tran vdout1_339ck670 FIND v(dout1_339) AT=340.025n

.meas tran vdout1_340ck670 FIND v(dout1_340) AT=340.025n

.meas tran vdout1_341ck670 FIND v(dout1_341) AT=340.025n

.meas tran vdout1_342ck670 FIND v(dout1_342) AT=340.025n

.meas tran vdout1_343ck670 FIND v(dout1_343) AT=340.025n

.meas tran vdout1_344ck670 FIND v(dout1_344) AT=340.025n

.meas tran vdout1_345ck670 FIND v(dout1_345) AT=340.025n

.meas tran vdout1_346ck670 FIND v(dout1_346) AT=340.025n

.meas tran vdout1_347ck670 FIND v(dout1_347) AT=340.025n

.meas tran vdout1_348ck670 FIND v(dout1_348) AT=340.025n

.meas tran vdout1_349ck670 FIND v(dout1_349) AT=340.025n

.meas tran vdout1_350ck670 FIND v(dout1_350) AT=340.025n

.meas tran vdout1_351ck670 FIND v(dout1_351) AT=340.025n

.meas tran vdout1_352ck670 FIND v(dout1_352) AT=340.025n

.meas tran vdout1_353ck670 FIND v(dout1_353) AT=340.025n

.meas tran vdout1_354ck670 FIND v(dout1_354) AT=340.025n

.meas tran vdout1_355ck670 FIND v(dout1_355) AT=340.025n

.meas tran vdout1_356ck670 FIND v(dout1_356) AT=340.025n

.meas tran vdout1_357ck670 FIND v(dout1_357) AT=340.025n

.meas tran vdout1_358ck670 FIND v(dout1_358) AT=340.025n

.meas tran vdout1_359ck670 FIND v(dout1_359) AT=340.025n

.meas tran vdout1_360ck670 FIND v(dout1_360) AT=340.025n

.meas tran vdout1_361ck670 FIND v(dout1_361) AT=340.025n

.meas tran vdout1_362ck670 FIND v(dout1_362) AT=340.025n

.meas tran vdout1_363ck670 FIND v(dout1_363) AT=340.025n

.meas tran vdout1_364ck670 FIND v(dout1_364) AT=340.025n

.meas tran vdout1_365ck670 FIND v(dout1_365) AT=340.025n

.meas tran vdout1_366ck670 FIND v(dout1_366) AT=340.025n

.meas tran vdout1_367ck670 FIND v(dout1_367) AT=340.025n

.meas tran vdout1_368ck670 FIND v(dout1_368) AT=340.025n

.meas tran vdout1_369ck670 FIND v(dout1_369) AT=340.025n

.meas tran vdout1_370ck670 FIND v(dout1_370) AT=340.025n

.meas tran vdout1_371ck670 FIND v(dout1_371) AT=340.025n

.meas tran vdout1_372ck670 FIND v(dout1_372) AT=340.025n

.meas tran vdout1_373ck670 FIND v(dout1_373) AT=340.025n

.meas tran vdout1_374ck670 FIND v(dout1_374) AT=340.025n

.meas tran vdout1_375ck670 FIND v(dout1_375) AT=340.025n

.meas tran vdout1_376ck670 FIND v(dout1_376) AT=340.025n

.meas tran vdout1_377ck670 FIND v(dout1_377) AT=340.025n

.meas tran vdout1_378ck670 FIND v(dout1_378) AT=340.025n

.meas tran vdout1_379ck670 FIND v(dout1_379) AT=340.025n

.meas tran vdout1_380ck670 FIND v(dout1_380) AT=340.025n

.meas tran vdout1_381ck670 FIND v(dout1_381) AT=340.025n

.meas tran vdout1_382ck670 FIND v(dout1_382) AT=340.025n

.meas tran vdout1_383ck670 FIND v(dout1_383) AT=340.025n

.meas tran vdout1_384ck670 FIND v(dout1_384) AT=340.025n

.meas tran vdout1_385ck670 FIND v(dout1_385) AT=340.025n

.meas tran vdout1_386ck670 FIND v(dout1_386) AT=340.025n

.meas tran vdout1_387ck670 FIND v(dout1_387) AT=340.025n

.meas tran vdout1_388ck670 FIND v(dout1_388) AT=340.025n

.meas tran vdout1_389ck670 FIND v(dout1_389) AT=340.025n

.meas tran vdout1_390ck670 FIND v(dout1_390) AT=340.025n

.meas tran vdout1_391ck670 FIND v(dout1_391) AT=340.025n

.meas tran vdout1_392ck670 FIND v(dout1_392) AT=340.025n

.meas tran vdout1_393ck670 FIND v(dout1_393) AT=340.025n

.meas tran vdout1_394ck670 FIND v(dout1_394) AT=340.025n

.meas tran vdout1_395ck670 FIND v(dout1_395) AT=340.025n

.meas tran vdout1_396ck670 FIND v(dout1_396) AT=340.025n

.meas tran vdout1_397ck670 FIND v(dout1_397) AT=340.025n

.meas tran vdout1_398ck670 FIND v(dout1_398) AT=340.025n

.meas tran vdout1_399ck670 FIND v(dout1_399) AT=340.025n

.meas tran vdout1_400ck670 FIND v(dout1_400) AT=340.025n

.meas tran vdout1_401ck670 FIND v(dout1_401) AT=340.025n

.meas tran vdout1_402ck670 FIND v(dout1_402) AT=340.025n

.meas tran vdout1_403ck670 FIND v(dout1_403) AT=340.025n

.meas tran vdout1_404ck670 FIND v(dout1_404) AT=340.025n

.meas tran vdout1_405ck670 FIND v(dout1_405) AT=340.025n

.meas tran vdout1_406ck670 FIND v(dout1_406) AT=340.025n

.meas tran vdout1_407ck670 FIND v(dout1_407) AT=340.025n

.meas tran vdout1_408ck670 FIND v(dout1_408) AT=340.025n

.meas tran vdout1_409ck670 FIND v(dout1_409) AT=340.025n

.meas tran vdout1_410ck670 FIND v(dout1_410) AT=340.025n

.meas tran vdout1_411ck670 FIND v(dout1_411) AT=340.025n

.meas tran vdout1_412ck670 FIND v(dout1_412) AT=340.025n

.meas tran vdout1_413ck670 FIND v(dout1_413) AT=340.025n

.meas tran vdout1_414ck670 FIND v(dout1_414) AT=340.025n

.meas tran vdout1_415ck670 FIND v(dout1_415) AT=340.025n

.meas tran vdout1_416ck670 FIND v(dout1_416) AT=340.025n

.meas tran vdout1_417ck670 FIND v(dout1_417) AT=340.025n

.meas tran vdout1_418ck670 FIND v(dout1_418) AT=340.025n

.meas tran vdout1_419ck670 FIND v(dout1_419) AT=340.025n

.meas tran vdout1_420ck670 FIND v(dout1_420) AT=340.025n

.meas tran vdout1_421ck670 FIND v(dout1_421) AT=340.025n

.meas tran vdout1_422ck670 FIND v(dout1_422) AT=340.025n

.meas tran vdout1_423ck670 FIND v(dout1_423) AT=340.025n

.meas tran vdout1_424ck670 FIND v(dout1_424) AT=340.025n

.meas tran vdout1_425ck670 FIND v(dout1_425) AT=340.025n

.meas tran vdout1_426ck670 FIND v(dout1_426) AT=340.025n

.meas tran vdout1_427ck670 FIND v(dout1_427) AT=340.025n

.meas tran vdout1_428ck670 FIND v(dout1_428) AT=340.025n

.meas tran vdout1_429ck670 FIND v(dout1_429) AT=340.025n

.meas tran vdout1_430ck670 FIND v(dout1_430) AT=340.025n

.meas tran vdout1_431ck670 FIND v(dout1_431) AT=340.025n

.meas tran vdout1_432ck670 FIND v(dout1_432) AT=340.025n

.meas tran vdout1_433ck670 FIND v(dout1_433) AT=340.025n

.meas tran vdout1_434ck670 FIND v(dout1_434) AT=340.025n

.meas tran vdout1_435ck670 FIND v(dout1_435) AT=340.025n

.meas tran vdout1_436ck670 FIND v(dout1_436) AT=340.025n

.meas tran vdout1_437ck670 FIND v(dout1_437) AT=340.025n

.meas tran vdout1_438ck670 FIND v(dout1_438) AT=340.025n

.meas tran vdout1_439ck670 FIND v(dout1_439) AT=340.025n

.meas tran vdout1_440ck670 FIND v(dout1_440) AT=340.025n

.meas tran vdout1_441ck670 FIND v(dout1_441) AT=340.025n

.meas tran vdout1_442ck670 FIND v(dout1_442) AT=340.025n

.meas tran vdout1_443ck670 FIND v(dout1_443) AT=340.025n

.meas tran vdout1_444ck670 FIND v(dout1_444) AT=340.025n

.meas tran vdout1_445ck670 FIND v(dout1_445) AT=340.025n

.meas tran vdout1_446ck670 FIND v(dout1_446) AT=340.025n

.meas tran vdout1_447ck670 FIND v(dout1_447) AT=340.025n

.meas tran vdout1_448ck670 FIND v(dout1_448) AT=340.025n

.meas tran vdout1_449ck670 FIND v(dout1_449) AT=340.025n

.meas tran vdout1_450ck670 FIND v(dout1_450) AT=340.025n

.meas tran vdout1_451ck670 FIND v(dout1_451) AT=340.025n

.meas tran vdout1_452ck670 FIND v(dout1_452) AT=340.025n

.meas tran vdout1_453ck670 FIND v(dout1_453) AT=340.025n

.meas tran vdout1_454ck670 FIND v(dout1_454) AT=340.025n

.meas tran vdout1_455ck670 FIND v(dout1_455) AT=340.025n

.meas tran vdout1_456ck670 FIND v(dout1_456) AT=340.025n

.meas tran vdout1_457ck670 FIND v(dout1_457) AT=340.025n

.meas tran vdout1_458ck670 FIND v(dout1_458) AT=340.025n

.meas tran vdout1_459ck670 FIND v(dout1_459) AT=340.025n

.meas tran vdout1_460ck670 FIND v(dout1_460) AT=340.025n

.meas tran vdout1_461ck670 FIND v(dout1_461) AT=340.025n

.meas tran vdout1_462ck670 FIND v(dout1_462) AT=340.025n

.meas tran vdout1_463ck670 FIND v(dout1_463) AT=340.025n

.meas tran vdout1_464ck670 FIND v(dout1_464) AT=340.025n

.meas tran vdout1_465ck670 FIND v(dout1_465) AT=340.025n

.meas tran vdout1_466ck670 FIND v(dout1_466) AT=340.025n

.meas tran vdout1_467ck670 FIND v(dout1_467) AT=340.025n

.meas tran vdout1_468ck670 FIND v(dout1_468) AT=340.025n

.meas tran vdout1_469ck670 FIND v(dout1_469) AT=340.025n

.meas tran vdout1_470ck670 FIND v(dout1_470) AT=340.025n

.meas tran vdout1_471ck670 FIND v(dout1_471) AT=340.025n

.meas tran vdout1_472ck670 FIND v(dout1_472) AT=340.025n

.meas tran vdout1_473ck670 FIND v(dout1_473) AT=340.025n

.meas tran vdout1_474ck670 FIND v(dout1_474) AT=340.025n

.meas tran vdout1_475ck670 FIND v(dout1_475) AT=340.025n

.meas tran vdout1_476ck670 FIND v(dout1_476) AT=340.025n

.meas tran vdout1_477ck670 FIND v(dout1_477) AT=340.025n

.meas tran vdout1_478ck670 FIND v(dout1_478) AT=340.025n

.meas tran vdout1_479ck670 FIND v(dout1_479) AT=340.025n

.meas tran vdout1_480ck670 FIND v(dout1_480) AT=340.025n

.meas tran vdout1_481ck670 FIND v(dout1_481) AT=340.025n

.meas tran vdout1_482ck670 FIND v(dout1_482) AT=340.025n

.meas tran vdout1_483ck670 FIND v(dout1_483) AT=340.025n

.meas tran vdout1_484ck670 FIND v(dout1_484) AT=340.025n

.meas tran vdout1_485ck670 FIND v(dout1_485) AT=340.025n

.meas tran vdout1_486ck670 FIND v(dout1_486) AT=340.025n

.meas tran vdout1_487ck670 FIND v(dout1_487) AT=340.025n

.meas tran vdout1_488ck670 FIND v(dout1_488) AT=340.025n

.meas tran vdout1_489ck670 FIND v(dout1_489) AT=340.025n

.meas tran vdout1_490ck670 FIND v(dout1_490) AT=340.025n

.meas tran vdout1_491ck670 FIND v(dout1_491) AT=340.025n

.meas tran vdout1_492ck670 FIND v(dout1_492) AT=340.025n

.meas tran vdout1_493ck670 FIND v(dout1_493) AT=340.025n

.meas tran vdout1_494ck670 FIND v(dout1_494) AT=340.025n

.meas tran vdout1_495ck670 FIND v(dout1_495) AT=340.025n

.meas tran vdout1_496ck670 FIND v(dout1_496) AT=340.025n

.meas tran vdout1_497ck670 FIND v(dout1_497) AT=340.025n

.meas tran vdout1_498ck670 FIND v(dout1_498) AT=340.025n

.meas tran vdout1_499ck670 FIND v(dout1_499) AT=340.025n

.meas tran vdout1_500ck670 FIND v(dout1_500) AT=340.025n

.meas tran vdout1_501ck670 FIND v(dout1_501) AT=340.025n

.meas tran vdout1_502ck670 FIND v(dout1_502) AT=340.025n

.meas tran vdout1_503ck670 FIND v(dout1_503) AT=340.025n

.meas tran vdout1_504ck670 FIND v(dout1_504) AT=340.025n

.meas tran vdout1_505ck670 FIND v(dout1_505) AT=340.025n

.meas tran vdout1_506ck670 FIND v(dout1_506) AT=340.025n

.meas tran vdout1_507ck670 FIND v(dout1_507) AT=340.025n

.meas tran vdout1_508ck670 FIND v(dout1_508) AT=340.025n

.meas tran vdout1_509ck670 FIND v(dout1_509) AT=340.025n

.meas tran vdout1_510ck670 FIND v(dout1_510) AT=340.025n

.meas tran vdout1_511ck670 FIND v(dout1_511) AT=340.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_17ck700 FIND v(dout1_17) AT=355.025n

.meas tran vdout1_18ck700 FIND v(dout1_18) AT=355.025n

.meas tran vdout1_19ck700 FIND v(dout1_19) AT=355.025n

.meas tran vdout1_20ck700 FIND v(dout1_20) AT=355.025n

.meas tran vdout1_21ck700 FIND v(dout1_21) AT=355.025n

.meas tran vdout1_22ck700 FIND v(dout1_22) AT=355.025n

.meas tran vdout1_23ck700 FIND v(dout1_23) AT=355.025n

.meas tran vdout1_24ck700 FIND v(dout1_24) AT=355.025n

.meas tran vdout1_25ck700 FIND v(dout1_25) AT=355.025n

.meas tran vdout1_26ck700 FIND v(dout1_26) AT=355.025n

.meas tran vdout1_27ck700 FIND v(dout1_27) AT=355.025n

.meas tran vdout1_28ck700 FIND v(dout1_28) AT=355.025n

.meas tran vdout1_29ck700 FIND v(dout1_29) AT=355.025n

.meas tran vdout1_30ck700 FIND v(dout1_30) AT=355.025n

.meas tran vdout1_31ck700 FIND v(dout1_31) AT=355.025n

.meas tran vdout1_32ck700 FIND v(dout1_32) AT=355.025n

.meas tran vdout1_33ck700 FIND v(dout1_33) AT=355.025n

.meas tran vdout1_34ck700 FIND v(dout1_34) AT=355.025n

.meas tran vdout1_35ck700 FIND v(dout1_35) AT=355.025n

.meas tran vdout1_36ck700 FIND v(dout1_36) AT=355.025n

.meas tran vdout1_37ck700 FIND v(dout1_37) AT=355.025n

.meas tran vdout1_38ck700 FIND v(dout1_38) AT=355.025n

.meas tran vdout1_39ck700 FIND v(dout1_39) AT=355.025n

.meas tran vdout1_40ck700 FIND v(dout1_40) AT=355.025n

.meas tran vdout1_41ck700 FIND v(dout1_41) AT=355.025n

.meas tran vdout1_42ck700 FIND v(dout1_42) AT=355.025n

.meas tran vdout1_43ck700 FIND v(dout1_43) AT=355.025n

.meas tran vdout1_44ck700 FIND v(dout1_44) AT=355.025n

.meas tran vdout1_45ck700 FIND v(dout1_45) AT=355.025n

.meas tran vdout1_46ck700 FIND v(dout1_46) AT=355.025n

.meas tran vdout1_47ck700 FIND v(dout1_47) AT=355.025n

.meas tran vdout1_48ck700 FIND v(dout1_48) AT=355.025n

.meas tran vdout1_49ck700 FIND v(dout1_49) AT=355.025n

.meas tran vdout1_50ck700 FIND v(dout1_50) AT=355.025n

.meas tran vdout1_51ck700 FIND v(dout1_51) AT=355.025n

.meas tran vdout1_52ck700 FIND v(dout1_52) AT=355.025n

.meas tran vdout1_53ck700 FIND v(dout1_53) AT=355.025n

.meas tran vdout1_54ck700 FIND v(dout1_54) AT=355.025n

.meas tran vdout1_55ck700 FIND v(dout1_55) AT=355.025n

.meas tran vdout1_56ck700 FIND v(dout1_56) AT=355.025n

.meas tran vdout1_57ck700 FIND v(dout1_57) AT=355.025n

.meas tran vdout1_58ck700 FIND v(dout1_58) AT=355.025n

.meas tran vdout1_59ck700 FIND v(dout1_59) AT=355.025n

.meas tran vdout1_60ck700 FIND v(dout1_60) AT=355.025n

.meas tran vdout1_61ck700 FIND v(dout1_61) AT=355.025n

.meas tran vdout1_62ck700 FIND v(dout1_62) AT=355.025n

.meas tran vdout1_63ck700 FIND v(dout1_63) AT=355.025n

.meas tran vdout1_64ck700 FIND v(dout1_64) AT=355.025n

.meas tran vdout1_65ck700 FIND v(dout1_65) AT=355.025n

.meas tran vdout1_66ck700 FIND v(dout1_66) AT=355.025n

.meas tran vdout1_67ck700 FIND v(dout1_67) AT=355.025n

.meas tran vdout1_68ck700 FIND v(dout1_68) AT=355.025n

.meas tran vdout1_69ck700 FIND v(dout1_69) AT=355.025n

.meas tran vdout1_70ck700 FIND v(dout1_70) AT=355.025n

.meas tran vdout1_71ck700 FIND v(dout1_71) AT=355.025n

.meas tran vdout1_72ck700 FIND v(dout1_72) AT=355.025n

.meas tran vdout1_73ck700 FIND v(dout1_73) AT=355.025n

.meas tran vdout1_74ck700 FIND v(dout1_74) AT=355.025n

.meas tran vdout1_75ck700 FIND v(dout1_75) AT=355.025n

.meas tran vdout1_76ck700 FIND v(dout1_76) AT=355.025n

.meas tran vdout1_77ck700 FIND v(dout1_77) AT=355.025n

.meas tran vdout1_78ck700 FIND v(dout1_78) AT=355.025n

.meas tran vdout1_79ck700 FIND v(dout1_79) AT=355.025n

.meas tran vdout1_80ck700 FIND v(dout1_80) AT=355.025n

.meas tran vdout1_81ck700 FIND v(dout1_81) AT=355.025n

.meas tran vdout1_82ck700 FIND v(dout1_82) AT=355.025n

.meas tran vdout1_83ck700 FIND v(dout1_83) AT=355.025n

.meas tran vdout1_84ck700 FIND v(dout1_84) AT=355.025n

.meas tran vdout1_85ck700 FIND v(dout1_85) AT=355.025n

.meas tran vdout1_86ck700 FIND v(dout1_86) AT=355.025n

.meas tran vdout1_87ck700 FIND v(dout1_87) AT=355.025n

.meas tran vdout1_88ck700 FIND v(dout1_88) AT=355.025n

.meas tran vdout1_89ck700 FIND v(dout1_89) AT=355.025n

.meas tran vdout1_90ck700 FIND v(dout1_90) AT=355.025n

.meas tran vdout1_91ck700 FIND v(dout1_91) AT=355.025n

.meas tran vdout1_92ck700 FIND v(dout1_92) AT=355.025n

.meas tran vdout1_93ck700 FIND v(dout1_93) AT=355.025n

.meas tran vdout1_94ck700 FIND v(dout1_94) AT=355.025n

.meas tran vdout1_95ck700 FIND v(dout1_95) AT=355.025n

.meas tran vdout1_96ck700 FIND v(dout1_96) AT=355.025n

.meas tran vdout1_97ck700 FIND v(dout1_97) AT=355.025n

.meas tran vdout1_98ck700 FIND v(dout1_98) AT=355.025n

.meas tran vdout1_99ck700 FIND v(dout1_99) AT=355.025n

.meas tran vdout1_100ck700 FIND v(dout1_100) AT=355.025n

.meas tran vdout1_101ck700 FIND v(dout1_101) AT=355.025n

.meas tran vdout1_102ck700 FIND v(dout1_102) AT=355.025n

.meas tran vdout1_103ck700 FIND v(dout1_103) AT=355.025n

.meas tran vdout1_104ck700 FIND v(dout1_104) AT=355.025n

.meas tran vdout1_105ck700 FIND v(dout1_105) AT=355.025n

.meas tran vdout1_106ck700 FIND v(dout1_106) AT=355.025n

.meas tran vdout1_107ck700 FIND v(dout1_107) AT=355.025n

.meas tran vdout1_108ck700 FIND v(dout1_108) AT=355.025n

.meas tran vdout1_109ck700 FIND v(dout1_109) AT=355.025n

.meas tran vdout1_110ck700 FIND v(dout1_110) AT=355.025n

.meas tran vdout1_111ck700 FIND v(dout1_111) AT=355.025n

.meas tran vdout1_112ck700 FIND v(dout1_112) AT=355.025n

.meas tran vdout1_113ck700 FIND v(dout1_113) AT=355.025n

.meas tran vdout1_114ck700 FIND v(dout1_114) AT=355.025n

.meas tran vdout1_115ck700 FIND v(dout1_115) AT=355.025n

.meas tran vdout1_116ck700 FIND v(dout1_116) AT=355.025n

.meas tran vdout1_117ck700 FIND v(dout1_117) AT=355.025n

.meas tran vdout1_118ck700 FIND v(dout1_118) AT=355.025n

.meas tran vdout1_119ck700 FIND v(dout1_119) AT=355.025n

.meas tran vdout1_120ck700 FIND v(dout1_120) AT=355.025n

.meas tran vdout1_121ck700 FIND v(dout1_121) AT=355.025n

.meas tran vdout1_122ck700 FIND v(dout1_122) AT=355.025n

.meas tran vdout1_123ck700 FIND v(dout1_123) AT=355.025n

.meas tran vdout1_124ck700 FIND v(dout1_124) AT=355.025n

.meas tran vdout1_125ck700 FIND v(dout1_125) AT=355.025n

.meas tran vdout1_126ck700 FIND v(dout1_126) AT=355.025n

.meas tran vdout1_127ck700 FIND v(dout1_127) AT=355.025n

.meas tran vdout1_128ck700 FIND v(dout1_128) AT=355.025n

.meas tran vdout1_129ck700 FIND v(dout1_129) AT=355.025n

.meas tran vdout1_130ck700 FIND v(dout1_130) AT=355.025n

.meas tran vdout1_131ck700 FIND v(dout1_131) AT=355.025n

.meas tran vdout1_132ck700 FIND v(dout1_132) AT=355.025n

.meas tran vdout1_133ck700 FIND v(dout1_133) AT=355.025n

.meas tran vdout1_134ck700 FIND v(dout1_134) AT=355.025n

.meas tran vdout1_135ck700 FIND v(dout1_135) AT=355.025n

.meas tran vdout1_136ck700 FIND v(dout1_136) AT=355.025n

.meas tran vdout1_137ck700 FIND v(dout1_137) AT=355.025n

.meas tran vdout1_138ck700 FIND v(dout1_138) AT=355.025n

.meas tran vdout1_139ck700 FIND v(dout1_139) AT=355.025n

.meas tran vdout1_140ck700 FIND v(dout1_140) AT=355.025n

.meas tran vdout1_141ck700 FIND v(dout1_141) AT=355.025n

.meas tran vdout1_142ck700 FIND v(dout1_142) AT=355.025n

.meas tran vdout1_143ck700 FIND v(dout1_143) AT=355.025n

.meas tran vdout1_144ck700 FIND v(dout1_144) AT=355.025n

.meas tran vdout1_145ck700 FIND v(dout1_145) AT=355.025n

.meas tran vdout1_146ck700 FIND v(dout1_146) AT=355.025n

.meas tran vdout1_147ck700 FIND v(dout1_147) AT=355.025n

.meas tran vdout1_148ck700 FIND v(dout1_148) AT=355.025n

.meas tran vdout1_149ck700 FIND v(dout1_149) AT=355.025n

.meas tran vdout1_150ck700 FIND v(dout1_150) AT=355.025n

.meas tran vdout1_151ck700 FIND v(dout1_151) AT=355.025n

.meas tran vdout1_152ck700 FIND v(dout1_152) AT=355.025n

.meas tran vdout1_153ck700 FIND v(dout1_153) AT=355.025n

.meas tran vdout1_154ck700 FIND v(dout1_154) AT=355.025n

.meas tran vdout1_155ck700 FIND v(dout1_155) AT=355.025n

.meas tran vdout1_156ck700 FIND v(dout1_156) AT=355.025n

.meas tran vdout1_157ck700 FIND v(dout1_157) AT=355.025n

.meas tran vdout1_158ck700 FIND v(dout1_158) AT=355.025n

.meas tran vdout1_159ck700 FIND v(dout1_159) AT=355.025n

.meas tran vdout1_160ck700 FIND v(dout1_160) AT=355.025n

.meas tran vdout1_161ck700 FIND v(dout1_161) AT=355.025n

.meas tran vdout1_162ck700 FIND v(dout1_162) AT=355.025n

.meas tran vdout1_163ck700 FIND v(dout1_163) AT=355.025n

.meas tran vdout1_164ck700 FIND v(dout1_164) AT=355.025n

.meas tran vdout1_165ck700 FIND v(dout1_165) AT=355.025n

.meas tran vdout1_166ck700 FIND v(dout1_166) AT=355.025n

.meas tran vdout1_167ck700 FIND v(dout1_167) AT=355.025n

.meas tran vdout1_168ck700 FIND v(dout1_168) AT=355.025n

.meas tran vdout1_169ck700 FIND v(dout1_169) AT=355.025n

.meas tran vdout1_170ck700 FIND v(dout1_170) AT=355.025n

.meas tran vdout1_171ck700 FIND v(dout1_171) AT=355.025n

.meas tran vdout1_172ck700 FIND v(dout1_172) AT=355.025n

.meas tran vdout1_173ck700 FIND v(dout1_173) AT=355.025n

.meas tran vdout1_174ck700 FIND v(dout1_174) AT=355.025n

.meas tran vdout1_175ck700 FIND v(dout1_175) AT=355.025n

.meas tran vdout1_176ck700 FIND v(dout1_176) AT=355.025n

.meas tran vdout1_177ck700 FIND v(dout1_177) AT=355.025n

.meas tran vdout1_178ck700 FIND v(dout1_178) AT=355.025n

.meas tran vdout1_179ck700 FIND v(dout1_179) AT=355.025n

.meas tran vdout1_180ck700 FIND v(dout1_180) AT=355.025n

.meas tran vdout1_181ck700 FIND v(dout1_181) AT=355.025n

.meas tran vdout1_182ck700 FIND v(dout1_182) AT=355.025n

.meas tran vdout1_183ck700 FIND v(dout1_183) AT=355.025n

.meas tran vdout1_184ck700 FIND v(dout1_184) AT=355.025n

.meas tran vdout1_185ck700 FIND v(dout1_185) AT=355.025n

.meas tran vdout1_186ck700 FIND v(dout1_186) AT=355.025n

.meas tran vdout1_187ck700 FIND v(dout1_187) AT=355.025n

.meas tran vdout1_188ck700 FIND v(dout1_188) AT=355.025n

.meas tran vdout1_189ck700 FIND v(dout1_189) AT=355.025n

.meas tran vdout1_190ck700 FIND v(dout1_190) AT=355.025n

.meas tran vdout1_191ck700 FIND v(dout1_191) AT=355.025n

.meas tran vdout1_192ck700 FIND v(dout1_192) AT=355.025n

.meas tran vdout1_193ck700 FIND v(dout1_193) AT=355.025n

.meas tran vdout1_194ck700 FIND v(dout1_194) AT=355.025n

.meas tran vdout1_195ck700 FIND v(dout1_195) AT=355.025n

.meas tran vdout1_196ck700 FIND v(dout1_196) AT=355.025n

.meas tran vdout1_197ck700 FIND v(dout1_197) AT=355.025n

.meas tran vdout1_198ck700 FIND v(dout1_198) AT=355.025n

.meas tran vdout1_199ck700 FIND v(dout1_199) AT=355.025n

.meas tran vdout1_200ck700 FIND v(dout1_200) AT=355.025n

.meas tran vdout1_201ck700 FIND v(dout1_201) AT=355.025n

.meas tran vdout1_202ck700 FIND v(dout1_202) AT=355.025n

.meas tran vdout1_203ck700 FIND v(dout1_203) AT=355.025n

.meas tran vdout1_204ck700 FIND v(dout1_204) AT=355.025n

.meas tran vdout1_205ck700 FIND v(dout1_205) AT=355.025n

.meas tran vdout1_206ck700 FIND v(dout1_206) AT=355.025n

.meas tran vdout1_207ck700 FIND v(dout1_207) AT=355.025n

.meas tran vdout1_208ck700 FIND v(dout1_208) AT=355.025n

.meas tran vdout1_209ck700 FIND v(dout1_209) AT=355.025n

.meas tran vdout1_210ck700 FIND v(dout1_210) AT=355.025n

.meas tran vdout1_211ck700 FIND v(dout1_211) AT=355.025n

.meas tran vdout1_212ck700 FIND v(dout1_212) AT=355.025n

.meas tran vdout1_213ck700 FIND v(dout1_213) AT=355.025n

.meas tran vdout1_214ck700 FIND v(dout1_214) AT=355.025n

.meas tran vdout1_215ck700 FIND v(dout1_215) AT=355.025n

.meas tran vdout1_216ck700 FIND v(dout1_216) AT=355.025n

.meas tran vdout1_217ck700 FIND v(dout1_217) AT=355.025n

.meas tran vdout1_218ck700 FIND v(dout1_218) AT=355.025n

.meas tran vdout1_219ck700 FIND v(dout1_219) AT=355.025n

.meas tran vdout1_220ck700 FIND v(dout1_220) AT=355.025n

.meas tran vdout1_221ck700 FIND v(dout1_221) AT=355.025n

.meas tran vdout1_222ck700 FIND v(dout1_222) AT=355.025n

.meas tran vdout1_223ck700 FIND v(dout1_223) AT=355.025n

.meas tran vdout1_224ck700 FIND v(dout1_224) AT=355.025n

.meas tran vdout1_225ck700 FIND v(dout1_225) AT=355.025n

.meas tran vdout1_226ck700 FIND v(dout1_226) AT=355.025n

.meas tran vdout1_227ck700 FIND v(dout1_227) AT=355.025n

.meas tran vdout1_228ck700 FIND v(dout1_228) AT=355.025n

.meas tran vdout1_229ck700 FIND v(dout1_229) AT=355.025n

.meas tran vdout1_230ck700 FIND v(dout1_230) AT=355.025n

.meas tran vdout1_231ck700 FIND v(dout1_231) AT=355.025n

.meas tran vdout1_232ck700 FIND v(dout1_232) AT=355.025n

.meas tran vdout1_233ck700 FIND v(dout1_233) AT=355.025n

.meas tran vdout1_234ck700 FIND v(dout1_234) AT=355.025n

.meas tran vdout1_235ck700 FIND v(dout1_235) AT=355.025n

.meas tran vdout1_236ck700 FIND v(dout1_236) AT=355.025n

.meas tran vdout1_237ck700 FIND v(dout1_237) AT=355.025n

.meas tran vdout1_238ck700 FIND v(dout1_238) AT=355.025n

.meas tran vdout1_239ck700 FIND v(dout1_239) AT=355.025n

.meas tran vdout1_240ck700 FIND v(dout1_240) AT=355.025n

.meas tran vdout1_241ck700 FIND v(dout1_241) AT=355.025n

.meas tran vdout1_242ck700 FIND v(dout1_242) AT=355.025n

.meas tran vdout1_243ck700 FIND v(dout1_243) AT=355.025n

.meas tran vdout1_244ck700 FIND v(dout1_244) AT=355.025n

.meas tran vdout1_245ck700 FIND v(dout1_245) AT=355.025n

.meas tran vdout1_246ck700 FIND v(dout1_246) AT=355.025n

.meas tran vdout1_247ck700 FIND v(dout1_247) AT=355.025n

.meas tran vdout1_248ck700 FIND v(dout1_248) AT=355.025n

.meas tran vdout1_249ck700 FIND v(dout1_249) AT=355.025n

.meas tran vdout1_250ck700 FIND v(dout1_250) AT=355.025n

.meas tran vdout1_251ck700 FIND v(dout1_251) AT=355.025n

.meas tran vdout1_252ck700 FIND v(dout1_252) AT=355.025n

.meas tran vdout1_253ck700 FIND v(dout1_253) AT=355.025n

.meas tran vdout1_254ck700 FIND v(dout1_254) AT=355.025n

.meas tran vdout1_255ck700 FIND v(dout1_255) AT=355.025n

.meas tran vdout1_256ck700 FIND v(dout1_256) AT=355.025n

.meas tran vdout1_257ck700 FIND v(dout1_257) AT=355.025n

.meas tran vdout1_258ck700 FIND v(dout1_258) AT=355.025n

.meas tran vdout1_259ck700 FIND v(dout1_259) AT=355.025n

.meas tran vdout1_260ck700 FIND v(dout1_260) AT=355.025n

.meas tran vdout1_261ck700 FIND v(dout1_261) AT=355.025n

.meas tran vdout1_262ck700 FIND v(dout1_262) AT=355.025n

.meas tran vdout1_263ck700 FIND v(dout1_263) AT=355.025n

.meas tran vdout1_264ck700 FIND v(dout1_264) AT=355.025n

.meas tran vdout1_265ck700 FIND v(dout1_265) AT=355.025n

.meas tran vdout1_266ck700 FIND v(dout1_266) AT=355.025n

.meas tran vdout1_267ck700 FIND v(dout1_267) AT=355.025n

.meas tran vdout1_268ck700 FIND v(dout1_268) AT=355.025n

.meas tran vdout1_269ck700 FIND v(dout1_269) AT=355.025n

.meas tran vdout1_270ck700 FIND v(dout1_270) AT=355.025n

.meas tran vdout1_271ck700 FIND v(dout1_271) AT=355.025n

.meas tran vdout1_272ck700 FIND v(dout1_272) AT=355.025n

.meas tran vdout1_273ck700 FIND v(dout1_273) AT=355.025n

.meas tran vdout1_274ck700 FIND v(dout1_274) AT=355.025n

.meas tran vdout1_275ck700 FIND v(dout1_275) AT=355.025n

.meas tran vdout1_276ck700 FIND v(dout1_276) AT=355.025n

.meas tran vdout1_277ck700 FIND v(dout1_277) AT=355.025n

.meas tran vdout1_278ck700 FIND v(dout1_278) AT=355.025n

.meas tran vdout1_279ck700 FIND v(dout1_279) AT=355.025n

.meas tran vdout1_280ck700 FIND v(dout1_280) AT=355.025n

.meas tran vdout1_281ck700 FIND v(dout1_281) AT=355.025n

.meas tran vdout1_282ck700 FIND v(dout1_282) AT=355.025n

.meas tran vdout1_283ck700 FIND v(dout1_283) AT=355.025n

.meas tran vdout1_284ck700 FIND v(dout1_284) AT=355.025n

.meas tran vdout1_285ck700 FIND v(dout1_285) AT=355.025n

.meas tran vdout1_286ck700 FIND v(dout1_286) AT=355.025n

.meas tran vdout1_287ck700 FIND v(dout1_287) AT=355.025n

.meas tran vdout1_288ck700 FIND v(dout1_288) AT=355.025n

.meas tran vdout1_289ck700 FIND v(dout1_289) AT=355.025n

.meas tran vdout1_290ck700 FIND v(dout1_290) AT=355.025n

.meas tran vdout1_291ck700 FIND v(dout1_291) AT=355.025n

.meas tran vdout1_292ck700 FIND v(dout1_292) AT=355.025n

.meas tran vdout1_293ck700 FIND v(dout1_293) AT=355.025n

.meas tran vdout1_294ck700 FIND v(dout1_294) AT=355.025n

.meas tran vdout1_295ck700 FIND v(dout1_295) AT=355.025n

.meas tran vdout1_296ck700 FIND v(dout1_296) AT=355.025n

.meas tran vdout1_297ck700 FIND v(dout1_297) AT=355.025n

.meas tran vdout1_298ck700 FIND v(dout1_298) AT=355.025n

.meas tran vdout1_299ck700 FIND v(dout1_299) AT=355.025n

.meas tran vdout1_300ck700 FIND v(dout1_300) AT=355.025n

.meas tran vdout1_301ck700 FIND v(dout1_301) AT=355.025n

.meas tran vdout1_302ck700 FIND v(dout1_302) AT=355.025n

.meas tran vdout1_303ck700 FIND v(dout1_303) AT=355.025n

.meas tran vdout1_304ck700 FIND v(dout1_304) AT=355.025n

.meas tran vdout1_305ck700 FIND v(dout1_305) AT=355.025n

.meas tran vdout1_306ck700 FIND v(dout1_306) AT=355.025n

.meas tran vdout1_307ck700 FIND v(dout1_307) AT=355.025n

.meas tran vdout1_308ck700 FIND v(dout1_308) AT=355.025n

.meas tran vdout1_309ck700 FIND v(dout1_309) AT=355.025n

.meas tran vdout1_310ck700 FIND v(dout1_310) AT=355.025n

.meas tran vdout1_311ck700 FIND v(dout1_311) AT=355.025n

.meas tran vdout1_312ck700 FIND v(dout1_312) AT=355.025n

.meas tran vdout1_313ck700 FIND v(dout1_313) AT=355.025n

.meas tran vdout1_314ck700 FIND v(dout1_314) AT=355.025n

.meas tran vdout1_315ck700 FIND v(dout1_315) AT=355.025n

.meas tran vdout1_316ck700 FIND v(dout1_316) AT=355.025n

.meas tran vdout1_317ck700 FIND v(dout1_317) AT=355.025n

.meas tran vdout1_318ck700 FIND v(dout1_318) AT=355.025n

.meas tran vdout1_319ck700 FIND v(dout1_319) AT=355.025n

.meas tran vdout1_320ck700 FIND v(dout1_320) AT=355.025n

.meas tran vdout1_321ck700 FIND v(dout1_321) AT=355.025n

.meas tran vdout1_322ck700 FIND v(dout1_322) AT=355.025n

.meas tran vdout1_323ck700 FIND v(dout1_323) AT=355.025n

.meas tran vdout1_324ck700 FIND v(dout1_324) AT=355.025n

.meas tran vdout1_325ck700 FIND v(dout1_325) AT=355.025n

.meas tran vdout1_326ck700 FIND v(dout1_326) AT=355.025n

.meas tran vdout1_327ck700 FIND v(dout1_327) AT=355.025n

.meas tran vdout1_328ck700 FIND v(dout1_328) AT=355.025n

.meas tran vdout1_329ck700 FIND v(dout1_329) AT=355.025n

.meas tran vdout1_330ck700 FIND v(dout1_330) AT=355.025n

.meas tran vdout1_331ck700 FIND v(dout1_331) AT=355.025n

.meas tran vdout1_332ck700 FIND v(dout1_332) AT=355.025n

.meas tran vdout1_333ck700 FIND v(dout1_333) AT=355.025n

.meas tran vdout1_334ck700 FIND v(dout1_334) AT=355.025n

.meas tran vdout1_335ck700 FIND v(dout1_335) AT=355.025n

.meas tran vdout1_336ck700 FIND v(dout1_336) AT=355.025n

.meas tran vdout1_337ck700 FIND v(dout1_337) AT=355.025n

.meas tran vdout1_338ck700 FIND v(dout1_338) AT=355.025n

.meas tran vdout1_339ck700 FIND v(dout1_339) AT=355.025n

.meas tran vdout1_340ck700 FIND v(dout1_340) AT=355.025n

.meas tran vdout1_341ck700 FIND v(dout1_341) AT=355.025n

.meas tran vdout1_342ck700 FIND v(dout1_342) AT=355.025n

.meas tran vdout1_343ck700 FIND v(dout1_343) AT=355.025n

.meas tran vdout1_344ck700 FIND v(dout1_344) AT=355.025n

.meas tran vdout1_345ck700 FIND v(dout1_345) AT=355.025n

.meas tran vdout1_346ck700 FIND v(dout1_346) AT=355.025n

.meas tran vdout1_347ck700 FIND v(dout1_347) AT=355.025n

.meas tran vdout1_348ck700 FIND v(dout1_348) AT=355.025n

.meas tran vdout1_349ck700 FIND v(dout1_349) AT=355.025n

.meas tran vdout1_350ck700 FIND v(dout1_350) AT=355.025n

.meas tran vdout1_351ck700 FIND v(dout1_351) AT=355.025n

.meas tran vdout1_352ck700 FIND v(dout1_352) AT=355.025n

.meas tran vdout1_353ck700 FIND v(dout1_353) AT=355.025n

.meas tran vdout1_354ck700 FIND v(dout1_354) AT=355.025n

.meas tran vdout1_355ck700 FIND v(dout1_355) AT=355.025n

.meas tran vdout1_356ck700 FIND v(dout1_356) AT=355.025n

.meas tran vdout1_357ck700 FIND v(dout1_357) AT=355.025n

.meas tran vdout1_358ck700 FIND v(dout1_358) AT=355.025n

.meas tran vdout1_359ck700 FIND v(dout1_359) AT=355.025n

.meas tran vdout1_360ck700 FIND v(dout1_360) AT=355.025n

.meas tran vdout1_361ck700 FIND v(dout1_361) AT=355.025n

.meas tran vdout1_362ck700 FIND v(dout1_362) AT=355.025n

.meas tran vdout1_363ck700 FIND v(dout1_363) AT=355.025n

.meas tran vdout1_364ck700 FIND v(dout1_364) AT=355.025n

.meas tran vdout1_365ck700 FIND v(dout1_365) AT=355.025n

.meas tran vdout1_366ck700 FIND v(dout1_366) AT=355.025n

.meas tran vdout1_367ck700 FIND v(dout1_367) AT=355.025n

.meas tran vdout1_368ck700 FIND v(dout1_368) AT=355.025n

.meas tran vdout1_369ck700 FIND v(dout1_369) AT=355.025n

.meas tran vdout1_370ck700 FIND v(dout1_370) AT=355.025n

.meas tran vdout1_371ck700 FIND v(dout1_371) AT=355.025n

.meas tran vdout1_372ck700 FIND v(dout1_372) AT=355.025n

.meas tran vdout1_373ck700 FIND v(dout1_373) AT=355.025n

.meas tran vdout1_374ck700 FIND v(dout1_374) AT=355.025n

.meas tran vdout1_375ck700 FIND v(dout1_375) AT=355.025n

.meas tran vdout1_376ck700 FIND v(dout1_376) AT=355.025n

.meas tran vdout1_377ck700 FIND v(dout1_377) AT=355.025n

.meas tran vdout1_378ck700 FIND v(dout1_378) AT=355.025n

.meas tran vdout1_379ck700 FIND v(dout1_379) AT=355.025n

.meas tran vdout1_380ck700 FIND v(dout1_380) AT=355.025n

.meas tran vdout1_381ck700 FIND v(dout1_381) AT=355.025n

.meas tran vdout1_382ck700 FIND v(dout1_382) AT=355.025n

.meas tran vdout1_383ck700 FIND v(dout1_383) AT=355.025n

.meas tran vdout1_384ck700 FIND v(dout1_384) AT=355.025n

.meas tran vdout1_385ck700 FIND v(dout1_385) AT=355.025n

.meas tran vdout1_386ck700 FIND v(dout1_386) AT=355.025n

.meas tran vdout1_387ck700 FIND v(dout1_387) AT=355.025n

.meas tran vdout1_388ck700 FIND v(dout1_388) AT=355.025n

.meas tran vdout1_389ck700 FIND v(dout1_389) AT=355.025n

.meas tran vdout1_390ck700 FIND v(dout1_390) AT=355.025n

.meas tran vdout1_391ck700 FIND v(dout1_391) AT=355.025n

.meas tran vdout1_392ck700 FIND v(dout1_392) AT=355.025n

.meas tran vdout1_393ck700 FIND v(dout1_393) AT=355.025n

.meas tran vdout1_394ck700 FIND v(dout1_394) AT=355.025n

.meas tran vdout1_395ck700 FIND v(dout1_395) AT=355.025n

.meas tran vdout1_396ck700 FIND v(dout1_396) AT=355.025n

.meas tran vdout1_397ck700 FIND v(dout1_397) AT=355.025n

.meas tran vdout1_398ck700 FIND v(dout1_398) AT=355.025n

.meas tran vdout1_399ck700 FIND v(dout1_399) AT=355.025n

.meas tran vdout1_400ck700 FIND v(dout1_400) AT=355.025n

.meas tran vdout1_401ck700 FIND v(dout1_401) AT=355.025n

.meas tran vdout1_402ck700 FIND v(dout1_402) AT=355.025n

.meas tran vdout1_403ck700 FIND v(dout1_403) AT=355.025n

.meas tran vdout1_404ck700 FIND v(dout1_404) AT=355.025n

.meas tran vdout1_405ck700 FIND v(dout1_405) AT=355.025n

.meas tran vdout1_406ck700 FIND v(dout1_406) AT=355.025n

.meas tran vdout1_407ck700 FIND v(dout1_407) AT=355.025n

.meas tran vdout1_408ck700 FIND v(dout1_408) AT=355.025n

.meas tran vdout1_409ck700 FIND v(dout1_409) AT=355.025n

.meas tran vdout1_410ck700 FIND v(dout1_410) AT=355.025n

.meas tran vdout1_411ck700 FIND v(dout1_411) AT=355.025n

.meas tran vdout1_412ck700 FIND v(dout1_412) AT=355.025n

.meas tran vdout1_413ck700 FIND v(dout1_413) AT=355.025n

.meas tran vdout1_414ck700 FIND v(dout1_414) AT=355.025n

.meas tran vdout1_415ck700 FIND v(dout1_415) AT=355.025n

.meas tran vdout1_416ck700 FIND v(dout1_416) AT=355.025n

.meas tran vdout1_417ck700 FIND v(dout1_417) AT=355.025n

.meas tran vdout1_418ck700 FIND v(dout1_418) AT=355.025n

.meas tran vdout1_419ck700 FIND v(dout1_419) AT=355.025n

.meas tran vdout1_420ck700 FIND v(dout1_420) AT=355.025n

.meas tran vdout1_421ck700 FIND v(dout1_421) AT=355.025n

.meas tran vdout1_422ck700 FIND v(dout1_422) AT=355.025n

.meas tran vdout1_423ck700 FIND v(dout1_423) AT=355.025n

.meas tran vdout1_424ck700 FIND v(dout1_424) AT=355.025n

.meas tran vdout1_425ck700 FIND v(dout1_425) AT=355.025n

.meas tran vdout1_426ck700 FIND v(dout1_426) AT=355.025n

.meas tran vdout1_427ck700 FIND v(dout1_427) AT=355.025n

.meas tran vdout1_428ck700 FIND v(dout1_428) AT=355.025n

.meas tran vdout1_429ck700 FIND v(dout1_429) AT=355.025n

.meas tran vdout1_430ck700 FIND v(dout1_430) AT=355.025n

.meas tran vdout1_431ck700 FIND v(dout1_431) AT=355.025n

.meas tran vdout1_432ck700 FIND v(dout1_432) AT=355.025n

.meas tran vdout1_433ck700 FIND v(dout1_433) AT=355.025n

.meas tran vdout1_434ck700 FIND v(dout1_434) AT=355.025n

.meas tran vdout1_435ck700 FIND v(dout1_435) AT=355.025n

.meas tran vdout1_436ck700 FIND v(dout1_436) AT=355.025n

.meas tran vdout1_437ck700 FIND v(dout1_437) AT=355.025n

.meas tran vdout1_438ck700 FIND v(dout1_438) AT=355.025n

.meas tran vdout1_439ck700 FIND v(dout1_439) AT=355.025n

.meas tran vdout1_440ck700 FIND v(dout1_440) AT=355.025n

.meas tran vdout1_441ck700 FIND v(dout1_441) AT=355.025n

.meas tran vdout1_442ck700 FIND v(dout1_442) AT=355.025n

.meas tran vdout1_443ck700 FIND v(dout1_443) AT=355.025n

.meas tran vdout1_444ck700 FIND v(dout1_444) AT=355.025n

.meas tran vdout1_445ck700 FIND v(dout1_445) AT=355.025n

.meas tran vdout1_446ck700 FIND v(dout1_446) AT=355.025n

.meas tran vdout1_447ck700 FIND v(dout1_447) AT=355.025n

.meas tran vdout1_448ck700 FIND v(dout1_448) AT=355.025n

.meas tran vdout1_449ck700 FIND v(dout1_449) AT=355.025n

.meas tran vdout1_450ck700 FIND v(dout1_450) AT=355.025n

.meas tran vdout1_451ck700 FIND v(dout1_451) AT=355.025n

.meas tran vdout1_452ck700 FIND v(dout1_452) AT=355.025n

.meas tran vdout1_453ck700 FIND v(dout1_453) AT=355.025n

.meas tran vdout1_454ck700 FIND v(dout1_454) AT=355.025n

.meas tran vdout1_455ck700 FIND v(dout1_455) AT=355.025n

.meas tran vdout1_456ck700 FIND v(dout1_456) AT=355.025n

.meas tran vdout1_457ck700 FIND v(dout1_457) AT=355.025n

.meas tran vdout1_458ck700 FIND v(dout1_458) AT=355.025n

.meas tran vdout1_459ck700 FIND v(dout1_459) AT=355.025n

.meas tran vdout1_460ck700 FIND v(dout1_460) AT=355.025n

.meas tran vdout1_461ck700 FIND v(dout1_461) AT=355.025n

.meas tran vdout1_462ck700 FIND v(dout1_462) AT=355.025n

.meas tran vdout1_463ck700 FIND v(dout1_463) AT=355.025n

.meas tran vdout1_464ck700 FIND v(dout1_464) AT=355.025n

.meas tran vdout1_465ck700 FIND v(dout1_465) AT=355.025n

.meas tran vdout1_466ck700 FIND v(dout1_466) AT=355.025n

.meas tran vdout1_467ck700 FIND v(dout1_467) AT=355.025n

.meas tran vdout1_468ck700 FIND v(dout1_468) AT=355.025n

.meas tran vdout1_469ck700 FIND v(dout1_469) AT=355.025n

.meas tran vdout1_470ck700 FIND v(dout1_470) AT=355.025n

.meas tran vdout1_471ck700 FIND v(dout1_471) AT=355.025n

.meas tran vdout1_472ck700 FIND v(dout1_472) AT=355.025n

.meas tran vdout1_473ck700 FIND v(dout1_473) AT=355.025n

.meas tran vdout1_474ck700 FIND v(dout1_474) AT=355.025n

.meas tran vdout1_475ck700 FIND v(dout1_475) AT=355.025n

.meas tran vdout1_476ck700 FIND v(dout1_476) AT=355.025n

.meas tran vdout1_477ck700 FIND v(dout1_477) AT=355.025n

.meas tran vdout1_478ck700 FIND v(dout1_478) AT=355.025n

.meas tran vdout1_479ck700 FIND v(dout1_479) AT=355.025n

.meas tran vdout1_480ck700 FIND v(dout1_480) AT=355.025n

.meas tran vdout1_481ck700 FIND v(dout1_481) AT=355.025n

.meas tran vdout1_482ck700 FIND v(dout1_482) AT=355.025n

.meas tran vdout1_483ck700 FIND v(dout1_483) AT=355.025n

.meas tran vdout1_484ck700 FIND v(dout1_484) AT=355.025n

.meas tran vdout1_485ck700 FIND v(dout1_485) AT=355.025n

.meas tran vdout1_486ck700 FIND v(dout1_486) AT=355.025n

.meas tran vdout1_487ck700 FIND v(dout1_487) AT=355.025n

.meas tran vdout1_488ck700 FIND v(dout1_488) AT=355.025n

.meas tran vdout1_489ck700 FIND v(dout1_489) AT=355.025n

.meas tran vdout1_490ck700 FIND v(dout1_490) AT=355.025n

.meas tran vdout1_491ck700 FIND v(dout1_491) AT=355.025n

.meas tran vdout1_492ck700 FIND v(dout1_492) AT=355.025n

.meas tran vdout1_493ck700 FIND v(dout1_493) AT=355.025n

.meas tran vdout1_494ck700 FIND v(dout1_494) AT=355.025n

.meas tran vdout1_495ck700 FIND v(dout1_495) AT=355.025n

.meas tran vdout1_496ck700 FIND v(dout1_496) AT=355.025n

.meas tran vdout1_497ck700 FIND v(dout1_497) AT=355.025n

.meas tran vdout1_498ck700 FIND v(dout1_498) AT=355.025n

.meas tran vdout1_499ck700 FIND v(dout1_499) AT=355.025n

.meas tran vdout1_500ck700 FIND v(dout1_500) AT=355.025n

.meas tran vdout1_501ck700 FIND v(dout1_501) AT=355.025n

.meas tran vdout1_502ck700 FIND v(dout1_502) AT=355.025n

.meas tran vdout1_503ck700 FIND v(dout1_503) AT=355.025n

.meas tran vdout1_504ck700 FIND v(dout1_504) AT=355.025n

.meas tran vdout1_505ck700 FIND v(dout1_505) AT=355.025n

.meas tran vdout1_506ck700 FIND v(dout1_506) AT=355.025n

.meas tran vdout1_507ck700 FIND v(dout1_507) AT=355.025n

.meas tran vdout1_508ck700 FIND v(dout1_508) AT=355.025n

.meas tran vdout1_509ck700 FIND v(dout1_509) AT=355.025n

.meas tran vdout1_510ck700 FIND v(dout1_510) AT=355.025n

.meas tran vdout1_511ck700 FIND v(dout1_511) AT=355.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_32ck710 FIND v(dout1_32) AT=360.025n

.meas tran vdout1_33ck710 FIND v(dout1_33) AT=360.025n

.meas tran vdout1_34ck710 FIND v(dout1_34) AT=360.025n

.meas tran vdout1_35ck710 FIND v(dout1_35) AT=360.025n

.meas tran vdout1_36ck710 FIND v(dout1_36) AT=360.025n

.meas tran vdout1_37ck710 FIND v(dout1_37) AT=360.025n

.meas tran vdout1_38ck710 FIND v(dout1_38) AT=360.025n

.meas tran vdout1_39ck710 FIND v(dout1_39) AT=360.025n

.meas tran vdout1_40ck710 FIND v(dout1_40) AT=360.025n

.meas tran vdout1_41ck710 FIND v(dout1_41) AT=360.025n

.meas tran vdout1_42ck710 FIND v(dout1_42) AT=360.025n

.meas tran vdout1_43ck710 FIND v(dout1_43) AT=360.025n

.meas tran vdout1_44ck710 FIND v(dout1_44) AT=360.025n

.meas tran vdout1_45ck710 FIND v(dout1_45) AT=360.025n

.meas tran vdout1_46ck710 FIND v(dout1_46) AT=360.025n

.meas tran vdout1_47ck710 FIND v(dout1_47) AT=360.025n

.meas tran vdout1_48ck710 FIND v(dout1_48) AT=360.025n

.meas tran vdout1_49ck710 FIND v(dout1_49) AT=360.025n

.meas tran vdout1_50ck710 FIND v(dout1_50) AT=360.025n

.meas tran vdout1_51ck710 FIND v(dout1_51) AT=360.025n

.meas tran vdout1_52ck710 FIND v(dout1_52) AT=360.025n

.meas tran vdout1_53ck710 FIND v(dout1_53) AT=360.025n

.meas tran vdout1_54ck710 FIND v(dout1_54) AT=360.025n

.meas tran vdout1_55ck710 FIND v(dout1_55) AT=360.025n

.meas tran vdout1_56ck710 FIND v(dout1_56) AT=360.025n

.meas tran vdout1_57ck710 FIND v(dout1_57) AT=360.025n

.meas tran vdout1_58ck710 FIND v(dout1_58) AT=360.025n

.meas tran vdout1_59ck710 FIND v(dout1_59) AT=360.025n

.meas tran vdout1_60ck710 FIND v(dout1_60) AT=360.025n

.meas tran vdout1_61ck710 FIND v(dout1_61) AT=360.025n

.meas tran vdout1_62ck710 FIND v(dout1_62) AT=360.025n

.meas tran vdout1_63ck710 FIND v(dout1_63) AT=360.025n

.meas tran vdout1_64ck710 FIND v(dout1_64) AT=360.025n

.meas tran vdout1_65ck710 FIND v(dout1_65) AT=360.025n

.meas tran vdout1_66ck710 FIND v(dout1_66) AT=360.025n

.meas tran vdout1_67ck710 FIND v(dout1_67) AT=360.025n

.meas tran vdout1_68ck710 FIND v(dout1_68) AT=360.025n

.meas tran vdout1_69ck710 FIND v(dout1_69) AT=360.025n

.meas tran vdout1_70ck710 FIND v(dout1_70) AT=360.025n

.meas tran vdout1_71ck710 FIND v(dout1_71) AT=360.025n

.meas tran vdout1_72ck710 FIND v(dout1_72) AT=360.025n

.meas tran vdout1_73ck710 FIND v(dout1_73) AT=360.025n

.meas tran vdout1_74ck710 FIND v(dout1_74) AT=360.025n

.meas tran vdout1_75ck710 FIND v(dout1_75) AT=360.025n

.meas tran vdout1_76ck710 FIND v(dout1_76) AT=360.025n

.meas tran vdout1_77ck710 FIND v(dout1_77) AT=360.025n

.meas tran vdout1_78ck710 FIND v(dout1_78) AT=360.025n

.meas tran vdout1_79ck710 FIND v(dout1_79) AT=360.025n

.meas tran vdout1_80ck710 FIND v(dout1_80) AT=360.025n

.meas tran vdout1_81ck710 FIND v(dout1_81) AT=360.025n

.meas tran vdout1_82ck710 FIND v(dout1_82) AT=360.025n

.meas tran vdout1_83ck710 FIND v(dout1_83) AT=360.025n

.meas tran vdout1_84ck710 FIND v(dout1_84) AT=360.025n

.meas tran vdout1_85ck710 FIND v(dout1_85) AT=360.025n

.meas tran vdout1_86ck710 FIND v(dout1_86) AT=360.025n

.meas tran vdout1_87ck710 FIND v(dout1_87) AT=360.025n

.meas tran vdout1_88ck710 FIND v(dout1_88) AT=360.025n

.meas tran vdout1_89ck710 FIND v(dout1_89) AT=360.025n

.meas tran vdout1_90ck710 FIND v(dout1_90) AT=360.025n

.meas tran vdout1_91ck710 FIND v(dout1_91) AT=360.025n

.meas tran vdout1_92ck710 FIND v(dout1_92) AT=360.025n

.meas tran vdout1_93ck710 FIND v(dout1_93) AT=360.025n

.meas tran vdout1_94ck710 FIND v(dout1_94) AT=360.025n

.meas tran vdout1_95ck710 FIND v(dout1_95) AT=360.025n

.meas tran vdout1_96ck710 FIND v(dout1_96) AT=360.025n

.meas tran vdout1_97ck710 FIND v(dout1_97) AT=360.025n

.meas tran vdout1_98ck710 FIND v(dout1_98) AT=360.025n

.meas tran vdout1_99ck710 FIND v(dout1_99) AT=360.025n

.meas tran vdout1_100ck710 FIND v(dout1_100) AT=360.025n

.meas tran vdout1_101ck710 FIND v(dout1_101) AT=360.025n

.meas tran vdout1_102ck710 FIND v(dout1_102) AT=360.025n

.meas tran vdout1_103ck710 FIND v(dout1_103) AT=360.025n

.meas tran vdout1_104ck710 FIND v(dout1_104) AT=360.025n

.meas tran vdout1_105ck710 FIND v(dout1_105) AT=360.025n

.meas tran vdout1_106ck710 FIND v(dout1_106) AT=360.025n

.meas tran vdout1_107ck710 FIND v(dout1_107) AT=360.025n

.meas tran vdout1_108ck710 FIND v(dout1_108) AT=360.025n

.meas tran vdout1_109ck710 FIND v(dout1_109) AT=360.025n

.meas tran vdout1_110ck710 FIND v(dout1_110) AT=360.025n

.meas tran vdout1_111ck710 FIND v(dout1_111) AT=360.025n

.meas tran vdout1_112ck710 FIND v(dout1_112) AT=360.025n

.meas tran vdout1_113ck710 FIND v(dout1_113) AT=360.025n

.meas tran vdout1_114ck710 FIND v(dout1_114) AT=360.025n

.meas tran vdout1_115ck710 FIND v(dout1_115) AT=360.025n

.meas tran vdout1_116ck710 FIND v(dout1_116) AT=360.025n

.meas tran vdout1_117ck710 FIND v(dout1_117) AT=360.025n

.meas tran vdout1_118ck710 FIND v(dout1_118) AT=360.025n

.meas tran vdout1_119ck710 FIND v(dout1_119) AT=360.025n

.meas tran vdout1_120ck710 FIND v(dout1_120) AT=360.025n

.meas tran vdout1_121ck710 FIND v(dout1_121) AT=360.025n

.meas tran vdout1_122ck710 FIND v(dout1_122) AT=360.025n

.meas tran vdout1_123ck710 FIND v(dout1_123) AT=360.025n

.meas tran vdout1_124ck710 FIND v(dout1_124) AT=360.025n

.meas tran vdout1_125ck710 FIND v(dout1_125) AT=360.025n

.meas tran vdout1_126ck710 FIND v(dout1_126) AT=360.025n

.meas tran vdout1_127ck710 FIND v(dout1_127) AT=360.025n

.meas tran vdout1_128ck710 FIND v(dout1_128) AT=360.025n

.meas tran vdout1_129ck710 FIND v(dout1_129) AT=360.025n

.meas tran vdout1_130ck710 FIND v(dout1_130) AT=360.025n

.meas tran vdout1_131ck710 FIND v(dout1_131) AT=360.025n

.meas tran vdout1_132ck710 FIND v(dout1_132) AT=360.025n

.meas tran vdout1_133ck710 FIND v(dout1_133) AT=360.025n

.meas tran vdout1_134ck710 FIND v(dout1_134) AT=360.025n

.meas tran vdout1_135ck710 FIND v(dout1_135) AT=360.025n

.meas tran vdout1_136ck710 FIND v(dout1_136) AT=360.025n

.meas tran vdout1_137ck710 FIND v(dout1_137) AT=360.025n

.meas tran vdout1_138ck710 FIND v(dout1_138) AT=360.025n

.meas tran vdout1_139ck710 FIND v(dout1_139) AT=360.025n

.meas tran vdout1_140ck710 FIND v(dout1_140) AT=360.025n

.meas tran vdout1_141ck710 FIND v(dout1_141) AT=360.025n

.meas tran vdout1_142ck710 FIND v(dout1_142) AT=360.025n

.meas tran vdout1_143ck710 FIND v(dout1_143) AT=360.025n

.meas tran vdout1_144ck710 FIND v(dout1_144) AT=360.025n

.meas tran vdout1_145ck710 FIND v(dout1_145) AT=360.025n

.meas tran vdout1_146ck710 FIND v(dout1_146) AT=360.025n

.meas tran vdout1_147ck710 FIND v(dout1_147) AT=360.025n

.meas tran vdout1_148ck710 FIND v(dout1_148) AT=360.025n

.meas tran vdout1_149ck710 FIND v(dout1_149) AT=360.025n

.meas tran vdout1_150ck710 FIND v(dout1_150) AT=360.025n

.meas tran vdout1_151ck710 FIND v(dout1_151) AT=360.025n

.meas tran vdout1_152ck710 FIND v(dout1_152) AT=360.025n

.meas tran vdout1_153ck710 FIND v(dout1_153) AT=360.025n

.meas tran vdout1_154ck710 FIND v(dout1_154) AT=360.025n

.meas tran vdout1_155ck710 FIND v(dout1_155) AT=360.025n

.meas tran vdout1_156ck710 FIND v(dout1_156) AT=360.025n

.meas tran vdout1_157ck710 FIND v(dout1_157) AT=360.025n

.meas tran vdout1_158ck710 FIND v(dout1_158) AT=360.025n

.meas tran vdout1_159ck710 FIND v(dout1_159) AT=360.025n

.meas tran vdout1_160ck710 FIND v(dout1_160) AT=360.025n

.meas tran vdout1_161ck710 FIND v(dout1_161) AT=360.025n

.meas tran vdout1_162ck710 FIND v(dout1_162) AT=360.025n

.meas tran vdout1_163ck710 FIND v(dout1_163) AT=360.025n

.meas tran vdout1_164ck710 FIND v(dout1_164) AT=360.025n

.meas tran vdout1_165ck710 FIND v(dout1_165) AT=360.025n

.meas tran vdout1_166ck710 FIND v(dout1_166) AT=360.025n

.meas tran vdout1_167ck710 FIND v(dout1_167) AT=360.025n

.meas tran vdout1_168ck710 FIND v(dout1_168) AT=360.025n

.meas tran vdout1_169ck710 FIND v(dout1_169) AT=360.025n

.meas tran vdout1_170ck710 FIND v(dout1_170) AT=360.025n

.meas tran vdout1_171ck710 FIND v(dout1_171) AT=360.025n

.meas tran vdout1_172ck710 FIND v(dout1_172) AT=360.025n

.meas tran vdout1_173ck710 FIND v(dout1_173) AT=360.025n

.meas tran vdout1_174ck710 FIND v(dout1_174) AT=360.025n

.meas tran vdout1_175ck710 FIND v(dout1_175) AT=360.025n

.meas tran vdout1_176ck710 FIND v(dout1_176) AT=360.025n

.meas tran vdout1_177ck710 FIND v(dout1_177) AT=360.025n

.meas tran vdout1_178ck710 FIND v(dout1_178) AT=360.025n

.meas tran vdout1_179ck710 FIND v(dout1_179) AT=360.025n

.meas tran vdout1_180ck710 FIND v(dout1_180) AT=360.025n

.meas tran vdout1_181ck710 FIND v(dout1_181) AT=360.025n

.meas tran vdout1_182ck710 FIND v(dout1_182) AT=360.025n

.meas tran vdout1_183ck710 FIND v(dout1_183) AT=360.025n

.meas tran vdout1_184ck710 FIND v(dout1_184) AT=360.025n

.meas tran vdout1_185ck710 FIND v(dout1_185) AT=360.025n

.meas tran vdout1_186ck710 FIND v(dout1_186) AT=360.025n

.meas tran vdout1_187ck710 FIND v(dout1_187) AT=360.025n

.meas tran vdout1_188ck710 FIND v(dout1_188) AT=360.025n

.meas tran vdout1_189ck710 FIND v(dout1_189) AT=360.025n

.meas tran vdout1_190ck710 FIND v(dout1_190) AT=360.025n

.meas tran vdout1_191ck710 FIND v(dout1_191) AT=360.025n

.meas tran vdout1_192ck710 FIND v(dout1_192) AT=360.025n

.meas tran vdout1_193ck710 FIND v(dout1_193) AT=360.025n

.meas tran vdout1_194ck710 FIND v(dout1_194) AT=360.025n

.meas tran vdout1_195ck710 FIND v(dout1_195) AT=360.025n

.meas tran vdout1_196ck710 FIND v(dout1_196) AT=360.025n

.meas tran vdout1_197ck710 FIND v(dout1_197) AT=360.025n

.meas tran vdout1_198ck710 FIND v(dout1_198) AT=360.025n

.meas tran vdout1_199ck710 FIND v(dout1_199) AT=360.025n

.meas tran vdout1_200ck710 FIND v(dout1_200) AT=360.025n

.meas tran vdout1_201ck710 FIND v(dout1_201) AT=360.025n

.meas tran vdout1_202ck710 FIND v(dout1_202) AT=360.025n

.meas tran vdout1_203ck710 FIND v(dout1_203) AT=360.025n

.meas tran vdout1_204ck710 FIND v(dout1_204) AT=360.025n

.meas tran vdout1_205ck710 FIND v(dout1_205) AT=360.025n

.meas tran vdout1_206ck710 FIND v(dout1_206) AT=360.025n

.meas tran vdout1_207ck710 FIND v(dout1_207) AT=360.025n

.meas tran vdout1_208ck710 FIND v(dout1_208) AT=360.025n

.meas tran vdout1_209ck710 FIND v(dout1_209) AT=360.025n

.meas tran vdout1_210ck710 FIND v(dout1_210) AT=360.025n

.meas tran vdout1_211ck710 FIND v(dout1_211) AT=360.025n

.meas tran vdout1_212ck710 FIND v(dout1_212) AT=360.025n

.meas tran vdout1_213ck710 FIND v(dout1_213) AT=360.025n

.meas tran vdout1_214ck710 FIND v(dout1_214) AT=360.025n

.meas tran vdout1_215ck710 FIND v(dout1_215) AT=360.025n

.meas tran vdout1_216ck710 FIND v(dout1_216) AT=360.025n

.meas tran vdout1_217ck710 FIND v(dout1_217) AT=360.025n

.meas tran vdout1_218ck710 FIND v(dout1_218) AT=360.025n

.meas tran vdout1_219ck710 FIND v(dout1_219) AT=360.025n

.meas tran vdout1_220ck710 FIND v(dout1_220) AT=360.025n

.meas tran vdout1_221ck710 FIND v(dout1_221) AT=360.025n

.meas tran vdout1_222ck710 FIND v(dout1_222) AT=360.025n

.meas tran vdout1_223ck710 FIND v(dout1_223) AT=360.025n

.meas tran vdout1_224ck710 FIND v(dout1_224) AT=360.025n

.meas tran vdout1_225ck710 FIND v(dout1_225) AT=360.025n

.meas tran vdout1_226ck710 FIND v(dout1_226) AT=360.025n

.meas tran vdout1_227ck710 FIND v(dout1_227) AT=360.025n

.meas tran vdout1_228ck710 FIND v(dout1_228) AT=360.025n

.meas tran vdout1_229ck710 FIND v(dout1_229) AT=360.025n

.meas tran vdout1_230ck710 FIND v(dout1_230) AT=360.025n

.meas tran vdout1_231ck710 FIND v(dout1_231) AT=360.025n

.meas tran vdout1_232ck710 FIND v(dout1_232) AT=360.025n

.meas tran vdout1_233ck710 FIND v(dout1_233) AT=360.025n

.meas tran vdout1_234ck710 FIND v(dout1_234) AT=360.025n

.meas tran vdout1_235ck710 FIND v(dout1_235) AT=360.025n

.meas tran vdout1_236ck710 FIND v(dout1_236) AT=360.025n

.meas tran vdout1_237ck710 FIND v(dout1_237) AT=360.025n

.meas tran vdout1_238ck710 FIND v(dout1_238) AT=360.025n

.meas tran vdout1_239ck710 FIND v(dout1_239) AT=360.025n

.meas tran vdout1_240ck710 FIND v(dout1_240) AT=360.025n

.meas tran vdout1_241ck710 FIND v(dout1_241) AT=360.025n

.meas tran vdout1_242ck710 FIND v(dout1_242) AT=360.025n

.meas tran vdout1_243ck710 FIND v(dout1_243) AT=360.025n

.meas tran vdout1_244ck710 FIND v(dout1_244) AT=360.025n

.meas tran vdout1_245ck710 FIND v(dout1_245) AT=360.025n

.meas tran vdout1_246ck710 FIND v(dout1_246) AT=360.025n

.meas tran vdout1_247ck710 FIND v(dout1_247) AT=360.025n

.meas tran vdout1_248ck710 FIND v(dout1_248) AT=360.025n

.meas tran vdout1_249ck710 FIND v(dout1_249) AT=360.025n

.meas tran vdout1_250ck710 FIND v(dout1_250) AT=360.025n

.meas tran vdout1_251ck710 FIND v(dout1_251) AT=360.025n

.meas tran vdout1_252ck710 FIND v(dout1_252) AT=360.025n

.meas tran vdout1_253ck710 FIND v(dout1_253) AT=360.025n

.meas tran vdout1_254ck710 FIND v(dout1_254) AT=360.025n

.meas tran vdout1_255ck710 FIND v(dout1_255) AT=360.025n

.meas tran vdout1_256ck710 FIND v(dout1_256) AT=360.025n

.meas tran vdout1_257ck710 FIND v(dout1_257) AT=360.025n

.meas tran vdout1_258ck710 FIND v(dout1_258) AT=360.025n

.meas tran vdout1_259ck710 FIND v(dout1_259) AT=360.025n

.meas tran vdout1_260ck710 FIND v(dout1_260) AT=360.025n

.meas tran vdout1_261ck710 FIND v(dout1_261) AT=360.025n

.meas tran vdout1_262ck710 FIND v(dout1_262) AT=360.025n

.meas tran vdout1_263ck710 FIND v(dout1_263) AT=360.025n

.meas tran vdout1_264ck710 FIND v(dout1_264) AT=360.025n

.meas tran vdout1_265ck710 FIND v(dout1_265) AT=360.025n

.meas tran vdout1_266ck710 FIND v(dout1_266) AT=360.025n

.meas tran vdout1_267ck710 FIND v(dout1_267) AT=360.025n

.meas tran vdout1_268ck710 FIND v(dout1_268) AT=360.025n

.meas tran vdout1_269ck710 FIND v(dout1_269) AT=360.025n

.meas tran vdout1_270ck710 FIND v(dout1_270) AT=360.025n

.meas tran vdout1_271ck710 FIND v(dout1_271) AT=360.025n

.meas tran vdout1_272ck710 FIND v(dout1_272) AT=360.025n

.meas tran vdout1_273ck710 FIND v(dout1_273) AT=360.025n

.meas tran vdout1_274ck710 FIND v(dout1_274) AT=360.025n

.meas tran vdout1_275ck710 FIND v(dout1_275) AT=360.025n

.meas tran vdout1_276ck710 FIND v(dout1_276) AT=360.025n

.meas tran vdout1_277ck710 FIND v(dout1_277) AT=360.025n

.meas tran vdout1_278ck710 FIND v(dout1_278) AT=360.025n

.meas tran vdout1_279ck710 FIND v(dout1_279) AT=360.025n

.meas tran vdout1_280ck710 FIND v(dout1_280) AT=360.025n

.meas tran vdout1_281ck710 FIND v(dout1_281) AT=360.025n

.meas tran vdout1_282ck710 FIND v(dout1_282) AT=360.025n

.meas tran vdout1_283ck710 FIND v(dout1_283) AT=360.025n

.meas tran vdout1_284ck710 FIND v(dout1_284) AT=360.025n

.meas tran vdout1_285ck710 FIND v(dout1_285) AT=360.025n

.meas tran vdout1_286ck710 FIND v(dout1_286) AT=360.025n

.meas tran vdout1_287ck710 FIND v(dout1_287) AT=360.025n

.meas tran vdout1_288ck710 FIND v(dout1_288) AT=360.025n

.meas tran vdout1_289ck710 FIND v(dout1_289) AT=360.025n

.meas tran vdout1_290ck710 FIND v(dout1_290) AT=360.025n

.meas tran vdout1_291ck710 FIND v(dout1_291) AT=360.025n

.meas tran vdout1_292ck710 FIND v(dout1_292) AT=360.025n

.meas tran vdout1_293ck710 FIND v(dout1_293) AT=360.025n

.meas tran vdout1_294ck710 FIND v(dout1_294) AT=360.025n

.meas tran vdout1_295ck710 FIND v(dout1_295) AT=360.025n

.meas tran vdout1_296ck710 FIND v(dout1_296) AT=360.025n

.meas tran vdout1_297ck710 FIND v(dout1_297) AT=360.025n

.meas tran vdout1_298ck710 FIND v(dout1_298) AT=360.025n

.meas tran vdout1_299ck710 FIND v(dout1_299) AT=360.025n

.meas tran vdout1_300ck710 FIND v(dout1_300) AT=360.025n

.meas tran vdout1_301ck710 FIND v(dout1_301) AT=360.025n

.meas tran vdout1_302ck710 FIND v(dout1_302) AT=360.025n

.meas tran vdout1_303ck710 FIND v(dout1_303) AT=360.025n

.meas tran vdout1_304ck710 FIND v(dout1_304) AT=360.025n

.meas tran vdout1_305ck710 FIND v(dout1_305) AT=360.025n

.meas tran vdout1_306ck710 FIND v(dout1_306) AT=360.025n

.meas tran vdout1_307ck710 FIND v(dout1_307) AT=360.025n

.meas tran vdout1_308ck710 FIND v(dout1_308) AT=360.025n

.meas tran vdout1_309ck710 FIND v(dout1_309) AT=360.025n

.meas tran vdout1_310ck710 FIND v(dout1_310) AT=360.025n

.meas tran vdout1_311ck710 FIND v(dout1_311) AT=360.025n

.meas tran vdout1_312ck710 FIND v(dout1_312) AT=360.025n

.meas tran vdout1_313ck710 FIND v(dout1_313) AT=360.025n

.meas tran vdout1_314ck710 FIND v(dout1_314) AT=360.025n

.meas tran vdout1_315ck710 FIND v(dout1_315) AT=360.025n

.meas tran vdout1_316ck710 FIND v(dout1_316) AT=360.025n

.meas tran vdout1_317ck710 FIND v(dout1_317) AT=360.025n

.meas tran vdout1_318ck710 FIND v(dout1_318) AT=360.025n

.meas tran vdout1_319ck710 FIND v(dout1_319) AT=360.025n

.meas tran vdout1_320ck710 FIND v(dout1_320) AT=360.025n

.meas tran vdout1_321ck710 FIND v(dout1_321) AT=360.025n

.meas tran vdout1_322ck710 FIND v(dout1_322) AT=360.025n

.meas tran vdout1_323ck710 FIND v(dout1_323) AT=360.025n

.meas tran vdout1_324ck710 FIND v(dout1_324) AT=360.025n

.meas tran vdout1_325ck710 FIND v(dout1_325) AT=360.025n

.meas tran vdout1_326ck710 FIND v(dout1_326) AT=360.025n

.meas tran vdout1_327ck710 FIND v(dout1_327) AT=360.025n

.meas tran vdout1_328ck710 FIND v(dout1_328) AT=360.025n

.meas tran vdout1_329ck710 FIND v(dout1_329) AT=360.025n

.meas tran vdout1_330ck710 FIND v(dout1_330) AT=360.025n

.meas tran vdout1_331ck710 FIND v(dout1_331) AT=360.025n

.meas tran vdout1_332ck710 FIND v(dout1_332) AT=360.025n

.meas tran vdout1_333ck710 FIND v(dout1_333) AT=360.025n

.meas tran vdout1_334ck710 FIND v(dout1_334) AT=360.025n

.meas tran vdout1_335ck710 FIND v(dout1_335) AT=360.025n

.meas tran vdout1_336ck710 FIND v(dout1_336) AT=360.025n

.meas tran vdout1_337ck710 FIND v(dout1_337) AT=360.025n

.meas tran vdout1_338ck710 FIND v(dout1_338) AT=360.025n

.meas tran vdout1_339ck710 FIND v(dout1_339) AT=360.025n

.meas tran vdout1_340ck710 FIND v(dout1_340) AT=360.025n

.meas tran vdout1_341ck710 FIND v(dout1_341) AT=360.025n

.meas tran vdout1_342ck710 FIND v(dout1_342) AT=360.025n

.meas tran vdout1_343ck710 FIND v(dout1_343) AT=360.025n

.meas tran vdout1_344ck710 FIND v(dout1_344) AT=360.025n

.meas tran vdout1_345ck710 FIND v(dout1_345) AT=360.025n

.meas tran vdout1_346ck710 FIND v(dout1_346) AT=360.025n

.meas tran vdout1_347ck710 FIND v(dout1_347) AT=360.025n

.meas tran vdout1_348ck710 FIND v(dout1_348) AT=360.025n

.meas tran vdout1_349ck710 FIND v(dout1_349) AT=360.025n

.meas tran vdout1_350ck710 FIND v(dout1_350) AT=360.025n

.meas tran vdout1_351ck710 FIND v(dout1_351) AT=360.025n

.meas tran vdout1_352ck710 FIND v(dout1_352) AT=360.025n

.meas tran vdout1_353ck710 FIND v(dout1_353) AT=360.025n

.meas tran vdout1_354ck710 FIND v(dout1_354) AT=360.025n

.meas tran vdout1_355ck710 FIND v(dout1_355) AT=360.025n

.meas tran vdout1_356ck710 FIND v(dout1_356) AT=360.025n

.meas tran vdout1_357ck710 FIND v(dout1_357) AT=360.025n

.meas tran vdout1_358ck710 FIND v(dout1_358) AT=360.025n

.meas tran vdout1_359ck710 FIND v(dout1_359) AT=360.025n

.meas tran vdout1_360ck710 FIND v(dout1_360) AT=360.025n

.meas tran vdout1_361ck710 FIND v(dout1_361) AT=360.025n

.meas tran vdout1_362ck710 FIND v(dout1_362) AT=360.025n

.meas tran vdout1_363ck710 FIND v(dout1_363) AT=360.025n

.meas tran vdout1_364ck710 FIND v(dout1_364) AT=360.025n

.meas tran vdout1_365ck710 FIND v(dout1_365) AT=360.025n

.meas tran vdout1_366ck710 FIND v(dout1_366) AT=360.025n

.meas tran vdout1_367ck710 FIND v(dout1_367) AT=360.025n

.meas tran vdout1_368ck710 FIND v(dout1_368) AT=360.025n

.meas tran vdout1_369ck710 FIND v(dout1_369) AT=360.025n

.meas tran vdout1_370ck710 FIND v(dout1_370) AT=360.025n

.meas tran vdout1_371ck710 FIND v(dout1_371) AT=360.025n

.meas tran vdout1_372ck710 FIND v(dout1_372) AT=360.025n

.meas tran vdout1_373ck710 FIND v(dout1_373) AT=360.025n

.meas tran vdout1_374ck710 FIND v(dout1_374) AT=360.025n

.meas tran vdout1_375ck710 FIND v(dout1_375) AT=360.025n

.meas tran vdout1_376ck710 FIND v(dout1_376) AT=360.025n

.meas tran vdout1_377ck710 FIND v(dout1_377) AT=360.025n

.meas tran vdout1_378ck710 FIND v(dout1_378) AT=360.025n

.meas tran vdout1_379ck710 FIND v(dout1_379) AT=360.025n

.meas tran vdout1_380ck710 FIND v(dout1_380) AT=360.025n

.meas tran vdout1_381ck710 FIND v(dout1_381) AT=360.025n

.meas tran vdout1_382ck710 FIND v(dout1_382) AT=360.025n

.meas tran vdout1_383ck710 FIND v(dout1_383) AT=360.025n

.meas tran vdout1_384ck710 FIND v(dout1_384) AT=360.025n

.meas tran vdout1_385ck710 FIND v(dout1_385) AT=360.025n

.meas tran vdout1_386ck710 FIND v(dout1_386) AT=360.025n

.meas tran vdout1_387ck710 FIND v(dout1_387) AT=360.025n

.meas tran vdout1_388ck710 FIND v(dout1_388) AT=360.025n

.meas tran vdout1_389ck710 FIND v(dout1_389) AT=360.025n

.meas tran vdout1_390ck710 FIND v(dout1_390) AT=360.025n

.meas tran vdout1_391ck710 FIND v(dout1_391) AT=360.025n

.meas tran vdout1_392ck710 FIND v(dout1_392) AT=360.025n

.meas tran vdout1_393ck710 FIND v(dout1_393) AT=360.025n

.meas tran vdout1_394ck710 FIND v(dout1_394) AT=360.025n

.meas tran vdout1_395ck710 FIND v(dout1_395) AT=360.025n

.meas tran vdout1_396ck710 FIND v(dout1_396) AT=360.025n

.meas tran vdout1_397ck710 FIND v(dout1_397) AT=360.025n

.meas tran vdout1_398ck710 FIND v(dout1_398) AT=360.025n

.meas tran vdout1_399ck710 FIND v(dout1_399) AT=360.025n

.meas tran vdout1_400ck710 FIND v(dout1_400) AT=360.025n

.meas tran vdout1_401ck710 FIND v(dout1_401) AT=360.025n

.meas tran vdout1_402ck710 FIND v(dout1_402) AT=360.025n

.meas tran vdout1_403ck710 FIND v(dout1_403) AT=360.025n

.meas tran vdout1_404ck710 FIND v(dout1_404) AT=360.025n

.meas tran vdout1_405ck710 FIND v(dout1_405) AT=360.025n

.meas tran vdout1_406ck710 FIND v(dout1_406) AT=360.025n

.meas tran vdout1_407ck710 FIND v(dout1_407) AT=360.025n

.meas tran vdout1_408ck710 FIND v(dout1_408) AT=360.025n

.meas tran vdout1_409ck710 FIND v(dout1_409) AT=360.025n

.meas tran vdout1_410ck710 FIND v(dout1_410) AT=360.025n

.meas tran vdout1_411ck710 FIND v(dout1_411) AT=360.025n

.meas tran vdout1_412ck710 FIND v(dout1_412) AT=360.025n

.meas tran vdout1_413ck710 FIND v(dout1_413) AT=360.025n

.meas tran vdout1_414ck710 FIND v(dout1_414) AT=360.025n

.meas tran vdout1_415ck710 FIND v(dout1_415) AT=360.025n

.meas tran vdout1_416ck710 FIND v(dout1_416) AT=360.025n

.meas tran vdout1_417ck710 FIND v(dout1_417) AT=360.025n

.meas tran vdout1_418ck710 FIND v(dout1_418) AT=360.025n

.meas tran vdout1_419ck710 FIND v(dout1_419) AT=360.025n

.meas tran vdout1_420ck710 FIND v(dout1_420) AT=360.025n

.meas tran vdout1_421ck710 FIND v(dout1_421) AT=360.025n

.meas tran vdout1_422ck710 FIND v(dout1_422) AT=360.025n

.meas tran vdout1_423ck710 FIND v(dout1_423) AT=360.025n

.meas tran vdout1_424ck710 FIND v(dout1_424) AT=360.025n

.meas tran vdout1_425ck710 FIND v(dout1_425) AT=360.025n

.meas tran vdout1_426ck710 FIND v(dout1_426) AT=360.025n

.meas tran vdout1_427ck710 FIND v(dout1_427) AT=360.025n

.meas tran vdout1_428ck710 FIND v(dout1_428) AT=360.025n

.meas tran vdout1_429ck710 FIND v(dout1_429) AT=360.025n

.meas tran vdout1_430ck710 FIND v(dout1_430) AT=360.025n

.meas tran vdout1_431ck710 FIND v(dout1_431) AT=360.025n

.meas tran vdout1_432ck710 FIND v(dout1_432) AT=360.025n

.meas tran vdout1_433ck710 FIND v(dout1_433) AT=360.025n

.meas tran vdout1_434ck710 FIND v(dout1_434) AT=360.025n

.meas tran vdout1_435ck710 FIND v(dout1_435) AT=360.025n

.meas tran vdout1_436ck710 FIND v(dout1_436) AT=360.025n

.meas tran vdout1_437ck710 FIND v(dout1_437) AT=360.025n

.meas tran vdout1_438ck710 FIND v(dout1_438) AT=360.025n

.meas tran vdout1_439ck710 FIND v(dout1_439) AT=360.025n

.meas tran vdout1_440ck710 FIND v(dout1_440) AT=360.025n

.meas tran vdout1_441ck710 FIND v(dout1_441) AT=360.025n

.meas tran vdout1_442ck710 FIND v(dout1_442) AT=360.025n

.meas tran vdout1_443ck710 FIND v(dout1_443) AT=360.025n

.meas tran vdout1_444ck710 FIND v(dout1_444) AT=360.025n

.meas tran vdout1_445ck710 FIND v(dout1_445) AT=360.025n

.meas tran vdout1_446ck710 FIND v(dout1_446) AT=360.025n

.meas tran vdout1_447ck710 FIND v(dout1_447) AT=360.025n

.meas tran vdout1_448ck710 FIND v(dout1_448) AT=360.025n

.meas tran vdout1_449ck710 FIND v(dout1_449) AT=360.025n

.meas tran vdout1_450ck710 FIND v(dout1_450) AT=360.025n

.meas tran vdout1_451ck710 FIND v(dout1_451) AT=360.025n

.meas tran vdout1_452ck710 FIND v(dout1_452) AT=360.025n

.meas tran vdout1_453ck710 FIND v(dout1_453) AT=360.025n

.meas tran vdout1_454ck710 FIND v(dout1_454) AT=360.025n

.meas tran vdout1_455ck710 FIND v(dout1_455) AT=360.025n

.meas tran vdout1_456ck710 FIND v(dout1_456) AT=360.025n

.meas tran vdout1_457ck710 FIND v(dout1_457) AT=360.025n

.meas tran vdout1_458ck710 FIND v(dout1_458) AT=360.025n

.meas tran vdout1_459ck710 FIND v(dout1_459) AT=360.025n

.meas tran vdout1_460ck710 FIND v(dout1_460) AT=360.025n

.meas tran vdout1_461ck710 FIND v(dout1_461) AT=360.025n

.meas tran vdout1_462ck710 FIND v(dout1_462) AT=360.025n

.meas tran vdout1_463ck710 FIND v(dout1_463) AT=360.025n

.meas tran vdout1_464ck710 FIND v(dout1_464) AT=360.025n

.meas tran vdout1_465ck710 FIND v(dout1_465) AT=360.025n

.meas tran vdout1_466ck710 FIND v(dout1_466) AT=360.025n

.meas tran vdout1_467ck710 FIND v(dout1_467) AT=360.025n

.meas tran vdout1_468ck710 FIND v(dout1_468) AT=360.025n

.meas tran vdout1_469ck710 FIND v(dout1_469) AT=360.025n

.meas tran vdout1_470ck710 FIND v(dout1_470) AT=360.025n

.meas tran vdout1_471ck710 FIND v(dout1_471) AT=360.025n

.meas tran vdout1_472ck710 FIND v(dout1_472) AT=360.025n

.meas tran vdout1_473ck710 FIND v(dout1_473) AT=360.025n

.meas tran vdout1_474ck710 FIND v(dout1_474) AT=360.025n

.meas tran vdout1_475ck710 FIND v(dout1_475) AT=360.025n

.meas tran vdout1_476ck710 FIND v(dout1_476) AT=360.025n

.meas tran vdout1_477ck710 FIND v(dout1_477) AT=360.025n

.meas tran vdout1_478ck710 FIND v(dout1_478) AT=360.025n

.meas tran vdout1_479ck710 FIND v(dout1_479) AT=360.025n

.meas tran vdout1_480ck710 FIND v(dout1_480) AT=360.025n

.meas tran vdout1_481ck710 FIND v(dout1_481) AT=360.025n

.meas tran vdout1_482ck710 FIND v(dout1_482) AT=360.025n

.meas tran vdout1_483ck710 FIND v(dout1_483) AT=360.025n

.meas tran vdout1_484ck710 FIND v(dout1_484) AT=360.025n

.meas tran vdout1_485ck710 FIND v(dout1_485) AT=360.025n

.meas tran vdout1_486ck710 FIND v(dout1_486) AT=360.025n

.meas tran vdout1_487ck710 FIND v(dout1_487) AT=360.025n

.meas tran vdout1_488ck710 FIND v(dout1_488) AT=360.025n

.meas tran vdout1_489ck710 FIND v(dout1_489) AT=360.025n

.meas tran vdout1_490ck710 FIND v(dout1_490) AT=360.025n

.meas tran vdout1_491ck710 FIND v(dout1_491) AT=360.025n

.meas tran vdout1_492ck710 FIND v(dout1_492) AT=360.025n

.meas tran vdout1_493ck710 FIND v(dout1_493) AT=360.025n

.meas tran vdout1_494ck710 FIND v(dout1_494) AT=360.025n

.meas tran vdout1_495ck710 FIND v(dout1_495) AT=360.025n

.meas tran vdout1_496ck710 FIND v(dout1_496) AT=360.025n

.meas tran vdout1_497ck710 FIND v(dout1_497) AT=360.025n

.meas tran vdout1_498ck710 FIND v(dout1_498) AT=360.025n

.meas tran vdout1_499ck710 FIND v(dout1_499) AT=360.025n

.meas tran vdout1_500ck710 FIND v(dout1_500) AT=360.025n

.meas tran vdout1_501ck710 FIND v(dout1_501) AT=360.025n

.meas tran vdout1_502ck710 FIND v(dout1_502) AT=360.025n

.meas tran vdout1_503ck710 FIND v(dout1_503) AT=360.025n

.meas tran vdout1_504ck710 FIND v(dout1_504) AT=360.025n

.meas tran vdout1_505ck710 FIND v(dout1_505) AT=360.025n

.meas tran vdout1_506ck710 FIND v(dout1_506) AT=360.025n

.meas tran vdout1_507ck710 FIND v(dout1_507) AT=360.025n

.meas tran vdout1_508ck710 FIND v(dout1_508) AT=360.025n

.meas tran vdout1_509ck710 FIND v(dout1_509) AT=360.025n

.meas tran vdout1_510ck710 FIND v(dout1_510) AT=360.025n

.meas tran vdout1_511ck710 FIND v(dout1_511) AT=360.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_8ck800 FIND v(dout1_8) AT=405.025n

.meas tran vdout1_9ck800 FIND v(dout1_9) AT=405.025n

.meas tran vdout1_10ck800 FIND v(dout1_10) AT=405.025n

.meas tran vdout1_11ck800 FIND v(dout1_11) AT=405.025n

.meas tran vdout1_12ck800 FIND v(dout1_12) AT=405.025n

.meas tran vdout1_13ck800 FIND v(dout1_13) AT=405.025n

.meas tran vdout1_14ck800 FIND v(dout1_14) AT=405.025n

.meas tran vdout1_15ck800 FIND v(dout1_15) AT=405.025n

.meas tran vdout1_16ck800 FIND v(dout1_16) AT=405.025n

.meas tran vdout1_17ck800 FIND v(dout1_17) AT=405.025n

.meas tran vdout1_18ck800 FIND v(dout1_18) AT=405.025n

.meas tran vdout1_19ck800 FIND v(dout1_19) AT=405.025n

.meas tran vdout1_20ck800 FIND v(dout1_20) AT=405.025n

.meas tran vdout1_21ck800 FIND v(dout1_21) AT=405.025n

.meas tran vdout1_22ck800 FIND v(dout1_22) AT=405.025n

.meas tran vdout1_23ck800 FIND v(dout1_23) AT=405.025n

.meas tran vdout1_24ck800 FIND v(dout1_24) AT=405.025n

.meas tran vdout1_25ck800 FIND v(dout1_25) AT=405.025n

.meas tran vdout1_26ck800 FIND v(dout1_26) AT=405.025n

.meas tran vdout1_27ck800 FIND v(dout1_27) AT=405.025n

.meas tran vdout1_28ck800 FIND v(dout1_28) AT=405.025n

.meas tran vdout1_29ck800 FIND v(dout1_29) AT=405.025n

.meas tran vdout1_30ck800 FIND v(dout1_30) AT=405.025n

.meas tran vdout1_31ck800 FIND v(dout1_31) AT=405.025n

.meas tran vdout1_32ck800 FIND v(dout1_32) AT=405.025n

.meas tran vdout1_33ck800 FIND v(dout1_33) AT=405.025n

.meas tran vdout1_34ck800 FIND v(dout1_34) AT=405.025n

.meas tran vdout1_35ck800 FIND v(dout1_35) AT=405.025n

.meas tran vdout1_36ck800 FIND v(dout1_36) AT=405.025n

.meas tran vdout1_37ck800 FIND v(dout1_37) AT=405.025n

.meas tran vdout1_38ck800 FIND v(dout1_38) AT=405.025n

.meas tran vdout1_39ck800 FIND v(dout1_39) AT=405.025n

.meas tran vdout1_40ck800 FIND v(dout1_40) AT=405.025n

.meas tran vdout1_41ck800 FIND v(dout1_41) AT=405.025n

.meas tran vdout1_42ck800 FIND v(dout1_42) AT=405.025n

.meas tran vdout1_43ck800 FIND v(dout1_43) AT=405.025n

.meas tran vdout1_44ck800 FIND v(dout1_44) AT=405.025n

.meas tran vdout1_45ck800 FIND v(dout1_45) AT=405.025n

.meas tran vdout1_46ck800 FIND v(dout1_46) AT=405.025n

.meas tran vdout1_47ck800 FIND v(dout1_47) AT=405.025n

.meas tran vdout1_48ck800 FIND v(dout1_48) AT=405.025n

.meas tran vdout1_49ck800 FIND v(dout1_49) AT=405.025n

.meas tran vdout1_50ck800 FIND v(dout1_50) AT=405.025n

.meas tran vdout1_51ck800 FIND v(dout1_51) AT=405.025n

.meas tran vdout1_52ck800 FIND v(dout1_52) AT=405.025n

.meas tran vdout1_53ck800 FIND v(dout1_53) AT=405.025n

.meas tran vdout1_54ck800 FIND v(dout1_54) AT=405.025n

.meas tran vdout1_55ck800 FIND v(dout1_55) AT=405.025n

.meas tran vdout1_56ck800 FIND v(dout1_56) AT=405.025n

.meas tran vdout1_57ck800 FIND v(dout1_57) AT=405.025n

.meas tran vdout1_58ck800 FIND v(dout1_58) AT=405.025n

.meas tran vdout1_59ck800 FIND v(dout1_59) AT=405.025n

.meas tran vdout1_60ck800 FIND v(dout1_60) AT=405.025n

.meas tran vdout1_61ck800 FIND v(dout1_61) AT=405.025n

.meas tran vdout1_62ck800 FIND v(dout1_62) AT=405.025n

.meas tran vdout1_63ck800 FIND v(dout1_63) AT=405.025n

.meas tran vdout1_64ck800 FIND v(dout1_64) AT=405.025n

.meas tran vdout1_65ck800 FIND v(dout1_65) AT=405.025n

.meas tran vdout1_66ck800 FIND v(dout1_66) AT=405.025n

.meas tran vdout1_67ck800 FIND v(dout1_67) AT=405.025n

.meas tran vdout1_68ck800 FIND v(dout1_68) AT=405.025n

.meas tran vdout1_69ck800 FIND v(dout1_69) AT=405.025n

.meas tran vdout1_70ck800 FIND v(dout1_70) AT=405.025n

.meas tran vdout1_71ck800 FIND v(dout1_71) AT=405.025n

.meas tran vdout1_72ck800 FIND v(dout1_72) AT=405.025n

.meas tran vdout1_73ck800 FIND v(dout1_73) AT=405.025n

.meas tran vdout1_74ck800 FIND v(dout1_74) AT=405.025n

.meas tran vdout1_75ck800 FIND v(dout1_75) AT=405.025n

.meas tran vdout1_76ck800 FIND v(dout1_76) AT=405.025n

.meas tran vdout1_77ck800 FIND v(dout1_77) AT=405.025n

.meas tran vdout1_78ck800 FIND v(dout1_78) AT=405.025n

.meas tran vdout1_79ck800 FIND v(dout1_79) AT=405.025n

.meas tran vdout1_80ck800 FIND v(dout1_80) AT=405.025n

.meas tran vdout1_81ck800 FIND v(dout1_81) AT=405.025n

.meas tran vdout1_82ck800 FIND v(dout1_82) AT=405.025n

.meas tran vdout1_83ck800 FIND v(dout1_83) AT=405.025n

.meas tran vdout1_84ck800 FIND v(dout1_84) AT=405.025n

.meas tran vdout1_85ck800 FIND v(dout1_85) AT=405.025n

.meas tran vdout1_86ck800 FIND v(dout1_86) AT=405.025n

.meas tran vdout1_87ck800 FIND v(dout1_87) AT=405.025n

.meas tran vdout1_88ck800 FIND v(dout1_88) AT=405.025n

.meas tran vdout1_89ck800 FIND v(dout1_89) AT=405.025n

.meas tran vdout1_90ck800 FIND v(dout1_90) AT=405.025n

.meas tran vdout1_91ck800 FIND v(dout1_91) AT=405.025n

.meas tran vdout1_92ck800 FIND v(dout1_92) AT=405.025n

.meas tran vdout1_93ck800 FIND v(dout1_93) AT=405.025n

.meas tran vdout1_94ck800 FIND v(dout1_94) AT=405.025n

.meas tran vdout1_95ck800 FIND v(dout1_95) AT=405.025n

.meas tran vdout1_96ck800 FIND v(dout1_96) AT=405.025n

.meas tran vdout1_97ck800 FIND v(dout1_97) AT=405.025n

.meas tran vdout1_98ck800 FIND v(dout1_98) AT=405.025n

.meas tran vdout1_99ck800 FIND v(dout1_99) AT=405.025n

.meas tran vdout1_100ck800 FIND v(dout1_100) AT=405.025n

.meas tran vdout1_101ck800 FIND v(dout1_101) AT=405.025n

.meas tran vdout1_102ck800 FIND v(dout1_102) AT=405.025n

.meas tran vdout1_103ck800 FIND v(dout1_103) AT=405.025n

.meas tran vdout1_104ck800 FIND v(dout1_104) AT=405.025n

.meas tran vdout1_105ck800 FIND v(dout1_105) AT=405.025n

.meas tran vdout1_106ck800 FIND v(dout1_106) AT=405.025n

.meas tran vdout1_107ck800 FIND v(dout1_107) AT=405.025n

.meas tran vdout1_108ck800 FIND v(dout1_108) AT=405.025n

.meas tran vdout1_109ck800 FIND v(dout1_109) AT=405.025n

.meas tran vdout1_110ck800 FIND v(dout1_110) AT=405.025n

.meas tran vdout1_111ck800 FIND v(dout1_111) AT=405.025n

.meas tran vdout1_112ck800 FIND v(dout1_112) AT=405.025n

.meas tran vdout1_113ck800 FIND v(dout1_113) AT=405.025n

.meas tran vdout1_114ck800 FIND v(dout1_114) AT=405.025n

.meas tran vdout1_115ck800 FIND v(dout1_115) AT=405.025n

.meas tran vdout1_116ck800 FIND v(dout1_116) AT=405.025n

.meas tran vdout1_117ck800 FIND v(dout1_117) AT=405.025n

.meas tran vdout1_118ck800 FIND v(dout1_118) AT=405.025n

.meas tran vdout1_119ck800 FIND v(dout1_119) AT=405.025n

.meas tran vdout1_120ck800 FIND v(dout1_120) AT=405.025n

.meas tran vdout1_121ck800 FIND v(dout1_121) AT=405.025n

.meas tran vdout1_122ck800 FIND v(dout1_122) AT=405.025n

.meas tran vdout1_123ck800 FIND v(dout1_123) AT=405.025n

.meas tran vdout1_124ck800 FIND v(dout1_124) AT=405.025n

.meas tran vdout1_125ck800 FIND v(dout1_125) AT=405.025n

.meas tran vdout1_126ck800 FIND v(dout1_126) AT=405.025n

.meas tran vdout1_127ck800 FIND v(dout1_127) AT=405.025n

.meas tran vdout1_128ck800 FIND v(dout1_128) AT=405.025n

.meas tran vdout1_129ck800 FIND v(dout1_129) AT=405.025n

.meas tran vdout1_130ck800 FIND v(dout1_130) AT=405.025n

.meas tran vdout1_131ck800 FIND v(dout1_131) AT=405.025n

.meas tran vdout1_132ck800 FIND v(dout1_132) AT=405.025n

.meas tran vdout1_133ck800 FIND v(dout1_133) AT=405.025n

.meas tran vdout1_134ck800 FIND v(dout1_134) AT=405.025n

.meas tran vdout1_135ck800 FIND v(dout1_135) AT=405.025n

.meas tran vdout1_136ck800 FIND v(dout1_136) AT=405.025n

.meas tran vdout1_137ck800 FIND v(dout1_137) AT=405.025n

.meas tran vdout1_138ck800 FIND v(dout1_138) AT=405.025n

.meas tran vdout1_139ck800 FIND v(dout1_139) AT=405.025n

.meas tran vdout1_140ck800 FIND v(dout1_140) AT=405.025n

.meas tran vdout1_141ck800 FIND v(dout1_141) AT=405.025n

.meas tran vdout1_142ck800 FIND v(dout1_142) AT=405.025n

.meas tran vdout1_143ck800 FIND v(dout1_143) AT=405.025n

.meas tran vdout1_144ck800 FIND v(dout1_144) AT=405.025n

.meas tran vdout1_145ck800 FIND v(dout1_145) AT=405.025n

.meas tran vdout1_146ck800 FIND v(dout1_146) AT=405.025n

.meas tran vdout1_147ck800 FIND v(dout1_147) AT=405.025n

.meas tran vdout1_148ck800 FIND v(dout1_148) AT=405.025n

.meas tran vdout1_149ck800 FIND v(dout1_149) AT=405.025n

.meas tran vdout1_150ck800 FIND v(dout1_150) AT=405.025n

.meas tran vdout1_151ck800 FIND v(dout1_151) AT=405.025n

.meas tran vdout1_152ck800 FIND v(dout1_152) AT=405.025n

.meas tran vdout1_153ck800 FIND v(dout1_153) AT=405.025n

.meas tran vdout1_154ck800 FIND v(dout1_154) AT=405.025n

.meas tran vdout1_155ck800 FIND v(dout1_155) AT=405.025n

.meas tran vdout1_156ck800 FIND v(dout1_156) AT=405.025n

.meas tran vdout1_157ck800 FIND v(dout1_157) AT=405.025n

.meas tran vdout1_158ck800 FIND v(dout1_158) AT=405.025n

.meas tran vdout1_159ck800 FIND v(dout1_159) AT=405.025n

.meas tran vdout1_160ck800 FIND v(dout1_160) AT=405.025n

.meas tran vdout1_161ck800 FIND v(dout1_161) AT=405.025n

.meas tran vdout1_162ck800 FIND v(dout1_162) AT=405.025n

.meas tran vdout1_163ck800 FIND v(dout1_163) AT=405.025n

.meas tran vdout1_164ck800 FIND v(dout1_164) AT=405.025n

.meas tran vdout1_165ck800 FIND v(dout1_165) AT=405.025n

.meas tran vdout1_166ck800 FIND v(dout1_166) AT=405.025n

.meas tran vdout1_167ck800 FIND v(dout1_167) AT=405.025n

.meas tran vdout1_168ck800 FIND v(dout1_168) AT=405.025n

.meas tran vdout1_169ck800 FIND v(dout1_169) AT=405.025n

.meas tran vdout1_170ck800 FIND v(dout1_170) AT=405.025n

.meas tran vdout1_171ck800 FIND v(dout1_171) AT=405.025n

.meas tran vdout1_172ck800 FIND v(dout1_172) AT=405.025n

.meas tran vdout1_173ck800 FIND v(dout1_173) AT=405.025n

.meas tran vdout1_174ck800 FIND v(dout1_174) AT=405.025n

.meas tran vdout1_175ck800 FIND v(dout1_175) AT=405.025n

.meas tran vdout1_176ck800 FIND v(dout1_176) AT=405.025n

.meas tran vdout1_177ck800 FIND v(dout1_177) AT=405.025n

.meas tran vdout1_178ck800 FIND v(dout1_178) AT=405.025n

.meas tran vdout1_179ck800 FIND v(dout1_179) AT=405.025n

.meas tran vdout1_180ck800 FIND v(dout1_180) AT=405.025n

.meas tran vdout1_181ck800 FIND v(dout1_181) AT=405.025n

.meas tran vdout1_182ck800 FIND v(dout1_182) AT=405.025n

.meas tran vdout1_183ck800 FIND v(dout1_183) AT=405.025n

.meas tran vdout1_184ck800 FIND v(dout1_184) AT=405.025n

.meas tran vdout1_185ck800 FIND v(dout1_185) AT=405.025n

.meas tran vdout1_186ck800 FIND v(dout1_186) AT=405.025n

.meas tran vdout1_187ck800 FIND v(dout1_187) AT=405.025n

.meas tran vdout1_188ck800 FIND v(dout1_188) AT=405.025n

.meas tran vdout1_189ck800 FIND v(dout1_189) AT=405.025n

.meas tran vdout1_190ck800 FIND v(dout1_190) AT=405.025n

.meas tran vdout1_191ck800 FIND v(dout1_191) AT=405.025n

.meas tran vdout1_192ck800 FIND v(dout1_192) AT=405.025n

.meas tran vdout1_193ck800 FIND v(dout1_193) AT=405.025n

.meas tran vdout1_194ck800 FIND v(dout1_194) AT=405.025n

.meas tran vdout1_195ck800 FIND v(dout1_195) AT=405.025n

.meas tran vdout1_196ck800 FIND v(dout1_196) AT=405.025n

.meas tran vdout1_197ck800 FIND v(dout1_197) AT=405.025n

.meas tran vdout1_198ck800 FIND v(dout1_198) AT=405.025n

.meas tran vdout1_199ck800 FIND v(dout1_199) AT=405.025n

.meas tran vdout1_200ck800 FIND v(dout1_200) AT=405.025n

.meas tran vdout1_201ck800 FIND v(dout1_201) AT=405.025n

.meas tran vdout1_202ck800 FIND v(dout1_202) AT=405.025n

.meas tran vdout1_203ck800 FIND v(dout1_203) AT=405.025n

.meas tran vdout1_204ck800 FIND v(dout1_204) AT=405.025n

.meas tran vdout1_205ck800 FIND v(dout1_205) AT=405.025n

.meas tran vdout1_206ck800 FIND v(dout1_206) AT=405.025n

.meas tran vdout1_207ck800 FIND v(dout1_207) AT=405.025n

.meas tran vdout1_208ck800 FIND v(dout1_208) AT=405.025n

.meas tran vdout1_209ck800 FIND v(dout1_209) AT=405.025n

.meas tran vdout1_210ck800 FIND v(dout1_210) AT=405.025n

.meas tran vdout1_211ck800 FIND v(dout1_211) AT=405.025n

.meas tran vdout1_212ck800 FIND v(dout1_212) AT=405.025n

.meas tran vdout1_213ck800 FIND v(dout1_213) AT=405.025n

.meas tran vdout1_214ck800 FIND v(dout1_214) AT=405.025n

.meas tran vdout1_215ck800 FIND v(dout1_215) AT=405.025n

.meas tran vdout1_216ck800 FIND v(dout1_216) AT=405.025n

.meas tran vdout1_217ck800 FIND v(dout1_217) AT=405.025n

.meas tran vdout1_218ck800 FIND v(dout1_218) AT=405.025n

.meas tran vdout1_219ck800 FIND v(dout1_219) AT=405.025n

.meas tran vdout1_220ck800 FIND v(dout1_220) AT=405.025n

.meas tran vdout1_221ck800 FIND v(dout1_221) AT=405.025n

.meas tran vdout1_222ck800 FIND v(dout1_222) AT=405.025n

.meas tran vdout1_223ck800 FIND v(dout1_223) AT=405.025n

.meas tran vdout1_224ck800 FIND v(dout1_224) AT=405.025n

.meas tran vdout1_225ck800 FIND v(dout1_225) AT=405.025n

.meas tran vdout1_226ck800 FIND v(dout1_226) AT=405.025n

.meas tran vdout1_227ck800 FIND v(dout1_227) AT=405.025n

.meas tran vdout1_228ck800 FIND v(dout1_228) AT=405.025n

.meas tran vdout1_229ck800 FIND v(dout1_229) AT=405.025n

.meas tran vdout1_230ck800 FIND v(dout1_230) AT=405.025n

.meas tran vdout1_231ck800 FIND v(dout1_231) AT=405.025n

.meas tran vdout1_232ck800 FIND v(dout1_232) AT=405.025n

.meas tran vdout1_233ck800 FIND v(dout1_233) AT=405.025n

.meas tran vdout1_234ck800 FIND v(dout1_234) AT=405.025n

.meas tran vdout1_235ck800 FIND v(dout1_235) AT=405.025n

.meas tran vdout1_236ck800 FIND v(dout1_236) AT=405.025n

.meas tran vdout1_237ck800 FIND v(dout1_237) AT=405.025n

.meas tran vdout1_238ck800 FIND v(dout1_238) AT=405.025n

.meas tran vdout1_239ck800 FIND v(dout1_239) AT=405.025n

.meas tran vdout1_240ck800 FIND v(dout1_240) AT=405.025n

.meas tran vdout1_241ck800 FIND v(dout1_241) AT=405.025n

.meas tran vdout1_242ck800 FIND v(dout1_242) AT=405.025n

.meas tran vdout1_243ck800 FIND v(dout1_243) AT=405.025n

.meas tran vdout1_244ck800 FIND v(dout1_244) AT=405.025n

.meas tran vdout1_245ck800 FIND v(dout1_245) AT=405.025n

.meas tran vdout1_246ck800 FIND v(dout1_246) AT=405.025n

.meas tran vdout1_247ck800 FIND v(dout1_247) AT=405.025n

.meas tran vdout1_248ck800 FIND v(dout1_248) AT=405.025n

.meas tran vdout1_249ck800 FIND v(dout1_249) AT=405.025n

.meas tran vdout1_250ck800 FIND v(dout1_250) AT=405.025n

.meas tran vdout1_251ck800 FIND v(dout1_251) AT=405.025n

.meas tran vdout1_252ck800 FIND v(dout1_252) AT=405.025n

.meas tran vdout1_253ck800 FIND v(dout1_253) AT=405.025n

.meas tran vdout1_254ck800 FIND v(dout1_254) AT=405.025n

.meas tran vdout1_255ck800 FIND v(dout1_255) AT=405.025n

.meas tran vdout1_256ck800 FIND v(dout1_256) AT=405.025n

.meas tran vdout1_257ck800 FIND v(dout1_257) AT=405.025n

.meas tran vdout1_258ck800 FIND v(dout1_258) AT=405.025n

.meas tran vdout1_259ck800 FIND v(dout1_259) AT=405.025n

.meas tran vdout1_260ck800 FIND v(dout1_260) AT=405.025n

.meas tran vdout1_261ck800 FIND v(dout1_261) AT=405.025n

.meas tran vdout1_262ck800 FIND v(dout1_262) AT=405.025n

.meas tran vdout1_263ck800 FIND v(dout1_263) AT=405.025n

.meas tran vdout1_264ck800 FIND v(dout1_264) AT=405.025n

.meas tran vdout1_265ck800 FIND v(dout1_265) AT=405.025n

.meas tran vdout1_266ck800 FIND v(dout1_266) AT=405.025n

.meas tran vdout1_267ck800 FIND v(dout1_267) AT=405.025n

.meas tran vdout1_268ck800 FIND v(dout1_268) AT=405.025n

.meas tran vdout1_269ck800 FIND v(dout1_269) AT=405.025n

.meas tran vdout1_270ck800 FIND v(dout1_270) AT=405.025n

.meas tran vdout1_271ck800 FIND v(dout1_271) AT=405.025n

.meas tran vdout1_272ck800 FIND v(dout1_272) AT=405.025n

.meas tran vdout1_273ck800 FIND v(dout1_273) AT=405.025n

.meas tran vdout1_274ck800 FIND v(dout1_274) AT=405.025n

.meas tran vdout1_275ck800 FIND v(dout1_275) AT=405.025n

.meas tran vdout1_276ck800 FIND v(dout1_276) AT=405.025n

.meas tran vdout1_277ck800 FIND v(dout1_277) AT=405.025n

.meas tran vdout1_278ck800 FIND v(dout1_278) AT=405.025n

.meas tran vdout1_279ck800 FIND v(dout1_279) AT=405.025n

.meas tran vdout1_280ck800 FIND v(dout1_280) AT=405.025n

.meas tran vdout1_281ck800 FIND v(dout1_281) AT=405.025n

.meas tran vdout1_282ck800 FIND v(dout1_282) AT=405.025n

.meas tran vdout1_283ck800 FIND v(dout1_283) AT=405.025n

.meas tran vdout1_284ck800 FIND v(dout1_284) AT=405.025n

.meas tran vdout1_285ck800 FIND v(dout1_285) AT=405.025n

.meas tran vdout1_286ck800 FIND v(dout1_286) AT=405.025n

.meas tran vdout1_287ck800 FIND v(dout1_287) AT=405.025n

.meas tran vdout1_288ck800 FIND v(dout1_288) AT=405.025n

.meas tran vdout1_289ck800 FIND v(dout1_289) AT=405.025n

.meas tran vdout1_290ck800 FIND v(dout1_290) AT=405.025n

.meas tran vdout1_291ck800 FIND v(dout1_291) AT=405.025n

.meas tran vdout1_292ck800 FIND v(dout1_292) AT=405.025n

.meas tran vdout1_293ck800 FIND v(dout1_293) AT=405.025n

.meas tran vdout1_294ck800 FIND v(dout1_294) AT=405.025n

.meas tran vdout1_295ck800 FIND v(dout1_295) AT=405.025n

.meas tran vdout1_296ck800 FIND v(dout1_296) AT=405.025n

.meas tran vdout1_297ck800 FIND v(dout1_297) AT=405.025n

.meas tran vdout1_298ck800 FIND v(dout1_298) AT=405.025n

.meas tran vdout1_299ck800 FIND v(dout1_299) AT=405.025n

.meas tran vdout1_300ck800 FIND v(dout1_300) AT=405.025n

.meas tran vdout1_301ck800 FIND v(dout1_301) AT=405.025n

.meas tran vdout1_302ck800 FIND v(dout1_302) AT=405.025n

.meas tran vdout1_303ck800 FIND v(dout1_303) AT=405.025n

.meas tran vdout1_304ck800 FIND v(dout1_304) AT=405.025n

.meas tran vdout1_305ck800 FIND v(dout1_305) AT=405.025n

.meas tran vdout1_306ck800 FIND v(dout1_306) AT=405.025n

.meas tran vdout1_307ck800 FIND v(dout1_307) AT=405.025n

.meas tran vdout1_308ck800 FIND v(dout1_308) AT=405.025n

.meas tran vdout1_309ck800 FIND v(dout1_309) AT=405.025n

.meas tran vdout1_310ck800 FIND v(dout1_310) AT=405.025n

.meas tran vdout1_311ck800 FIND v(dout1_311) AT=405.025n

.meas tran vdout1_312ck800 FIND v(dout1_312) AT=405.025n

.meas tran vdout1_313ck800 FIND v(dout1_313) AT=405.025n

.meas tran vdout1_314ck800 FIND v(dout1_314) AT=405.025n

.meas tran vdout1_315ck800 FIND v(dout1_315) AT=405.025n

.meas tran vdout1_316ck800 FIND v(dout1_316) AT=405.025n

.meas tran vdout1_317ck800 FIND v(dout1_317) AT=405.025n

.meas tran vdout1_318ck800 FIND v(dout1_318) AT=405.025n

.meas tran vdout1_319ck800 FIND v(dout1_319) AT=405.025n

.meas tran vdout1_320ck800 FIND v(dout1_320) AT=405.025n

.meas tran vdout1_321ck800 FIND v(dout1_321) AT=405.025n

.meas tran vdout1_322ck800 FIND v(dout1_322) AT=405.025n

.meas tran vdout1_323ck800 FIND v(dout1_323) AT=405.025n

.meas tran vdout1_324ck800 FIND v(dout1_324) AT=405.025n

.meas tran vdout1_325ck800 FIND v(dout1_325) AT=405.025n

.meas tran vdout1_326ck800 FIND v(dout1_326) AT=405.025n

.meas tran vdout1_327ck800 FIND v(dout1_327) AT=405.025n

.meas tran vdout1_328ck800 FIND v(dout1_328) AT=405.025n

.meas tran vdout1_329ck800 FIND v(dout1_329) AT=405.025n

.meas tran vdout1_330ck800 FIND v(dout1_330) AT=405.025n

.meas tran vdout1_331ck800 FIND v(dout1_331) AT=405.025n

.meas tran vdout1_332ck800 FIND v(dout1_332) AT=405.025n

.meas tran vdout1_333ck800 FIND v(dout1_333) AT=405.025n

.meas tran vdout1_334ck800 FIND v(dout1_334) AT=405.025n

.meas tran vdout1_335ck800 FIND v(dout1_335) AT=405.025n

.meas tran vdout1_336ck800 FIND v(dout1_336) AT=405.025n

.meas tran vdout1_337ck800 FIND v(dout1_337) AT=405.025n

.meas tran vdout1_338ck800 FIND v(dout1_338) AT=405.025n

.meas tran vdout1_339ck800 FIND v(dout1_339) AT=405.025n

.meas tran vdout1_340ck800 FIND v(dout1_340) AT=405.025n

.meas tran vdout1_341ck800 FIND v(dout1_341) AT=405.025n

.meas tran vdout1_342ck800 FIND v(dout1_342) AT=405.025n

.meas tran vdout1_343ck800 FIND v(dout1_343) AT=405.025n

.meas tran vdout1_344ck800 FIND v(dout1_344) AT=405.025n

.meas tran vdout1_345ck800 FIND v(dout1_345) AT=405.025n

.meas tran vdout1_346ck800 FIND v(dout1_346) AT=405.025n

.meas tran vdout1_347ck800 FIND v(dout1_347) AT=405.025n

.meas tran vdout1_348ck800 FIND v(dout1_348) AT=405.025n

.meas tran vdout1_349ck800 FIND v(dout1_349) AT=405.025n

.meas tran vdout1_350ck800 FIND v(dout1_350) AT=405.025n

.meas tran vdout1_351ck800 FIND v(dout1_351) AT=405.025n

.meas tran vdout1_352ck800 FIND v(dout1_352) AT=405.025n

.meas tran vdout1_353ck800 FIND v(dout1_353) AT=405.025n

.meas tran vdout1_354ck800 FIND v(dout1_354) AT=405.025n

.meas tran vdout1_355ck800 FIND v(dout1_355) AT=405.025n

.meas tran vdout1_356ck800 FIND v(dout1_356) AT=405.025n

.meas tran vdout1_357ck800 FIND v(dout1_357) AT=405.025n

.meas tran vdout1_358ck800 FIND v(dout1_358) AT=405.025n

.meas tran vdout1_359ck800 FIND v(dout1_359) AT=405.025n

.meas tran vdout1_360ck800 FIND v(dout1_360) AT=405.025n

.meas tran vdout1_361ck800 FIND v(dout1_361) AT=405.025n

.meas tran vdout1_362ck800 FIND v(dout1_362) AT=405.025n

.meas tran vdout1_363ck800 FIND v(dout1_363) AT=405.025n

.meas tran vdout1_364ck800 FIND v(dout1_364) AT=405.025n

.meas tran vdout1_365ck800 FIND v(dout1_365) AT=405.025n

.meas tran vdout1_366ck800 FIND v(dout1_366) AT=405.025n

.meas tran vdout1_367ck800 FIND v(dout1_367) AT=405.025n

.meas tran vdout1_368ck800 FIND v(dout1_368) AT=405.025n

.meas tran vdout1_369ck800 FIND v(dout1_369) AT=405.025n

.meas tran vdout1_370ck800 FIND v(dout1_370) AT=405.025n

.meas tran vdout1_371ck800 FIND v(dout1_371) AT=405.025n

.meas tran vdout1_372ck800 FIND v(dout1_372) AT=405.025n

.meas tran vdout1_373ck800 FIND v(dout1_373) AT=405.025n

.meas tran vdout1_374ck800 FIND v(dout1_374) AT=405.025n

.meas tran vdout1_375ck800 FIND v(dout1_375) AT=405.025n

.meas tran vdout1_376ck800 FIND v(dout1_376) AT=405.025n

.meas tran vdout1_377ck800 FIND v(dout1_377) AT=405.025n

.meas tran vdout1_378ck800 FIND v(dout1_378) AT=405.025n

.meas tran vdout1_379ck800 FIND v(dout1_379) AT=405.025n

.meas tran vdout1_380ck800 FIND v(dout1_380) AT=405.025n

.meas tran vdout1_381ck800 FIND v(dout1_381) AT=405.025n

.meas tran vdout1_382ck800 FIND v(dout1_382) AT=405.025n

.meas tran vdout1_383ck800 FIND v(dout1_383) AT=405.025n

.meas tran vdout1_384ck800 FIND v(dout1_384) AT=405.025n

.meas tran vdout1_385ck800 FIND v(dout1_385) AT=405.025n

.meas tran vdout1_386ck800 FIND v(dout1_386) AT=405.025n

.meas tran vdout1_387ck800 FIND v(dout1_387) AT=405.025n

.meas tran vdout1_388ck800 FIND v(dout1_388) AT=405.025n

.meas tran vdout1_389ck800 FIND v(dout1_389) AT=405.025n

.meas tran vdout1_390ck800 FIND v(dout1_390) AT=405.025n

.meas tran vdout1_391ck800 FIND v(dout1_391) AT=405.025n

.meas tran vdout1_392ck800 FIND v(dout1_392) AT=405.025n

.meas tran vdout1_393ck800 FIND v(dout1_393) AT=405.025n

.meas tran vdout1_394ck800 FIND v(dout1_394) AT=405.025n

.meas tran vdout1_395ck800 FIND v(dout1_395) AT=405.025n

.meas tran vdout1_396ck800 FIND v(dout1_396) AT=405.025n

.meas tran vdout1_397ck800 FIND v(dout1_397) AT=405.025n

.meas tran vdout1_398ck800 FIND v(dout1_398) AT=405.025n

.meas tran vdout1_399ck800 FIND v(dout1_399) AT=405.025n

.meas tran vdout1_400ck800 FIND v(dout1_400) AT=405.025n

.meas tran vdout1_401ck800 FIND v(dout1_401) AT=405.025n

.meas tran vdout1_402ck800 FIND v(dout1_402) AT=405.025n

.meas tran vdout1_403ck800 FIND v(dout1_403) AT=405.025n

.meas tran vdout1_404ck800 FIND v(dout1_404) AT=405.025n

.meas tran vdout1_405ck800 FIND v(dout1_405) AT=405.025n

.meas tran vdout1_406ck800 FIND v(dout1_406) AT=405.025n

.meas tran vdout1_407ck800 FIND v(dout1_407) AT=405.025n

.meas tran vdout1_408ck800 FIND v(dout1_408) AT=405.025n

.meas tran vdout1_409ck800 FIND v(dout1_409) AT=405.025n

.meas tran vdout1_410ck800 FIND v(dout1_410) AT=405.025n

.meas tran vdout1_411ck800 FIND v(dout1_411) AT=405.025n

.meas tran vdout1_412ck800 FIND v(dout1_412) AT=405.025n

.meas tran vdout1_413ck800 FIND v(dout1_413) AT=405.025n

.meas tran vdout1_414ck800 FIND v(dout1_414) AT=405.025n

.meas tran vdout1_415ck800 FIND v(dout1_415) AT=405.025n

.meas tran vdout1_416ck800 FIND v(dout1_416) AT=405.025n

.meas tran vdout1_417ck800 FIND v(dout1_417) AT=405.025n

.meas tran vdout1_418ck800 FIND v(dout1_418) AT=405.025n

.meas tran vdout1_419ck800 FIND v(dout1_419) AT=405.025n

.meas tran vdout1_420ck800 FIND v(dout1_420) AT=405.025n

.meas tran vdout1_421ck800 FIND v(dout1_421) AT=405.025n

.meas tran vdout1_422ck800 FIND v(dout1_422) AT=405.025n

.meas tran vdout1_423ck800 FIND v(dout1_423) AT=405.025n

.meas tran vdout1_424ck800 FIND v(dout1_424) AT=405.025n

.meas tran vdout1_425ck800 FIND v(dout1_425) AT=405.025n

.meas tran vdout1_426ck800 FIND v(dout1_426) AT=405.025n

.meas tran vdout1_427ck800 FIND v(dout1_427) AT=405.025n

.meas tran vdout1_428ck800 FIND v(dout1_428) AT=405.025n

.meas tran vdout1_429ck800 FIND v(dout1_429) AT=405.025n

.meas tran vdout1_430ck800 FIND v(dout1_430) AT=405.025n

.meas tran vdout1_431ck800 FIND v(dout1_431) AT=405.025n

.meas tran vdout1_432ck800 FIND v(dout1_432) AT=405.025n

.meas tran vdout1_433ck800 FIND v(dout1_433) AT=405.025n

.meas tran vdout1_434ck800 FIND v(dout1_434) AT=405.025n

.meas tran vdout1_435ck800 FIND v(dout1_435) AT=405.025n

.meas tran vdout1_436ck800 FIND v(dout1_436) AT=405.025n

.meas tran vdout1_437ck800 FIND v(dout1_437) AT=405.025n

.meas tran vdout1_438ck800 FIND v(dout1_438) AT=405.025n

.meas tran vdout1_439ck800 FIND v(dout1_439) AT=405.025n

.meas tran vdout1_440ck800 FIND v(dout1_440) AT=405.025n

.meas tran vdout1_441ck800 FIND v(dout1_441) AT=405.025n

.meas tran vdout1_442ck800 FIND v(dout1_442) AT=405.025n

.meas tran vdout1_443ck800 FIND v(dout1_443) AT=405.025n

.meas tran vdout1_444ck800 FIND v(dout1_444) AT=405.025n

.meas tran vdout1_445ck800 FIND v(dout1_445) AT=405.025n

.meas tran vdout1_446ck800 FIND v(dout1_446) AT=405.025n

.meas tran vdout1_447ck800 FIND v(dout1_447) AT=405.025n

.meas tran vdout1_448ck800 FIND v(dout1_448) AT=405.025n

.meas tran vdout1_449ck800 FIND v(dout1_449) AT=405.025n

.meas tran vdout1_450ck800 FIND v(dout1_450) AT=405.025n

.meas tran vdout1_451ck800 FIND v(dout1_451) AT=405.025n

.meas tran vdout1_452ck800 FIND v(dout1_452) AT=405.025n

.meas tran vdout1_453ck800 FIND v(dout1_453) AT=405.025n

.meas tran vdout1_454ck800 FIND v(dout1_454) AT=405.025n

.meas tran vdout1_455ck800 FIND v(dout1_455) AT=405.025n

.meas tran vdout1_456ck800 FIND v(dout1_456) AT=405.025n

.meas tran vdout1_457ck800 FIND v(dout1_457) AT=405.025n

.meas tran vdout1_458ck800 FIND v(dout1_458) AT=405.025n

.meas tran vdout1_459ck800 FIND v(dout1_459) AT=405.025n

.meas tran vdout1_460ck800 FIND v(dout1_460) AT=405.025n

.meas tran vdout1_461ck800 FIND v(dout1_461) AT=405.025n

.meas tran vdout1_462ck800 FIND v(dout1_462) AT=405.025n

.meas tran vdout1_463ck800 FIND v(dout1_463) AT=405.025n

.meas tran vdout1_464ck800 FIND v(dout1_464) AT=405.025n

.meas tran vdout1_465ck800 FIND v(dout1_465) AT=405.025n

.meas tran vdout1_466ck800 FIND v(dout1_466) AT=405.025n

.meas tran vdout1_467ck800 FIND v(dout1_467) AT=405.025n

.meas tran vdout1_468ck800 FIND v(dout1_468) AT=405.025n

.meas tran vdout1_469ck800 FIND v(dout1_469) AT=405.025n

.meas tran vdout1_470ck800 FIND v(dout1_470) AT=405.025n

.meas tran vdout1_471ck800 FIND v(dout1_471) AT=405.025n

.meas tran vdout1_472ck800 FIND v(dout1_472) AT=405.025n

.meas tran vdout1_473ck800 FIND v(dout1_473) AT=405.025n

.meas tran vdout1_474ck800 FIND v(dout1_474) AT=405.025n

.meas tran vdout1_475ck800 FIND v(dout1_475) AT=405.025n

.meas tran vdout1_476ck800 FIND v(dout1_476) AT=405.025n

.meas tran vdout1_477ck800 FIND v(dout1_477) AT=405.025n

.meas tran vdout1_478ck800 FIND v(dout1_478) AT=405.025n

.meas tran vdout1_479ck800 FIND v(dout1_479) AT=405.025n

.meas tran vdout1_480ck800 FIND v(dout1_480) AT=405.025n

.meas tran vdout1_481ck800 FIND v(dout1_481) AT=405.025n

.meas tran vdout1_482ck800 FIND v(dout1_482) AT=405.025n

.meas tran vdout1_483ck800 FIND v(dout1_483) AT=405.025n

.meas tran vdout1_484ck800 FIND v(dout1_484) AT=405.025n

.meas tran vdout1_485ck800 FIND v(dout1_485) AT=405.025n

.meas tran vdout1_486ck800 FIND v(dout1_486) AT=405.025n

.meas tran vdout1_487ck800 FIND v(dout1_487) AT=405.025n

.meas tran vdout1_488ck800 FIND v(dout1_488) AT=405.025n

.meas tran vdout1_489ck800 FIND v(dout1_489) AT=405.025n

.meas tran vdout1_490ck800 FIND v(dout1_490) AT=405.025n

.meas tran vdout1_491ck800 FIND v(dout1_491) AT=405.025n

.meas tran vdout1_492ck800 FIND v(dout1_492) AT=405.025n

.meas tran vdout1_493ck800 FIND v(dout1_493) AT=405.025n

.meas tran vdout1_494ck800 FIND v(dout1_494) AT=405.025n

.meas tran vdout1_495ck800 FIND v(dout1_495) AT=405.025n

.meas tran vdout1_496ck800 FIND v(dout1_496) AT=405.025n

.meas tran vdout1_497ck800 FIND v(dout1_497) AT=405.025n

.meas tran vdout1_498ck800 FIND v(dout1_498) AT=405.025n

.meas tran vdout1_499ck800 FIND v(dout1_499) AT=405.025n

.meas tran vdout1_500ck800 FIND v(dout1_500) AT=405.025n

.meas tran vdout1_501ck800 FIND v(dout1_501) AT=405.025n

.meas tran vdout1_502ck800 FIND v(dout1_502) AT=405.025n

.meas tran vdout1_503ck800 FIND v(dout1_503) AT=405.025n

.meas tran vdout1_504ck800 FIND v(dout1_504) AT=405.025n

.meas tran vdout1_505ck800 FIND v(dout1_505) AT=405.025n

.meas tran vdout1_506ck800 FIND v(dout1_506) AT=405.025n

.meas tran vdout1_507ck800 FIND v(dout1_507) AT=405.025n

.meas tran vdout1_508ck800 FIND v(dout1_508) AT=405.025n

.meas tran vdout1_509ck800 FIND v(dout1_509) AT=405.025n

.meas tran vdout1_510ck800 FIND v(dout1_510) AT=405.025n

.meas tran vdout1_511ck800 FIND v(dout1_511) AT=405.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_19ck850 FIND v(dout1_19) AT=430.025n

.meas tran vdout1_20ck850 FIND v(dout1_20) AT=430.025n

.meas tran vdout1_21ck850 FIND v(dout1_21) AT=430.025n

.meas tran vdout1_22ck850 FIND v(dout1_22) AT=430.025n

.meas tran vdout1_23ck850 FIND v(dout1_23) AT=430.025n

.meas tran vdout1_24ck850 FIND v(dout1_24) AT=430.025n

.meas tran vdout1_25ck850 FIND v(dout1_25) AT=430.025n

.meas tran vdout1_26ck850 FIND v(dout1_26) AT=430.025n

.meas tran vdout1_27ck850 FIND v(dout1_27) AT=430.025n

.meas tran vdout1_28ck850 FIND v(dout1_28) AT=430.025n

.meas tran vdout1_29ck850 FIND v(dout1_29) AT=430.025n

.meas tran vdout1_30ck850 FIND v(dout1_30) AT=430.025n

.meas tran vdout1_31ck850 FIND v(dout1_31) AT=430.025n

.meas tran vdout1_32ck850 FIND v(dout1_32) AT=430.025n

.meas tran vdout1_33ck850 FIND v(dout1_33) AT=430.025n

.meas tran vdout1_34ck850 FIND v(dout1_34) AT=430.025n

.meas tran vdout1_35ck850 FIND v(dout1_35) AT=430.025n

.meas tran vdout1_36ck850 FIND v(dout1_36) AT=430.025n

.meas tran vdout1_37ck850 FIND v(dout1_37) AT=430.025n

.meas tran vdout1_38ck850 FIND v(dout1_38) AT=430.025n

.meas tran vdout1_39ck850 FIND v(dout1_39) AT=430.025n

.meas tran vdout1_40ck850 FIND v(dout1_40) AT=430.025n

.meas tran vdout1_41ck850 FIND v(dout1_41) AT=430.025n

.meas tran vdout1_42ck850 FIND v(dout1_42) AT=430.025n

.meas tran vdout1_43ck850 FIND v(dout1_43) AT=430.025n

.meas tran vdout1_44ck850 FIND v(dout1_44) AT=430.025n

.meas tran vdout1_45ck850 FIND v(dout1_45) AT=430.025n

.meas tran vdout1_46ck850 FIND v(dout1_46) AT=430.025n

.meas tran vdout1_47ck850 FIND v(dout1_47) AT=430.025n

.meas tran vdout1_48ck850 FIND v(dout1_48) AT=430.025n

.meas tran vdout1_49ck850 FIND v(dout1_49) AT=430.025n

.meas tran vdout1_50ck850 FIND v(dout1_50) AT=430.025n

.meas tran vdout1_51ck850 FIND v(dout1_51) AT=430.025n

.meas tran vdout1_52ck850 FIND v(dout1_52) AT=430.025n

.meas tran vdout1_53ck850 FIND v(dout1_53) AT=430.025n

.meas tran vdout1_54ck850 FIND v(dout1_54) AT=430.025n

.meas tran vdout1_55ck850 FIND v(dout1_55) AT=430.025n

.meas tran vdout1_56ck850 FIND v(dout1_56) AT=430.025n

.meas tran vdout1_57ck850 FIND v(dout1_57) AT=430.025n

.meas tran vdout1_58ck850 FIND v(dout1_58) AT=430.025n

.meas tran vdout1_59ck850 FIND v(dout1_59) AT=430.025n

.meas tran vdout1_60ck850 FIND v(dout1_60) AT=430.025n

.meas tran vdout1_61ck850 FIND v(dout1_61) AT=430.025n

.meas tran vdout1_62ck850 FIND v(dout1_62) AT=430.025n

.meas tran vdout1_63ck850 FIND v(dout1_63) AT=430.025n

.meas tran vdout1_64ck850 FIND v(dout1_64) AT=430.025n

.meas tran vdout1_65ck850 FIND v(dout1_65) AT=430.025n

.meas tran vdout1_66ck850 FIND v(dout1_66) AT=430.025n

.meas tran vdout1_67ck850 FIND v(dout1_67) AT=430.025n

.meas tran vdout1_68ck850 FIND v(dout1_68) AT=430.025n

.meas tran vdout1_69ck850 FIND v(dout1_69) AT=430.025n

.meas tran vdout1_70ck850 FIND v(dout1_70) AT=430.025n

.meas tran vdout1_71ck850 FIND v(dout1_71) AT=430.025n

.meas tran vdout1_72ck850 FIND v(dout1_72) AT=430.025n

.meas tran vdout1_73ck850 FIND v(dout1_73) AT=430.025n

.meas tran vdout1_74ck850 FIND v(dout1_74) AT=430.025n

.meas tran vdout1_75ck850 FIND v(dout1_75) AT=430.025n

.meas tran vdout1_76ck850 FIND v(dout1_76) AT=430.025n

.meas tran vdout1_77ck850 FIND v(dout1_77) AT=430.025n

.meas tran vdout1_78ck850 FIND v(dout1_78) AT=430.025n

.meas tran vdout1_79ck850 FIND v(dout1_79) AT=430.025n

.meas tran vdout1_80ck850 FIND v(dout1_80) AT=430.025n

.meas tran vdout1_81ck850 FIND v(dout1_81) AT=430.025n

.meas tran vdout1_82ck850 FIND v(dout1_82) AT=430.025n

.meas tran vdout1_83ck850 FIND v(dout1_83) AT=430.025n

.meas tran vdout1_84ck850 FIND v(dout1_84) AT=430.025n

.meas tran vdout1_85ck850 FIND v(dout1_85) AT=430.025n

.meas tran vdout1_86ck850 FIND v(dout1_86) AT=430.025n

.meas tran vdout1_87ck850 FIND v(dout1_87) AT=430.025n

.meas tran vdout1_88ck850 FIND v(dout1_88) AT=430.025n

.meas tran vdout1_89ck850 FIND v(dout1_89) AT=430.025n

.meas tran vdout1_90ck850 FIND v(dout1_90) AT=430.025n

.meas tran vdout1_91ck850 FIND v(dout1_91) AT=430.025n

.meas tran vdout1_92ck850 FIND v(dout1_92) AT=430.025n

.meas tran vdout1_93ck850 FIND v(dout1_93) AT=430.025n

.meas tran vdout1_94ck850 FIND v(dout1_94) AT=430.025n

.meas tran vdout1_95ck850 FIND v(dout1_95) AT=430.025n

.meas tran vdout1_96ck850 FIND v(dout1_96) AT=430.025n

.meas tran vdout1_97ck850 FIND v(dout1_97) AT=430.025n

.meas tran vdout1_98ck850 FIND v(dout1_98) AT=430.025n

.meas tran vdout1_99ck850 FIND v(dout1_99) AT=430.025n

.meas tran vdout1_100ck850 FIND v(dout1_100) AT=430.025n

.meas tran vdout1_101ck850 FIND v(dout1_101) AT=430.025n

.meas tran vdout1_102ck850 FIND v(dout1_102) AT=430.025n

.meas tran vdout1_103ck850 FIND v(dout1_103) AT=430.025n

.meas tran vdout1_104ck850 FIND v(dout1_104) AT=430.025n

.meas tran vdout1_105ck850 FIND v(dout1_105) AT=430.025n

.meas tran vdout1_106ck850 FIND v(dout1_106) AT=430.025n

.meas tran vdout1_107ck850 FIND v(dout1_107) AT=430.025n

.meas tran vdout1_108ck850 FIND v(dout1_108) AT=430.025n

.meas tran vdout1_109ck850 FIND v(dout1_109) AT=430.025n

.meas tran vdout1_110ck850 FIND v(dout1_110) AT=430.025n

.meas tran vdout1_111ck850 FIND v(dout1_111) AT=430.025n

.meas tran vdout1_112ck850 FIND v(dout1_112) AT=430.025n

.meas tran vdout1_113ck850 FIND v(dout1_113) AT=430.025n

.meas tran vdout1_114ck850 FIND v(dout1_114) AT=430.025n

.meas tran vdout1_115ck850 FIND v(dout1_115) AT=430.025n

.meas tran vdout1_116ck850 FIND v(dout1_116) AT=430.025n

.meas tran vdout1_117ck850 FIND v(dout1_117) AT=430.025n

.meas tran vdout1_118ck850 FIND v(dout1_118) AT=430.025n

.meas tran vdout1_119ck850 FIND v(dout1_119) AT=430.025n

.meas tran vdout1_120ck850 FIND v(dout1_120) AT=430.025n

.meas tran vdout1_121ck850 FIND v(dout1_121) AT=430.025n

.meas tran vdout1_122ck850 FIND v(dout1_122) AT=430.025n

.meas tran vdout1_123ck850 FIND v(dout1_123) AT=430.025n

.meas tran vdout1_124ck850 FIND v(dout1_124) AT=430.025n

.meas tran vdout1_125ck850 FIND v(dout1_125) AT=430.025n

.meas tran vdout1_126ck850 FIND v(dout1_126) AT=430.025n

.meas tran vdout1_127ck850 FIND v(dout1_127) AT=430.025n

.meas tran vdout1_128ck850 FIND v(dout1_128) AT=430.025n

.meas tran vdout1_129ck850 FIND v(dout1_129) AT=430.025n

.meas tran vdout1_130ck850 FIND v(dout1_130) AT=430.025n

.meas tran vdout1_131ck850 FIND v(dout1_131) AT=430.025n

.meas tran vdout1_132ck850 FIND v(dout1_132) AT=430.025n

.meas tran vdout1_133ck850 FIND v(dout1_133) AT=430.025n

.meas tran vdout1_134ck850 FIND v(dout1_134) AT=430.025n

.meas tran vdout1_135ck850 FIND v(dout1_135) AT=430.025n

.meas tran vdout1_136ck850 FIND v(dout1_136) AT=430.025n

.meas tran vdout1_137ck850 FIND v(dout1_137) AT=430.025n

.meas tran vdout1_138ck850 FIND v(dout1_138) AT=430.025n

.meas tran vdout1_139ck850 FIND v(dout1_139) AT=430.025n

.meas tran vdout1_140ck850 FIND v(dout1_140) AT=430.025n

.meas tran vdout1_141ck850 FIND v(dout1_141) AT=430.025n

.meas tran vdout1_142ck850 FIND v(dout1_142) AT=430.025n

.meas tran vdout1_143ck850 FIND v(dout1_143) AT=430.025n

.meas tran vdout1_144ck850 FIND v(dout1_144) AT=430.025n

.meas tran vdout1_145ck850 FIND v(dout1_145) AT=430.025n

.meas tran vdout1_146ck850 FIND v(dout1_146) AT=430.025n

.meas tran vdout1_147ck850 FIND v(dout1_147) AT=430.025n

.meas tran vdout1_148ck850 FIND v(dout1_148) AT=430.025n

.meas tran vdout1_149ck850 FIND v(dout1_149) AT=430.025n

.meas tran vdout1_150ck850 FIND v(dout1_150) AT=430.025n

.meas tran vdout1_151ck850 FIND v(dout1_151) AT=430.025n

.meas tran vdout1_152ck850 FIND v(dout1_152) AT=430.025n

.meas tran vdout1_153ck850 FIND v(dout1_153) AT=430.025n

.meas tran vdout1_154ck850 FIND v(dout1_154) AT=430.025n

.meas tran vdout1_155ck850 FIND v(dout1_155) AT=430.025n

.meas tran vdout1_156ck850 FIND v(dout1_156) AT=430.025n

.meas tran vdout1_157ck850 FIND v(dout1_157) AT=430.025n

.meas tran vdout1_158ck850 FIND v(dout1_158) AT=430.025n

.meas tran vdout1_159ck850 FIND v(dout1_159) AT=430.025n

.meas tran vdout1_160ck850 FIND v(dout1_160) AT=430.025n

.meas tran vdout1_161ck850 FIND v(dout1_161) AT=430.025n

.meas tran vdout1_162ck850 FIND v(dout1_162) AT=430.025n

.meas tran vdout1_163ck850 FIND v(dout1_163) AT=430.025n

.meas tran vdout1_164ck850 FIND v(dout1_164) AT=430.025n

.meas tran vdout1_165ck850 FIND v(dout1_165) AT=430.025n

.meas tran vdout1_166ck850 FIND v(dout1_166) AT=430.025n

.meas tran vdout1_167ck850 FIND v(dout1_167) AT=430.025n

.meas tran vdout1_168ck850 FIND v(dout1_168) AT=430.025n

.meas tran vdout1_169ck850 FIND v(dout1_169) AT=430.025n

.meas tran vdout1_170ck850 FIND v(dout1_170) AT=430.025n

.meas tran vdout1_171ck850 FIND v(dout1_171) AT=430.025n

.meas tran vdout1_172ck850 FIND v(dout1_172) AT=430.025n

.meas tran vdout1_173ck850 FIND v(dout1_173) AT=430.025n

.meas tran vdout1_174ck850 FIND v(dout1_174) AT=430.025n

.meas tran vdout1_175ck850 FIND v(dout1_175) AT=430.025n

.meas tran vdout1_176ck850 FIND v(dout1_176) AT=430.025n

.meas tran vdout1_177ck850 FIND v(dout1_177) AT=430.025n

.meas tran vdout1_178ck850 FIND v(dout1_178) AT=430.025n

.meas tran vdout1_179ck850 FIND v(dout1_179) AT=430.025n

.meas tran vdout1_180ck850 FIND v(dout1_180) AT=430.025n

.meas tran vdout1_181ck850 FIND v(dout1_181) AT=430.025n

.meas tran vdout1_182ck850 FIND v(dout1_182) AT=430.025n

.meas tran vdout1_183ck850 FIND v(dout1_183) AT=430.025n

.meas tran vdout1_184ck850 FIND v(dout1_184) AT=430.025n

.meas tran vdout1_185ck850 FIND v(dout1_185) AT=430.025n

.meas tran vdout1_186ck850 FIND v(dout1_186) AT=430.025n

.meas tran vdout1_187ck850 FIND v(dout1_187) AT=430.025n

.meas tran vdout1_188ck850 FIND v(dout1_188) AT=430.025n

.meas tran vdout1_189ck850 FIND v(dout1_189) AT=430.025n

.meas tran vdout1_190ck850 FIND v(dout1_190) AT=430.025n

.meas tran vdout1_191ck850 FIND v(dout1_191) AT=430.025n

.meas tran vdout1_192ck850 FIND v(dout1_192) AT=430.025n

.meas tran vdout1_193ck850 FIND v(dout1_193) AT=430.025n

.meas tran vdout1_194ck850 FIND v(dout1_194) AT=430.025n

.meas tran vdout1_195ck850 FIND v(dout1_195) AT=430.025n

.meas tran vdout1_196ck850 FIND v(dout1_196) AT=430.025n

.meas tran vdout1_197ck850 FIND v(dout1_197) AT=430.025n

.meas tran vdout1_198ck850 FIND v(dout1_198) AT=430.025n

.meas tran vdout1_199ck850 FIND v(dout1_199) AT=430.025n

.meas tran vdout1_200ck850 FIND v(dout1_200) AT=430.025n

.meas tran vdout1_201ck850 FIND v(dout1_201) AT=430.025n

.meas tran vdout1_202ck850 FIND v(dout1_202) AT=430.025n

.meas tran vdout1_203ck850 FIND v(dout1_203) AT=430.025n

.meas tran vdout1_204ck850 FIND v(dout1_204) AT=430.025n

.meas tran vdout1_205ck850 FIND v(dout1_205) AT=430.025n

.meas tran vdout1_206ck850 FIND v(dout1_206) AT=430.025n

.meas tran vdout1_207ck850 FIND v(dout1_207) AT=430.025n

.meas tran vdout1_208ck850 FIND v(dout1_208) AT=430.025n

.meas tran vdout1_209ck850 FIND v(dout1_209) AT=430.025n

.meas tran vdout1_210ck850 FIND v(dout1_210) AT=430.025n

.meas tran vdout1_211ck850 FIND v(dout1_211) AT=430.025n

.meas tran vdout1_212ck850 FIND v(dout1_212) AT=430.025n

.meas tran vdout1_213ck850 FIND v(dout1_213) AT=430.025n

.meas tran vdout1_214ck850 FIND v(dout1_214) AT=430.025n

.meas tran vdout1_215ck850 FIND v(dout1_215) AT=430.025n

.meas tran vdout1_216ck850 FIND v(dout1_216) AT=430.025n

.meas tran vdout1_217ck850 FIND v(dout1_217) AT=430.025n

.meas tran vdout1_218ck850 FIND v(dout1_218) AT=430.025n

.meas tran vdout1_219ck850 FIND v(dout1_219) AT=430.025n

.meas tran vdout1_220ck850 FIND v(dout1_220) AT=430.025n

.meas tran vdout1_221ck850 FIND v(dout1_221) AT=430.025n

.meas tran vdout1_222ck850 FIND v(dout1_222) AT=430.025n

.meas tran vdout1_223ck850 FIND v(dout1_223) AT=430.025n

.meas tran vdout1_224ck850 FIND v(dout1_224) AT=430.025n

.meas tran vdout1_225ck850 FIND v(dout1_225) AT=430.025n

.meas tran vdout1_226ck850 FIND v(dout1_226) AT=430.025n

.meas tran vdout1_227ck850 FIND v(dout1_227) AT=430.025n

.meas tran vdout1_228ck850 FIND v(dout1_228) AT=430.025n

.meas tran vdout1_229ck850 FIND v(dout1_229) AT=430.025n

.meas tran vdout1_230ck850 FIND v(dout1_230) AT=430.025n

.meas tran vdout1_231ck850 FIND v(dout1_231) AT=430.025n

.meas tran vdout1_232ck850 FIND v(dout1_232) AT=430.025n

.meas tran vdout1_233ck850 FIND v(dout1_233) AT=430.025n

.meas tran vdout1_234ck850 FIND v(dout1_234) AT=430.025n

.meas tran vdout1_235ck850 FIND v(dout1_235) AT=430.025n

.meas tran vdout1_236ck850 FIND v(dout1_236) AT=430.025n

.meas tran vdout1_237ck850 FIND v(dout1_237) AT=430.025n

.meas tran vdout1_238ck850 FIND v(dout1_238) AT=430.025n

.meas tran vdout1_239ck850 FIND v(dout1_239) AT=430.025n

.meas tran vdout1_240ck850 FIND v(dout1_240) AT=430.025n

.meas tran vdout1_241ck850 FIND v(dout1_241) AT=430.025n

.meas tran vdout1_242ck850 FIND v(dout1_242) AT=430.025n

.meas tran vdout1_243ck850 FIND v(dout1_243) AT=430.025n

.meas tran vdout1_244ck850 FIND v(dout1_244) AT=430.025n

.meas tran vdout1_245ck850 FIND v(dout1_245) AT=430.025n

.meas tran vdout1_246ck850 FIND v(dout1_246) AT=430.025n

.meas tran vdout1_247ck850 FIND v(dout1_247) AT=430.025n

.meas tran vdout1_248ck850 FIND v(dout1_248) AT=430.025n

.meas tran vdout1_249ck850 FIND v(dout1_249) AT=430.025n

.meas tran vdout1_250ck850 FIND v(dout1_250) AT=430.025n

.meas tran vdout1_251ck850 FIND v(dout1_251) AT=430.025n

.meas tran vdout1_252ck850 FIND v(dout1_252) AT=430.025n

.meas tran vdout1_253ck850 FIND v(dout1_253) AT=430.025n

.meas tran vdout1_254ck850 FIND v(dout1_254) AT=430.025n

.meas tran vdout1_255ck850 FIND v(dout1_255) AT=430.025n

.meas tran vdout1_256ck850 FIND v(dout1_256) AT=430.025n

.meas tran vdout1_257ck850 FIND v(dout1_257) AT=430.025n

.meas tran vdout1_258ck850 FIND v(dout1_258) AT=430.025n

.meas tran vdout1_259ck850 FIND v(dout1_259) AT=430.025n

.meas tran vdout1_260ck850 FIND v(dout1_260) AT=430.025n

.meas tran vdout1_261ck850 FIND v(dout1_261) AT=430.025n

.meas tran vdout1_262ck850 FIND v(dout1_262) AT=430.025n

.meas tran vdout1_263ck850 FIND v(dout1_263) AT=430.025n

.meas tran vdout1_264ck850 FIND v(dout1_264) AT=430.025n

.meas tran vdout1_265ck850 FIND v(dout1_265) AT=430.025n

.meas tran vdout1_266ck850 FIND v(dout1_266) AT=430.025n

.meas tran vdout1_267ck850 FIND v(dout1_267) AT=430.025n

.meas tran vdout1_268ck850 FIND v(dout1_268) AT=430.025n

.meas tran vdout1_269ck850 FIND v(dout1_269) AT=430.025n

.meas tran vdout1_270ck850 FIND v(dout1_270) AT=430.025n

.meas tran vdout1_271ck850 FIND v(dout1_271) AT=430.025n

.meas tran vdout1_272ck850 FIND v(dout1_272) AT=430.025n

.meas tran vdout1_273ck850 FIND v(dout1_273) AT=430.025n

.meas tran vdout1_274ck850 FIND v(dout1_274) AT=430.025n

.meas tran vdout1_275ck850 FIND v(dout1_275) AT=430.025n

.meas tran vdout1_276ck850 FIND v(dout1_276) AT=430.025n

.meas tran vdout1_277ck850 FIND v(dout1_277) AT=430.025n

.meas tran vdout1_278ck850 FIND v(dout1_278) AT=430.025n

.meas tran vdout1_279ck850 FIND v(dout1_279) AT=430.025n

.meas tran vdout1_280ck850 FIND v(dout1_280) AT=430.025n

.meas tran vdout1_281ck850 FIND v(dout1_281) AT=430.025n

.meas tran vdout1_282ck850 FIND v(dout1_282) AT=430.025n

.meas tran vdout1_283ck850 FIND v(dout1_283) AT=430.025n

.meas tran vdout1_284ck850 FIND v(dout1_284) AT=430.025n

.meas tran vdout1_285ck850 FIND v(dout1_285) AT=430.025n

.meas tran vdout1_286ck850 FIND v(dout1_286) AT=430.025n

.meas tran vdout1_287ck850 FIND v(dout1_287) AT=430.025n

.meas tran vdout1_288ck850 FIND v(dout1_288) AT=430.025n

.meas tran vdout1_289ck850 FIND v(dout1_289) AT=430.025n

.meas tran vdout1_290ck850 FIND v(dout1_290) AT=430.025n

.meas tran vdout1_291ck850 FIND v(dout1_291) AT=430.025n

.meas tran vdout1_292ck850 FIND v(dout1_292) AT=430.025n

.meas tran vdout1_293ck850 FIND v(dout1_293) AT=430.025n

.meas tran vdout1_294ck850 FIND v(dout1_294) AT=430.025n

.meas tran vdout1_295ck850 FIND v(dout1_295) AT=430.025n

.meas tran vdout1_296ck850 FIND v(dout1_296) AT=430.025n

.meas tran vdout1_297ck850 FIND v(dout1_297) AT=430.025n

.meas tran vdout1_298ck850 FIND v(dout1_298) AT=430.025n

.meas tran vdout1_299ck850 FIND v(dout1_299) AT=430.025n

.meas tran vdout1_300ck850 FIND v(dout1_300) AT=430.025n

.meas tran vdout1_301ck850 FIND v(dout1_301) AT=430.025n

.meas tran vdout1_302ck850 FIND v(dout1_302) AT=430.025n

.meas tran vdout1_303ck850 FIND v(dout1_303) AT=430.025n

.meas tran vdout1_304ck850 FIND v(dout1_304) AT=430.025n

.meas tran vdout1_305ck850 FIND v(dout1_305) AT=430.025n

.meas tran vdout1_306ck850 FIND v(dout1_306) AT=430.025n

.meas tran vdout1_307ck850 FIND v(dout1_307) AT=430.025n

.meas tran vdout1_308ck850 FIND v(dout1_308) AT=430.025n

.meas tran vdout1_309ck850 FIND v(dout1_309) AT=430.025n

.meas tran vdout1_310ck850 FIND v(dout1_310) AT=430.025n

.meas tran vdout1_311ck850 FIND v(dout1_311) AT=430.025n

.meas tran vdout1_312ck850 FIND v(dout1_312) AT=430.025n

.meas tran vdout1_313ck850 FIND v(dout1_313) AT=430.025n

.meas tran vdout1_314ck850 FIND v(dout1_314) AT=430.025n

.meas tran vdout1_315ck850 FIND v(dout1_315) AT=430.025n

.meas tran vdout1_316ck850 FIND v(dout1_316) AT=430.025n

.meas tran vdout1_317ck850 FIND v(dout1_317) AT=430.025n

.meas tran vdout1_318ck850 FIND v(dout1_318) AT=430.025n

.meas tran vdout1_319ck850 FIND v(dout1_319) AT=430.025n

.meas tran vdout1_320ck850 FIND v(dout1_320) AT=430.025n

.meas tran vdout1_321ck850 FIND v(dout1_321) AT=430.025n

.meas tran vdout1_322ck850 FIND v(dout1_322) AT=430.025n

.meas tran vdout1_323ck850 FIND v(dout1_323) AT=430.025n

.meas tran vdout1_324ck850 FIND v(dout1_324) AT=430.025n

.meas tran vdout1_325ck850 FIND v(dout1_325) AT=430.025n

.meas tran vdout1_326ck850 FIND v(dout1_326) AT=430.025n

.meas tran vdout1_327ck850 FIND v(dout1_327) AT=430.025n

.meas tran vdout1_328ck850 FIND v(dout1_328) AT=430.025n

.meas tran vdout1_329ck850 FIND v(dout1_329) AT=430.025n

.meas tran vdout1_330ck850 FIND v(dout1_330) AT=430.025n

.meas tran vdout1_331ck850 FIND v(dout1_331) AT=430.025n

.meas tran vdout1_332ck850 FIND v(dout1_332) AT=430.025n

.meas tran vdout1_333ck850 FIND v(dout1_333) AT=430.025n

.meas tran vdout1_334ck850 FIND v(dout1_334) AT=430.025n

.meas tran vdout1_335ck850 FIND v(dout1_335) AT=430.025n

.meas tran vdout1_336ck850 FIND v(dout1_336) AT=430.025n

.meas tran vdout1_337ck850 FIND v(dout1_337) AT=430.025n

.meas tran vdout1_338ck850 FIND v(dout1_338) AT=430.025n

.meas tran vdout1_339ck850 FIND v(dout1_339) AT=430.025n

.meas tran vdout1_340ck850 FIND v(dout1_340) AT=430.025n

.meas tran vdout1_341ck850 FIND v(dout1_341) AT=430.025n

.meas tran vdout1_342ck850 FIND v(dout1_342) AT=430.025n

.meas tran vdout1_343ck850 FIND v(dout1_343) AT=430.025n

.meas tran vdout1_344ck850 FIND v(dout1_344) AT=430.025n

.meas tran vdout1_345ck850 FIND v(dout1_345) AT=430.025n

.meas tran vdout1_346ck850 FIND v(dout1_346) AT=430.025n

.meas tran vdout1_347ck850 FIND v(dout1_347) AT=430.025n

.meas tran vdout1_348ck850 FIND v(dout1_348) AT=430.025n

.meas tran vdout1_349ck850 FIND v(dout1_349) AT=430.025n

.meas tran vdout1_350ck850 FIND v(dout1_350) AT=430.025n

.meas tran vdout1_351ck850 FIND v(dout1_351) AT=430.025n

.meas tran vdout1_352ck850 FIND v(dout1_352) AT=430.025n

.meas tran vdout1_353ck850 FIND v(dout1_353) AT=430.025n

.meas tran vdout1_354ck850 FIND v(dout1_354) AT=430.025n

.meas tran vdout1_355ck850 FIND v(dout1_355) AT=430.025n

.meas tran vdout1_356ck850 FIND v(dout1_356) AT=430.025n

.meas tran vdout1_357ck850 FIND v(dout1_357) AT=430.025n

.meas tran vdout1_358ck850 FIND v(dout1_358) AT=430.025n

.meas tran vdout1_359ck850 FIND v(dout1_359) AT=430.025n

.meas tran vdout1_360ck850 FIND v(dout1_360) AT=430.025n

.meas tran vdout1_361ck850 FIND v(dout1_361) AT=430.025n

.meas tran vdout1_362ck850 FIND v(dout1_362) AT=430.025n

.meas tran vdout1_363ck850 FIND v(dout1_363) AT=430.025n

.meas tran vdout1_364ck850 FIND v(dout1_364) AT=430.025n

.meas tran vdout1_365ck850 FIND v(dout1_365) AT=430.025n

.meas tran vdout1_366ck850 FIND v(dout1_366) AT=430.025n

.meas tran vdout1_367ck850 FIND v(dout1_367) AT=430.025n

.meas tran vdout1_368ck850 FIND v(dout1_368) AT=430.025n

.meas tran vdout1_369ck850 FIND v(dout1_369) AT=430.025n

.meas tran vdout1_370ck850 FIND v(dout1_370) AT=430.025n

.meas tran vdout1_371ck850 FIND v(dout1_371) AT=430.025n

.meas tran vdout1_372ck850 FIND v(dout1_372) AT=430.025n

.meas tran vdout1_373ck850 FIND v(dout1_373) AT=430.025n

.meas tran vdout1_374ck850 FIND v(dout1_374) AT=430.025n

.meas tran vdout1_375ck850 FIND v(dout1_375) AT=430.025n

.meas tran vdout1_376ck850 FIND v(dout1_376) AT=430.025n

.meas tran vdout1_377ck850 FIND v(dout1_377) AT=430.025n

.meas tran vdout1_378ck850 FIND v(dout1_378) AT=430.025n

.meas tran vdout1_379ck850 FIND v(dout1_379) AT=430.025n

.meas tran vdout1_380ck850 FIND v(dout1_380) AT=430.025n

.meas tran vdout1_381ck850 FIND v(dout1_381) AT=430.025n

.meas tran vdout1_382ck850 FIND v(dout1_382) AT=430.025n

.meas tran vdout1_383ck850 FIND v(dout1_383) AT=430.025n

.meas tran vdout1_384ck850 FIND v(dout1_384) AT=430.025n

.meas tran vdout1_385ck850 FIND v(dout1_385) AT=430.025n

.meas tran vdout1_386ck850 FIND v(dout1_386) AT=430.025n

.meas tran vdout1_387ck850 FIND v(dout1_387) AT=430.025n

.meas tran vdout1_388ck850 FIND v(dout1_388) AT=430.025n

.meas tran vdout1_389ck850 FIND v(dout1_389) AT=430.025n

.meas tran vdout1_390ck850 FIND v(dout1_390) AT=430.025n

.meas tran vdout1_391ck850 FIND v(dout1_391) AT=430.025n

.meas tran vdout1_392ck850 FIND v(dout1_392) AT=430.025n

.meas tran vdout1_393ck850 FIND v(dout1_393) AT=430.025n

.meas tran vdout1_394ck850 FIND v(dout1_394) AT=430.025n

.meas tran vdout1_395ck850 FIND v(dout1_395) AT=430.025n

.meas tran vdout1_396ck850 FIND v(dout1_396) AT=430.025n

.meas tran vdout1_397ck850 FIND v(dout1_397) AT=430.025n

.meas tran vdout1_398ck850 FIND v(dout1_398) AT=430.025n

.meas tran vdout1_399ck850 FIND v(dout1_399) AT=430.025n

.meas tran vdout1_400ck850 FIND v(dout1_400) AT=430.025n

.meas tran vdout1_401ck850 FIND v(dout1_401) AT=430.025n

.meas tran vdout1_402ck850 FIND v(dout1_402) AT=430.025n

.meas tran vdout1_403ck850 FIND v(dout1_403) AT=430.025n

.meas tran vdout1_404ck850 FIND v(dout1_404) AT=430.025n

.meas tran vdout1_405ck850 FIND v(dout1_405) AT=430.025n

.meas tran vdout1_406ck850 FIND v(dout1_406) AT=430.025n

.meas tran vdout1_407ck850 FIND v(dout1_407) AT=430.025n

.meas tran vdout1_408ck850 FIND v(dout1_408) AT=430.025n

.meas tran vdout1_409ck850 FIND v(dout1_409) AT=430.025n

.meas tran vdout1_410ck850 FIND v(dout1_410) AT=430.025n

.meas tran vdout1_411ck850 FIND v(dout1_411) AT=430.025n

.meas tran vdout1_412ck850 FIND v(dout1_412) AT=430.025n

.meas tran vdout1_413ck850 FIND v(dout1_413) AT=430.025n

.meas tran vdout1_414ck850 FIND v(dout1_414) AT=430.025n

.meas tran vdout1_415ck850 FIND v(dout1_415) AT=430.025n

.meas tran vdout1_416ck850 FIND v(dout1_416) AT=430.025n

.meas tran vdout1_417ck850 FIND v(dout1_417) AT=430.025n

.meas tran vdout1_418ck850 FIND v(dout1_418) AT=430.025n

.meas tran vdout1_419ck850 FIND v(dout1_419) AT=430.025n

.meas tran vdout1_420ck850 FIND v(dout1_420) AT=430.025n

.meas tran vdout1_421ck850 FIND v(dout1_421) AT=430.025n

.meas tran vdout1_422ck850 FIND v(dout1_422) AT=430.025n

.meas tran vdout1_423ck850 FIND v(dout1_423) AT=430.025n

.meas tran vdout1_424ck850 FIND v(dout1_424) AT=430.025n

.meas tran vdout1_425ck850 FIND v(dout1_425) AT=430.025n

.meas tran vdout1_426ck850 FIND v(dout1_426) AT=430.025n

.meas tran vdout1_427ck850 FIND v(dout1_427) AT=430.025n

.meas tran vdout1_428ck850 FIND v(dout1_428) AT=430.025n

.meas tran vdout1_429ck850 FIND v(dout1_429) AT=430.025n

.meas tran vdout1_430ck850 FIND v(dout1_430) AT=430.025n

.meas tran vdout1_431ck850 FIND v(dout1_431) AT=430.025n

.meas tran vdout1_432ck850 FIND v(dout1_432) AT=430.025n

.meas tran vdout1_433ck850 FIND v(dout1_433) AT=430.025n

.meas tran vdout1_434ck850 FIND v(dout1_434) AT=430.025n

.meas tran vdout1_435ck850 FIND v(dout1_435) AT=430.025n

.meas tran vdout1_436ck850 FIND v(dout1_436) AT=430.025n

.meas tran vdout1_437ck850 FIND v(dout1_437) AT=430.025n

.meas tran vdout1_438ck850 FIND v(dout1_438) AT=430.025n

.meas tran vdout1_439ck850 FIND v(dout1_439) AT=430.025n

.meas tran vdout1_440ck850 FIND v(dout1_440) AT=430.025n

.meas tran vdout1_441ck850 FIND v(dout1_441) AT=430.025n

.meas tran vdout1_442ck850 FIND v(dout1_442) AT=430.025n

.meas tran vdout1_443ck850 FIND v(dout1_443) AT=430.025n

.meas tran vdout1_444ck850 FIND v(dout1_444) AT=430.025n

.meas tran vdout1_445ck850 FIND v(dout1_445) AT=430.025n

.meas tran vdout1_446ck850 FIND v(dout1_446) AT=430.025n

.meas tran vdout1_447ck850 FIND v(dout1_447) AT=430.025n

.meas tran vdout1_448ck850 FIND v(dout1_448) AT=430.025n

.meas tran vdout1_449ck850 FIND v(dout1_449) AT=430.025n

.meas tran vdout1_450ck850 FIND v(dout1_450) AT=430.025n

.meas tran vdout1_451ck850 FIND v(dout1_451) AT=430.025n

.meas tran vdout1_452ck850 FIND v(dout1_452) AT=430.025n

.meas tran vdout1_453ck850 FIND v(dout1_453) AT=430.025n

.meas tran vdout1_454ck850 FIND v(dout1_454) AT=430.025n

.meas tran vdout1_455ck850 FIND v(dout1_455) AT=430.025n

.meas tran vdout1_456ck850 FIND v(dout1_456) AT=430.025n

.meas tran vdout1_457ck850 FIND v(dout1_457) AT=430.025n

.meas tran vdout1_458ck850 FIND v(dout1_458) AT=430.025n

.meas tran vdout1_459ck850 FIND v(dout1_459) AT=430.025n

.meas tran vdout1_460ck850 FIND v(dout1_460) AT=430.025n

.meas tran vdout1_461ck850 FIND v(dout1_461) AT=430.025n

.meas tran vdout1_462ck850 FIND v(dout1_462) AT=430.025n

.meas tran vdout1_463ck850 FIND v(dout1_463) AT=430.025n

.meas tran vdout1_464ck850 FIND v(dout1_464) AT=430.025n

.meas tran vdout1_465ck850 FIND v(dout1_465) AT=430.025n

.meas tran vdout1_466ck850 FIND v(dout1_466) AT=430.025n

.meas tran vdout1_467ck850 FIND v(dout1_467) AT=430.025n

.meas tran vdout1_468ck850 FIND v(dout1_468) AT=430.025n

.meas tran vdout1_469ck850 FIND v(dout1_469) AT=430.025n

.meas tran vdout1_470ck850 FIND v(dout1_470) AT=430.025n

.meas tran vdout1_471ck850 FIND v(dout1_471) AT=430.025n

.meas tran vdout1_472ck850 FIND v(dout1_472) AT=430.025n

.meas tran vdout1_473ck850 FIND v(dout1_473) AT=430.025n

.meas tran vdout1_474ck850 FIND v(dout1_474) AT=430.025n

.meas tran vdout1_475ck850 FIND v(dout1_475) AT=430.025n

.meas tran vdout1_476ck850 FIND v(dout1_476) AT=430.025n

.meas tran vdout1_477ck850 FIND v(dout1_477) AT=430.025n

.meas tran vdout1_478ck850 FIND v(dout1_478) AT=430.025n

.meas tran vdout1_479ck850 FIND v(dout1_479) AT=430.025n

.meas tran vdout1_480ck850 FIND v(dout1_480) AT=430.025n

.meas tran vdout1_481ck850 FIND v(dout1_481) AT=430.025n

.meas tran vdout1_482ck850 FIND v(dout1_482) AT=430.025n

.meas tran vdout1_483ck850 FIND v(dout1_483) AT=430.025n

.meas tran vdout1_484ck850 FIND v(dout1_484) AT=430.025n

.meas tran vdout1_485ck850 FIND v(dout1_485) AT=430.025n

.meas tran vdout1_486ck850 FIND v(dout1_486) AT=430.025n

.meas tran vdout1_487ck850 FIND v(dout1_487) AT=430.025n

.meas tran vdout1_488ck850 FIND v(dout1_488) AT=430.025n

.meas tran vdout1_489ck850 FIND v(dout1_489) AT=430.025n

.meas tran vdout1_490ck850 FIND v(dout1_490) AT=430.025n

.meas tran vdout1_491ck850 FIND v(dout1_491) AT=430.025n

.meas tran vdout1_492ck850 FIND v(dout1_492) AT=430.025n

.meas tran vdout1_493ck850 FIND v(dout1_493) AT=430.025n

.meas tran vdout1_494ck850 FIND v(dout1_494) AT=430.025n

.meas tran vdout1_495ck850 FIND v(dout1_495) AT=430.025n

.meas tran vdout1_496ck850 FIND v(dout1_496) AT=430.025n

.meas tran vdout1_497ck850 FIND v(dout1_497) AT=430.025n

.meas tran vdout1_498ck850 FIND v(dout1_498) AT=430.025n

.meas tran vdout1_499ck850 FIND v(dout1_499) AT=430.025n

.meas tran vdout1_500ck850 FIND v(dout1_500) AT=430.025n

.meas tran vdout1_501ck850 FIND v(dout1_501) AT=430.025n

.meas tran vdout1_502ck850 FIND v(dout1_502) AT=430.025n

.meas tran vdout1_503ck850 FIND v(dout1_503) AT=430.025n

.meas tran vdout1_504ck850 FIND v(dout1_504) AT=430.025n

.meas tran vdout1_505ck850 FIND v(dout1_505) AT=430.025n

.meas tran vdout1_506ck850 FIND v(dout1_506) AT=430.025n

.meas tran vdout1_507ck850 FIND v(dout1_507) AT=430.025n

.meas tran vdout1_508ck850 FIND v(dout1_508) AT=430.025n

.meas tran vdout1_509ck850 FIND v(dout1_509) AT=430.025n

.meas tran vdout1_510ck850 FIND v(dout1_510) AT=430.025n

.meas tran vdout1_511ck850 FIND v(dout1_511) AT=430.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_32ck860 FIND v(dout1_32) AT=435.025n

.meas tran vdout1_33ck860 FIND v(dout1_33) AT=435.025n

.meas tran vdout1_34ck860 FIND v(dout1_34) AT=435.025n

.meas tran vdout1_35ck860 FIND v(dout1_35) AT=435.025n

.meas tran vdout1_36ck860 FIND v(dout1_36) AT=435.025n

.meas tran vdout1_37ck860 FIND v(dout1_37) AT=435.025n

.meas tran vdout1_38ck860 FIND v(dout1_38) AT=435.025n

.meas tran vdout1_39ck860 FIND v(dout1_39) AT=435.025n

.meas tran vdout1_40ck860 FIND v(dout1_40) AT=435.025n

.meas tran vdout1_41ck860 FIND v(dout1_41) AT=435.025n

.meas tran vdout1_42ck860 FIND v(dout1_42) AT=435.025n

.meas tran vdout1_43ck860 FIND v(dout1_43) AT=435.025n

.meas tran vdout1_44ck860 FIND v(dout1_44) AT=435.025n

.meas tran vdout1_45ck860 FIND v(dout1_45) AT=435.025n

.meas tran vdout1_46ck860 FIND v(dout1_46) AT=435.025n

.meas tran vdout1_47ck860 FIND v(dout1_47) AT=435.025n

.meas tran vdout1_48ck860 FIND v(dout1_48) AT=435.025n

.meas tran vdout1_49ck860 FIND v(dout1_49) AT=435.025n

.meas tran vdout1_50ck860 FIND v(dout1_50) AT=435.025n

.meas tran vdout1_51ck860 FIND v(dout1_51) AT=435.025n

.meas tran vdout1_52ck860 FIND v(dout1_52) AT=435.025n

.meas tran vdout1_53ck860 FIND v(dout1_53) AT=435.025n

.meas tran vdout1_54ck860 FIND v(dout1_54) AT=435.025n

.meas tran vdout1_55ck860 FIND v(dout1_55) AT=435.025n

.meas tran vdout1_56ck860 FIND v(dout1_56) AT=435.025n

.meas tran vdout1_57ck860 FIND v(dout1_57) AT=435.025n

.meas tran vdout1_58ck860 FIND v(dout1_58) AT=435.025n

.meas tran vdout1_59ck860 FIND v(dout1_59) AT=435.025n

.meas tran vdout1_60ck860 FIND v(dout1_60) AT=435.025n

.meas tran vdout1_61ck860 FIND v(dout1_61) AT=435.025n

.meas tran vdout1_62ck860 FIND v(dout1_62) AT=435.025n

.meas tran vdout1_63ck860 FIND v(dout1_63) AT=435.025n

.meas tran vdout1_64ck860 FIND v(dout1_64) AT=435.025n

.meas tran vdout1_65ck860 FIND v(dout1_65) AT=435.025n

.meas tran vdout1_66ck860 FIND v(dout1_66) AT=435.025n

.meas tran vdout1_67ck860 FIND v(dout1_67) AT=435.025n

.meas tran vdout1_68ck860 FIND v(dout1_68) AT=435.025n

.meas tran vdout1_69ck860 FIND v(dout1_69) AT=435.025n

.meas tran vdout1_70ck860 FIND v(dout1_70) AT=435.025n

.meas tran vdout1_71ck860 FIND v(dout1_71) AT=435.025n

.meas tran vdout1_72ck860 FIND v(dout1_72) AT=435.025n

.meas tran vdout1_73ck860 FIND v(dout1_73) AT=435.025n

.meas tran vdout1_74ck860 FIND v(dout1_74) AT=435.025n

.meas tran vdout1_75ck860 FIND v(dout1_75) AT=435.025n

.meas tran vdout1_76ck860 FIND v(dout1_76) AT=435.025n

.meas tran vdout1_77ck860 FIND v(dout1_77) AT=435.025n

.meas tran vdout1_78ck860 FIND v(dout1_78) AT=435.025n

.meas tran vdout1_79ck860 FIND v(dout1_79) AT=435.025n

.meas tran vdout1_80ck860 FIND v(dout1_80) AT=435.025n

.meas tran vdout1_81ck860 FIND v(dout1_81) AT=435.025n

.meas tran vdout1_82ck860 FIND v(dout1_82) AT=435.025n

.meas tran vdout1_83ck860 FIND v(dout1_83) AT=435.025n

.meas tran vdout1_84ck860 FIND v(dout1_84) AT=435.025n

.meas tran vdout1_85ck860 FIND v(dout1_85) AT=435.025n

.meas tran vdout1_86ck860 FIND v(dout1_86) AT=435.025n

.meas tran vdout1_87ck860 FIND v(dout1_87) AT=435.025n

.meas tran vdout1_88ck860 FIND v(dout1_88) AT=435.025n

.meas tran vdout1_89ck860 FIND v(dout1_89) AT=435.025n

.meas tran vdout1_90ck860 FIND v(dout1_90) AT=435.025n

.meas tran vdout1_91ck860 FIND v(dout1_91) AT=435.025n

.meas tran vdout1_92ck860 FIND v(dout1_92) AT=435.025n

.meas tran vdout1_93ck860 FIND v(dout1_93) AT=435.025n

.meas tran vdout1_94ck860 FIND v(dout1_94) AT=435.025n

.meas tran vdout1_95ck860 FIND v(dout1_95) AT=435.025n

.meas tran vdout1_96ck860 FIND v(dout1_96) AT=435.025n

.meas tran vdout1_97ck860 FIND v(dout1_97) AT=435.025n

.meas tran vdout1_98ck860 FIND v(dout1_98) AT=435.025n

.meas tran vdout1_99ck860 FIND v(dout1_99) AT=435.025n

.meas tran vdout1_100ck860 FIND v(dout1_100) AT=435.025n

.meas tran vdout1_101ck860 FIND v(dout1_101) AT=435.025n

.meas tran vdout1_102ck860 FIND v(dout1_102) AT=435.025n

.meas tran vdout1_103ck860 FIND v(dout1_103) AT=435.025n

.meas tran vdout1_104ck860 FIND v(dout1_104) AT=435.025n

.meas tran vdout1_105ck860 FIND v(dout1_105) AT=435.025n

.meas tran vdout1_106ck860 FIND v(dout1_106) AT=435.025n

.meas tran vdout1_107ck860 FIND v(dout1_107) AT=435.025n

.meas tran vdout1_108ck860 FIND v(dout1_108) AT=435.025n

.meas tran vdout1_109ck860 FIND v(dout1_109) AT=435.025n

.meas tran vdout1_110ck860 FIND v(dout1_110) AT=435.025n

.meas tran vdout1_111ck860 FIND v(dout1_111) AT=435.025n

.meas tran vdout1_112ck860 FIND v(dout1_112) AT=435.025n

.meas tran vdout1_113ck860 FIND v(dout1_113) AT=435.025n

.meas tran vdout1_114ck860 FIND v(dout1_114) AT=435.025n

.meas tran vdout1_115ck860 FIND v(dout1_115) AT=435.025n

.meas tran vdout1_116ck860 FIND v(dout1_116) AT=435.025n

.meas tran vdout1_117ck860 FIND v(dout1_117) AT=435.025n

.meas tran vdout1_118ck860 FIND v(dout1_118) AT=435.025n

.meas tran vdout1_119ck860 FIND v(dout1_119) AT=435.025n

.meas tran vdout1_120ck860 FIND v(dout1_120) AT=435.025n

.meas tran vdout1_121ck860 FIND v(dout1_121) AT=435.025n

.meas tran vdout1_122ck860 FIND v(dout1_122) AT=435.025n

.meas tran vdout1_123ck860 FIND v(dout1_123) AT=435.025n

.meas tran vdout1_124ck860 FIND v(dout1_124) AT=435.025n

.meas tran vdout1_125ck860 FIND v(dout1_125) AT=435.025n

.meas tran vdout1_126ck860 FIND v(dout1_126) AT=435.025n

.meas tran vdout1_127ck860 FIND v(dout1_127) AT=435.025n

.meas tran vdout1_128ck860 FIND v(dout1_128) AT=435.025n

.meas tran vdout1_129ck860 FIND v(dout1_129) AT=435.025n

.meas tran vdout1_130ck860 FIND v(dout1_130) AT=435.025n

.meas tran vdout1_131ck860 FIND v(dout1_131) AT=435.025n

.meas tran vdout1_132ck860 FIND v(dout1_132) AT=435.025n

.meas tran vdout1_133ck860 FIND v(dout1_133) AT=435.025n

.meas tran vdout1_134ck860 FIND v(dout1_134) AT=435.025n

.meas tran vdout1_135ck860 FIND v(dout1_135) AT=435.025n

.meas tran vdout1_136ck860 FIND v(dout1_136) AT=435.025n

.meas tran vdout1_137ck860 FIND v(dout1_137) AT=435.025n

.meas tran vdout1_138ck860 FIND v(dout1_138) AT=435.025n

.meas tran vdout1_139ck860 FIND v(dout1_139) AT=435.025n

.meas tran vdout1_140ck860 FIND v(dout1_140) AT=435.025n

.meas tran vdout1_141ck860 FIND v(dout1_141) AT=435.025n

.meas tran vdout1_142ck860 FIND v(dout1_142) AT=435.025n

.meas tran vdout1_143ck860 FIND v(dout1_143) AT=435.025n

.meas tran vdout1_144ck860 FIND v(dout1_144) AT=435.025n

.meas tran vdout1_145ck860 FIND v(dout1_145) AT=435.025n

.meas tran vdout1_146ck860 FIND v(dout1_146) AT=435.025n

.meas tran vdout1_147ck860 FIND v(dout1_147) AT=435.025n

.meas tran vdout1_148ck860 FIND v(dout1_148) AT=435.025n

.meas tran vdout1_149ck860 FIND v(dout1_149) AT=435.025n

.meas tran vdout1_150ck860 FIND v(dout1_150) AT=435.025n

.meas tran vdout1_151ck860 FIND v(dout1_151) AT=435.025n

.meas tran vdout1_152ck860 FIND v(dout1_152) AT=435.025n

.meas tran vdout1_153ck860 FIND v(dout1_153) AT=435.025n

.meas tran vdout1_154ck860 FIND v(dout1_154) AT=435.025n

.meas tran vdout1_155ck860 FIND v(dout1_155) AT=435.025n

.meas tran vdout1_156ck860 FIND v(dout1_156) AT=435.025n

.meas tran vdout1_157ck860 FIND v(dout1_157) AT=435.025n

.meas tran vdout1_158ck860 FIND v(dout1_158) AT=435.025n

.meas tran vdout1_159ck860 FIND v(dout1_159) AT=435.025n

.meas tran vdout1_160ck860 FIND v(dout1_160) AT=435.025n

.meas tran vdout1_161ck860 FIND v(dout1_161) AT=435.025n

.meas tran vdout1_162ck860 FIND v(dout1_162) AT=435.025n

.meas tran vdout1_163ck860 FIND v(dout1_163) AT=435.025n

.meas tran vdout1_164ck860 FIND v(dout1_164) AT=435.025n

.meas tran vdout1_165ck860 FIND v(dout1_165) AT=435.025n

.meas tran vdout1_166ck860 FIND v(dout1_166) AT=435.025n

.meas tran vdout1_167ck860 FIND v(dout1_167) AT=435.025n

.meas tran vdout1_168ck860 FIND v(dout1_168) AT=435.025n

.meas tran vdout1_169ck860 FIND v(dout1_169) AT=435.025n

.meas tran vdout1_170ck860 FIND v(dout1_170) AT=435.025n

.meas tran vdout1_171ck860 FIND v(dout1_171) AT=435.025n

.meas tran vdout1_172ck860 FIND v(dout1_172) AT=435.025n

.meas tran vdout1_173ck860 FIND v(dout1_173) AT=435.025n

.meas tran vdout1_174ck860 FIND v(dout1_174) AT=435.025n

.meas tran vdout1_175ck860 FIND v(dout1_175) AT=435.025n

.meas tran vdout1_176ck860 FIND v(dout1_176) AT=435.025n

.meas tran vdout1_177ck860 FIND v(dout1_177) AT=435.025n

.meas tran vdout1_178ck860 FIND v(dout1_178) AT=435.025n

.meas tran vdout1_179ck860 FIND v(dout1_179) AT=435.025n

.meas tran vdout1_180ck860 FIND v(dout1_180) AT=435.025n

.meas tran vdout1_181ck860 FIND v(dout1_181) AT=435.025n

.meas tran vdout1_182ck860 FIND v(dout1_182) AT=435.025n

.meas tran vdout1_183ck860 FIND v(dout1_183) AT=435.025n

.meas tran vdout1_184ck860 FIND v(dout1_184) AT=435.025n

.meas tran vdout1_185ck860 FIND v(dout1_185) AT=435.025n

.meas tran vdout1_186ck860 FIND v(dout1_186) AT=435.025n

.meas tran vdout1_187ck860 FIND v(dout1_187) AT=435.025n

.meas tran vdout1_188ck860 FIND v(dout1_188) AT=435.025n

.meas tran vdout1_189ck860 FIND v(dout1_189) AT=435.025n

.meas tran vdout1_190ck860 FIND v(dout1_190) AT=435.025n

.meas tran vdout1_191ck860 FIND v(dout1_191) AT=435.025n

.meas tran vdout1_192ck860 FIND v(dout1_192) AT=435.025n

.meas tran vdout1_193ck860 FIND v(dout1_193) AT=435.025n

.meas tran vdout1_194ck860 FIND v(dout1_194) AT=435.025n

.meas tran vdout1_195ck860 FIND v(dout1_195) AT=435.025n

.meas tran vdout1_196ck860 FIND v(dout1_196) AT=435.025n

.meas tran vdout1_197ck860 FIND v(dout1_197) AT=435.025n

.meas tran vdout1_198ck860 FIND v(dout1_198) AT=435.025n

.meas tran vdout1_199ck860 FIND v(dout1_199) AT=435.025n

.meas tran vdout1_200ck860 FIND v(dout1_200) AT=435.025n

.meas tran vdout1_201ck860 FIND v(dout1_201) AT=435.025n

.meas tran vdout1_202ck860 FIND v(dout1_202) AT=435.025n

.meas tran vdout1_203ck860 FIND v(dout1_203) AT=435.025n

.meas tran vdout1_204ck860 FIND v(dout1_204) AT=435.025n

.meas tran vdout1_205ck860 FIND v(dout1_205) AT=435.025n

.meas tran vdout1_206ck860 FIND v(dout1_206) AT=435.025n

.meas tran vdout1_207ck860 FIND v(dout1_207) AT=435.025n

.meas tran vdout1_208ck860 FIND v(dout1_208) AT=435.025n

.meas tran vdout1_209ck860 FIND v(dout1_209) AT=435.025n

.meas tran vdout1_210ck860 FIND v(dout1_210) AT=435.025n

.meas tran vdout1_211ck860 FIND v(dout1_211) AT=435.025n

.meas tran vdout1_212ck860 FIND v(dout1_212) AT=435.025n

.meas tran vdout1_213ck860 FIND v(dout1_213) AT=435.025n

.meas tran vdout1_214ck860 FIND v(dout1_214) AT=435.025n

.meas tran vdout1_215ck860 FIND v(dout1_215) AT=435.025n

.meas tran vdout1_216ck860 FIND v(dout1_216) AT=435.025n

.meas tran vdout1_217ck860 FIND v(dout1_217) AT=435.025n

.meas tran vdout1_218ck860 FIND v(dout1_218) AT=435.025n

.meas tran vdout1_219ck860 FIND v(dout1_219) AT=435.025n

.meas tran vdout1_220ck860 FIND v(dout1_220) AT=435.025n

.meas tran vdout1_221ck860 FIND v(dout1_221) AT=435.025n

.meas tran vdout1_222ck860 FIND v(dout1_222) AT=435.025n

.meas tran vdout1_223ck860 FIND v(dout1_223) AT=435.025n

.meas tran vdout1_224ck860 FIND v(dout1_224) AT=435.025n

.meas tran vdout1_225ck860 FIND v(dout1_225) AT=435.025n

.meas tran vdout1_226ck860 FIND v(dout1_226) AT=435.025n

.meas tran vdout1_227ck860 FIND v(dout1_227) AT=435.025n

.meas tran vdout1_228ck860 FIND v(dout1_228) AT=435.025n

.meas tran vdout1_229ck860 FIND v(dout1_229) AT=435.025n

.meas tran vdout1_230ck860 FIND v(dout1_230) AT=435.025n

.meas tran vdout1_231ck860 FIND v(dout1_231) AT=435.025n

.meas tran vdout1_232ck860 FIND v(dout1_232) AT=435.025n

.meas tran vdout1_233ck860 FIND v(dout1_233) AT=435.025n

.meas tran vdout1_234ck860 FIND v(dout1_234) AT=435.025n

.meas tran vdout1_235ck860 FIND v(dout1_235) AT=435.025n

.meas tran vdout1_236ck860 FIND v(dout1_236) AT=435.025n

.meas tran vdout1_237ck860 FIND v(dout1_237) AT=435.025n

.meas tran vdout1_238ck860 FIND v(dout1_238) AT=435.025n

.meas tran vdout1_239ck860 FIND v(dout1_239) AT=435.025n

.meas tran vdout1_240ck860 FIND v(dout1_240) AT=435.025n

.meas tran vdout1_241ck860 FIND v(dout1_241) AT=435.025n

.meas tran vdout1_242ck860 FIND v(dout1_242) AT=435.025n

.meas tran vdout1_243ck860 FIND v(dout1_243) AT=435.025n

.meas tran vdout1_244ck860 FIND v(dout1_244) AT=435.025n

.meas tran vdout1_245ck860 FIND v(dout1_245) AT=435.025n

.meas tran vdout1_246ck860 FIND v(dout1_246) AT=435.025n

.meas tran vdout1_247ck860 FIND v(dout1_247) AT=435.025n

.meas tran vdout1_248ck860 FIND v(dout1_248) AT=435.025n

.meas tran vdout1_249ck860 FIND v(dout1_249) AT=435.025n

.meas tran vdout1_250ck860 FIND v(dout1_250) AT=435.025n

.meas tran vdout1_251ck860 FIND v(dout1_251) AT=435.025n

.meas tran vdout1_252ck860 FIND v(dout1_252) AT=435.025n

.meas tran vdout1_253ck860 FIND v(dout1_253) AT=435.025n

.meas tran vdout1_254ck860 FIND v(dout1_254) AT=435.025n

.meas tran vdout1_255ck860 FIND v(dout1_255) AT=435.025n

.meas tran vdout1_256ck860 FIND v(dout1_256) AT=435.025n

.meas tran vdout1_257ck860 FIND v(dout1_257) AT=435.025n

.meas tran vdout1_258ck860 FIND v(dout1_258) AT=435.025n

.meas tran vdout1_259ck860 FIND v(dout1_259) AT=435.025n

.meas tran vdout1_260ck860 FIND v(dout1_260) AT=435.025n

.meas tran vdout1_261ck860 FIND v(dout1_261) AT=435.025n

.meas tran vdout1_262ck860 FIND v(dout1_262) AT=435.025n

.meas tran vdout1_263ck860 FIND v(dout1_263) AT=435.025n

.meas tran vdout1_264ck860 FIND v(dout1_264) AT=435.025n

.meas tran vdout1_265ck860 FIND v(dout1_265) AT=435.025n

.meas tran vdout1_266ck860 FIND v(dout1_266) AT=435.025n

.meas tran vdout1_267ck860 FIND v(dout1_267) AT=435.025n

.meas tran vdout1_268ck860 FIND v(dout1_268) AT=435.025n

.meas tran vdout1_269ck860 FIND v(dout1_269) AT=435.025n

.meas tran vdout1_270ck860 FIND v(dout1_270) AT=435.025n

.meas tran vdout1_271ck860 FIND v(dout1_271) AT=435.025n

.meas tran vdout1_272ck860 FIND v(dout1_272) AT=435.025n

.meas tran vdout1_273ck860 FIND v(dout1_273) AT=435.025n

.meas tran vdout1_274ck860 FIND v(dout1_274) AT=435.025n

.meas tran vdout1_275ck860 FIND v(dout1_275) AT=435.025n

.meas tran vdout1_276ck860 FIND v(dout1_276) AT=435.025n

.meas tran vdout1_277ck860 FIND v(dout1_277) AT=435.025n

.meas tran vdout1_278ck860 FIND v(dout1_278) AT=435.025n

.meas tran vdout1_279ck860 FIND v(dout1_279) AT=435.025n

.meas tran vdout1_280ck860 FIND v(dout1_280) AT=435.025n

.meas tran vdout1_281ck860 FIND v(dout1_281) AT=435.025n

.meas tran vdout1_282ck860 FIND v(dout1_282) AT=435.025n

.meas tran vdout1_283ck860 FIND v(dout1_283) AT=435.025n

.meas tran vdout1_284ck860 FIND v(dout1_284) AT=435.025n

.meas tran vdout1_285ck860 FIND v(dout1_285) AT=435.025n

.meas tran vdout1_286ck860 FIND v(dout1_286) AT=435.025n

.meas tran vdout1_287ck860 FIND v(dout1_287) AT=435.025n

.meas tran vdout1_288ck860 FIND v(dout1_288) AT=435.025n

.meas tran vdout1_289ck860 FIND v(dout1_289) AT=435.025n

.meas tran vdout1_290ck860 FIND v(dout1_290) AT=435.025n

.meas tran vdout1_291ck860 FIND v(dout1_291) AT=435.025n

.meas tran vdout1_292ck860 FIND v(dout1_292) AT=435.025n

.meas tran vdout1_293ck860 FIND v(dout1_293) AT=435.025n

.meas tran vdout1_294ck860 FIND v(dout1_294) AT=435.025n

.meas tran vdout1_295ck860 FIND v(dout1_295) AT=435.025n

.meas tran vdout1_296ck860 FIND v(dout1_296) AT=435.025n

.meas tran vdout1_297ck860 FIND v(dout1_297) AT=435.025n

.meas tran vdout1_298ck860 FIND v(dout1_298) AT=435.025n

.meas tran vdout1_299ck860 FIND v(dout1_299) AT=435.025n

.meas tran vdout1_300ck860 FIND v(dout1_300) AT=435.025n

.meas tran vdout1_301ck860 FIND v(dout1_301) AT=435.025n

.meas tran vdout1_302ck860 FIND v(dout1_302) AT=435.025n

.meas tran vdout1_303ck860 FIND v(dout1_303) AT=435.025n

.meas tran vdout1_304ck860 FIND v(dout1_304) AT=435.025n

.meas tran vdout1_305ck860 FIND v(dout1_305) AT=435.025n

.meas tran vdout1_306ck860 FIND v(dout1_306) AT=435.025n

.meas tran vdout1_307ck860 FIND v(dout1_307) AT=435.025n

.meas tran vdout1_308ck860 FIND v(dout1_308) AT=435.025n

.meas tran vdout1_309ck860 FIND v(dout1_309) AT=435.025n

.meas tran vdout1_310ck860 FIND v(dout1_310) AT=435.025n

.meas tran vdout1_311ck860 FIND v(dout1_311) AT=435.025n

.meas tran vdout1_312ck860 FIND v(dout1_312) AT=435.025n

.meas tran vdout1_313ck860 FIND v(dout1_313) AT=435.025n

.meas tran vdout1_314ck860 FIND v(dout1_314) AT=435.025n

.meas tran vdout1_315ck860 FIND v(dout1_315) AT=435.025n

.meas tran vdout1_316ck860 FIND v(dout1_316) AT=435.025n

.meas tran vdout1_317ck860 FIND v(dout1_317) AT=435.025n

.meas tran vdout1_318ck860 FIND v(dout1_318) AT=435.025n

.meas tran vdout1_319ck860 FIND v(dout1_319) AT=435.025n

.meas tran vdout1_320ck860 FIND v(dout1_320) AT=435.025n

.meas tran vdout1_321ck860 FIND v(dout1_321) AT=435.025n

.meas tran vdout1_322ck860 FIND v(dout1_322) AT=435.025n

.meas tran vdout1_323ck860 FIND v(dout1_323) AT=435.025n

.meas tran vdout1_324ck860 FIND v(dout1_324) AT=435.025n

.meas tran vdout1_325ck860 FIND v(dout1_325) AT=435.025n

.meas tran vdout1_326ck860 FIND v(dout1_326) AT=435.025n

.meas tran vdout1_327ck860 FIND v(dout1_327) AT=435.025n

.meas tran vdout1_328ck860 FIND v(dout1_328) AT=435.025n

.meas tran vdout1_329ck860 FIND v(dout1_329) AT=435.025n

.meas tran vdout1_330ck860 FIND v(dout1_330) AT=435.025n

.meas tran vdout1_331ck860 FIND v(dout1_331) AT=435.025n

.meas tran vdout1_332ck860 FIND v(dout1_332) AT=435.025n

.meas tran vdout1_333ck860 FIND v(dout1_333) AT=435.025n

.meas tran vdout1_334ck860 FIND v(dout1_334) AT=435.025n

.meas tran vdout1_335ck860 FIND v(dout1_335) AT=435.025n

.meas tran vdout1_336ck860 FIND v(dout1_336) AT=435.025n

.meas tran vdout1_337ck860 FIND v(dout1_337) AT=435.025n

.meas tran vdout1_338ck860 FIND v(dout1_338) AT=435.025n

.meas tran vdout1_339ck860 FIND v(dout1_339) AT=435.025n

.meas tran vdout1_340ck860 FIND v(dout1_340) AT=435.025n

.meas tran vdout1_341ck860 FIND v(dout1_341) AT=435.025n

.meas tran vdout1_342ck860 FIND v(dout1_342) AT=435.025n

.meas tran vdout1_343ck860 FIND v(dout1_343) AT=435.025n

.meas tran vdout1_344ck860 FIND v(dout1_344) AT=435.025n

.meas tran vdout1_345ck860 FIND v(dout1_345) AT=435.025n

.meas tran vdout1_346ck860 FIND v(dout1_346) AT=435.025n

.meas tran vdout1_347ck860 FIND v(dout1_347) AT=435.025n

.meas tran vdout1_348ck860 FIND v(dout1_348) AT=435.025n

.meas tran vdout1_349ck860 FIND v(dout1_349) AT=435.025n

.meas tran vdout1_350ck860 FIND v(dout1_350) AT=435.025n

.meas tran vdout1_351ck860 FIND v(dout1_351) AT=435.025n

.meas tran vdout1_352ck860 FIND v(dout1_352) AT=435.025n

.meas tran vdout1_353ck860 FIND v(dout1_353) AT=435.025n

.meas tran vdout1_354ck860 FIND v(dout1_354) AT=435.025n

.meas tran vdout1_355ck860 FIND v(dout1_355) AT=435.025n

.meas tran vdout1_356ck860 FIND v(dout1_356) AT=435.025n

.meas tran vdout1_357ck860 FIND v(dout1_357) AT=435.025n

.meas tran vdout1_358ck860 FIND v(dout1_358) AT=435.025n

.meas tran vdout1_359ck860 FIND v(dout1_359) AT=435.025n

.meas tran vdout1_360ck860 FIND v(dout1_360) AT=435.025n

.meas tran vdout1_361ck860 FIND v(dout1_361) AT=435.025n

.meas tran vdout1_362ck860 FIND v(dout1_362) AT=435.025n

.meas tran vdout1_363ck860 FIND v(dout1_363) AT=435.025n

.meas tran vdout1_364ck860 FIND v(dout1_364) AT=435.025n

.meas tran vdout1_365ck860 FIND v(dout1_365) AT=435.025n

.meas tran vdout1_366ck860 FIND v(dout1_366) AT=435.025n

.meas tran vdout1_367ck860 FIND v(dout1_367) AT=435.025n

.meas tran vdout1_368ck860 FIND v(dout1_368) AT=435.025n

.meas tran vdout1_369ck860 FIND v(dout1_369) AT=435.025n

.meas tran vdout1_370ck860 FIND v(dout1_370) AT=435.025n

.meas tran vdout1_371ck860 FIND v(dout1_371) AT=435.025n

.meas tran vdout1_372ck860 FIND v(dout1_372) AT=435.025n

.meas tran vdout1_373ck860 FIND v(dout1_373) AT=435.025n

.meas tran vdout1_374ck860 FIND v(dout1_374) AT=435.025n

.meas tran vdout1_375ck860 FIND v(dout1_375) AT=435.025n

.meas tran vdout1_376ck860 FIND v(dout1_376) AT=435.025n

.meas tran vdout1_377ck860 FIND v(dout1_377) AT=435.025n

.meas tran vdout1_378ck860 FIND v(dout1_378) AT=435.025n

.meas tran vdout1_379ck860 FIND v(dout1_379) AT=435.025n

.meas tran vdout1_380ck860 FIND v(dout1_380) AT=435.025n

.meas tran vdout1_381ck860 FIND v(dout1_381) AT=435.025n

.meas tran vdout1_382ck860 FIND v(dout1_382) AT=435.025n

.meas tran vdout1_383ck860 FIND v(dout1_383) AT=435.025n

.meas tran vdout1_384ck860 FIND v(dout1_384) AT=435.025n

.meas tran vdout1_385ck860 FIND v(dout1_385) AT=435.025n

.meas tran vdout1_386ck860 FIND v(dout1_386) AT=435.025n

.meas tran vdout1_387ck860 FIND v(dout1_387) AT=435.025n

.meas tran vdout1_388ck860 FIND v(dout1_388) AT=435.025n

.meas tran vdout1_389ck860 FIND v(dout1_389) AT=435.025n

.meas tran vdout1_390ck860 FIND v(dout1_390) AT=435.025n

.meas tran vdout1_391ck860 FIND v(dout1_391) AT=435.025n

.meas tran vdout1_392ck860 FIND v(dout1_392) AT=435.025n

.meas tran vdout1_393ck860 FIND v(dout1_393) AT=435.025n

.meas tran vdout1_394ck860 FIND v(dout1_394) AT=435.025n

.meas tran vdout1_395ck860 FIND v(dout1_395) AT=435.025n

.meas tran vdout1_396ck860 FIND v(dout1_396) AT=435.025n

.meas tran vdout1_397ck860 FIND v(dout1_397) AT=435.025n

.meas tran vdout1_398ck860 FIND v(dout1_398) AT=435.025n

.meas tran vdout1_399ck860 FIND v(dout1_399) AT=435.025n

.meas tran vdout1_400ck860 FIND v(dout1_400) AT=435.025n

.meas tran vdout1_401ck860 FIND v(dout1_401) AT=435.025n

.meas tran vdout1_402ck860 FIND v(dout1_402) AT=435.025n

.meas tran vdout1_403ck860 FIND v(dout1_403) AT=435.025n

.meas tran vdout1_404ck860 FIND v(dout1_404) AT=435.025n

.meas tran vdout1_405ck860 FIND v(dout1_405) AT=435.025n

.meas tran vdout1_406ck860 FIND v(dout1_406) AT=435.025n

.meas tran vdout1_407ck860 FIND v(dout1_407) AT=435.025n

.meas tran vdout1_408ck860 FIND v(dout1_408) AT=435.025n

.meas tran vdout1_409ck860 FIND v(dout1_409) AT=435.025n

.meas tran vdout1_410ck860 FIND v(dout1_410) AT=435.025n

.meas tran vdout1_411ck860 FIND v(dout1_411) AT=435.025n

.meas tran vdout1_412ck860 FIND v(dout1_412) AT=435.025n

.meas tran vdout1_413ck860 FIND v(dout1_413) AT=435.025n

.meas tran vdout1_414ck860 FIND v(dout1_414) AT=435.025n

.meas tran vdout1_415ck860 FIND v(dout1_415) AT=435.025n

.meas tran vdout1_416ck860 FIND v(dout1_416) AT=435.025n

.meas tran vdout1_417ck860 FIND v(dout1_417) AT=435.025n

.meas tran vdout1_418ck860 FIND v(dout1_418) AT=435.025n

.meas tran vdout1_419ck860 FIND v(dout1_419) AT=435.025n

.meas tran vdout1_420ck860 FIND v(dout1_420) AT=435.025n

.meas tran vdout1_421ck860 FIND v(dout1_421) AT=435.025n

.meas tran vdout1_422ck860 FIND v(dout1_422) AT=435.025n

.meas tran vdout1_423ck860 FIND v(dout1_423) AT=435.025n

.meas tran vdout1_424ck860 FIND v(dout1_424) AT=435.025n

.meas tran vdout1_425ck860 FIND v(dout1_425) AT=435.025n

.meas tran vdout1_426ck860 FIND v(dout1_426) AT=435.025n

.meas tran vdout1_427ck860 FIND v(dout1_427) AT=435.025n

.meas tran vdout1_428ck860 FIND v(dout1_428) AT=435.025n

.meas tran vdout1_429ck860 FIND v(dout1_429) AT=435.025n

.meas tran vdout1_430ck860 FIND v(dout1_430) AT=435.025n

.meas tran vdout1_431ck860 FIND v(dout1_431) AT=435.025n

.meas tran vdout1_432ck860 FIND v(dout1_432) AT=435.025n

.meas tran vdout1_433ck860 FIND v(dout1_433) AT=435.025n

.meas tran vdout1_434ck860 FIND v(dout1_434) AT=435.025n

.meas tran vdout1_435ck860 FIND v(dout1_435) AT=435.025n

.meas tran vdout1_436ck860 FIND v(dout1_436) AT=435.025n

.meas tran vdout1_437ck860 FIND v(dout1_437) AT=435.025n

.meas tran vdout1_438ck860 FIND v(dout1_438) AT=435.025n

.meas tran vdout1_439ck860 FIND v(dout1_439) AT=435.025n

.meas tran vdout1_440ck860 FIND v(dout1_440) AT=435.025n

.meas tran vdout1_441ck860 FIND v(dout1_441) AT=435.025n

.meas tran vdout1_442ck860 FIND v(dout1_442) AT=435.025n

.meas tran vdout1_443ck860 FIND v(dout1_443) AT=435.025n

.meas tran vdout1_444ck860 FIND v(dout1_444) AT=435.025n

.meas tran vdout1_445ck860 FIND v(dout1_445) AT=435.025n

.meas tran vdout1_446ck860 FIND v(dout1_446) AT=435.025n

.meas tran vdout1_447ck860 FIND v(dout1_447) AT=435.025n

.meas tran vdout1_448ck860 FIND v(dout1_448) AT=435.025n

.meas tran vdout1_449ck860 FIND v(dout1_449) AT=435.025n

.meas tran vdout1_450ck860 FIND v(dout1_450) AT=435.025n

.meas tran vdout1_451ck860 FIND v(dout1_451) AT=435.025n

.meas tran vdout1_452ck860 FIND v(dout1_452) AT=435.025n

.meas tran vdout1_453ck860 FIND v(dout1_453) AT=435.025n

.meas tran vdout1_454ck860 FIND v(dout1_454) AT=435.025n

.meas tran vdout1_455ck860 FIND v(dout1_455) AT=435.025n

.meas tran vdout1_456ck860 FIND v(dout1_456) AT=435.025n

.meas tran vdout1_457ck860 FIND v(dout1_457) AT=435.025n

.meas tran vdout1_458ck860 FIND v(dout1_458) AT=435.025n

.meas tran vdout1_459ck860 FIND v(dout1_459) AT=435.025n

.meas tran vdout1_460ck860 FIND v(dout1_460) AT=435.025n

.meas tran vdout1_461ck860 FIND v(dout1_461) AT=435.025n

.meas tran vdout1_462ck860 FIND v(dout1_462) AT=435.025n

.meas tran vdout1_463ck860 FIND v(dout1_463) AT=435.025n

.meas tran vdout1_464ck860 FIND v(dout1_464) AT=435.025n

.meas tran vdout1_465ck860 FIND v(dout1_465) AT=435.025n

.meas tran vdout1_466ck860 FIND v(dout1_466) AT=435.025n

.meas tran vdout1_467ck860 FIND v(dout1_467) AT=435.025n

.meas tran vdout1_468ck860 FIND v(dout1_468) AT=435.025n

.meas tran vdout1_469ck860 FIND v(dout1_469) AT=435.025n

.meas tran vdout1_470ck860 FIND v(dout1_470) AT=435.025n

.meas tran vdout1_471ck860 FIND v(dout1_471) AT=435.025n

.meas tran vdout1_472ck860 FIND v(dout1_472) AT=435.025n

.meas tran vdout1_473ck860 FIND v(dout1_473) AT=435.025n

.meas tran vdout1_474ck860 FIND v(dout1_474) AT=435.025n

.meas tran vdout1_475ck860 FIND v(dout1_475) AT=435.025n

.meas tran vdout1_476ck860 FIND v(dout1_476) AT=435.025n

.meas tran vdout1_477ck860 FIND v(dout1_477) AT=435.025n

.meas tran vdout1_478ck860 FIND v(dout1_478) AT=435.025n

.meas tran vdout1_479ck860 FIND v(dout1_479) AT=435.025n

.meas tran vdout1_480ck860 FIND v(dout1_480) AT=435.025n

.meas tran vdout1_481ck860 FIND v(dout1_481) AT=435.025n

.meas tran vdout1_482ck860 FIND v(dout1_482) AT=435.025n

.meas tran vdout1_483ck860 FIND v(dout1_483) AT=435.025n

.meas tran vdout1_484ck860 FIND v(dout1_484) AT=435.025n

.meas tran vdout1_485ck860 FIND v(dout1_485) AT=435.025n

.meas tran vdout1_486ck860 FIND v(dout1_486) AT=435.025n

.meas tran vdout1_487ck860 FIND v(dout1_487) AT=435.025n

.meas tran vdout1_488ck860 FIND v(dout1_488) AT=435.025n

.meas tran vdout1_489ck860 FIND v(dout1_489) AT=435.025n

.meas tran vdout1_490ck860 FIND v(dout1_490) AT=435.025n

.meas tran vdout1_491ck860 FIND v(dout1_491) AT=435.025n

.meas tran vdout1_492ck860 FIND v(dout1_492) AT=435.025n

.meas tran vdout1_493ck860 FIND v(dout1_493) AT=435.025n

.meas tran vdout1_494ck860 FIND v(dout1_494) AT=435.025n

.meas tran vdout1_495ck860 FIND v(dout1_495) AT=435.025n

.meas tran vdout1_496ck860 FIND v(dout1_496) AT=435.025n

.meas tran vdout1_497ck860 FIND v(dout1_497) AT=435.025n

.meas tran vdout1_498ck860 FIND v(dout1_498) AT=435.025n

.meas tran vdout1_499ck860 FIND v(dout1_499) AT=435.025n

.meas tran vdout1_500ck860 FIND v(dout1_500) AT=435.025n

.meas tran vdout1_501ck860 FIND v(dout1_501) AT=435.025n

.meas tran vdout1_502ck860 FIND v(dout1_502) AT=435.025n

.meas tran vdout1_503ck860 FIND v(dout1_503) AT=435.025n

.meas tran vdout1_504ck860 FIND v(dout1_504) AT=435.025n

.meas tran vdout1_505ck860 FIND v(dout1_505) AT=435.025n

.meas tran vdout1_506ck860 FIND v(dout1_506) AT=435.025n

.meas tran vdout1_507ck860 FIND v(dout1_507) AT=435.025n

.meas tran vdout1_508ck860 FIND v(dout1_508) AT=435.025n

.meas tran vdout1_509ck860 FIND v(dout1_509) AT=435.025n

.meas tran vdout1_510ck860 FIND v(dout1_510) AT=435.025n

.meas tran vdout1_511ck860 FIND v(dout1_511) AT=435.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_16ck920 FIND v(dout1_16) AT=465.025n

.meas tran vdout1_17ck920 FIND v(dout1_17) AT=465.025n

.meas tran vdout1_18ck920 FIND v(dout1_18) AT=465.025n

.meas tran vdout1_19ck920 FIND v(dout1_19) AT=465.025n

.meas tran vdout1_20ck920 FIND v(dout1_20) AT=465.025n

.meas tran vdout1_21ck920 FIND v(dout1_21) AT=465.025n

.meas tran vdout1_22ck920 FIND v(dout1_22) AT=465.025n

.meas tran vdout1_23ck920 FIND v(dout1_23) AT=465.025n

.meas tran vdout1_24ck920 FIND v(dout1_24) AT=465.025n

.meas tran vdout1_25ck920 FIND v(dout1_25) AT=465.025n

.meas tran vdout1_26ck920 FIND v(dout1_26) AT=465.025n

.meas tran vdout1_27ck920 FIND v(dout1_27) AT=465.025n

.meas tran vdout1_28ck920 FIND v(dout1_28) AT=465.025n

.meas tran vdout1_29ck920 FIND v(dout1_29) AT=465.025n

.meas tran vdout1_30ck920 FIND v(dout1_30) AT=465.025n

.meas tran vdout1_31ck920 FIND v(dout1_31) AT=465.025n

.meas tran vdout1_32ck920 FIND v(dout1_32) AT=465.025n

.meas tran vdout1_33ck920 FIND v(dout1_33) AT=465.025n

.meas tran vdout1_34ck920 FIND v(dout1_34) AT=465.025n

.meas tran vdout1_35ck920 FIND v(dout1_35) AT=465.025n

.meas tran vdout1_36ck920 FIND v(dout1_36) AT=465.025n

.meas tran vdout1_37ck920 FIND v(dout1_37) AT=465.025n

.meas tran vdout1_38ck920 FIND v(dout1_38) AT=465.025n

.meas tran vdout1_39ck920 FIND v(dout1_39) AT=465.025n

.meas tran vdout1_40ck920 FIND v(dout1_40) AT=465.025n

.meas tran vdout1_41ck920 FIND v(dout1_41) AT=465.025n

.meas tran vdout1_42ck920 FIND v(dout1_42) AT=465.025n

.meas tran vdout1_43ck920 FIND v(dout1_43) AT=465.025n

.meas tran vdout1_44ck920 FIND v(dout1_44) AT=465.025n

.meas tran vdout1_45ck920 FIND v(dout1_45) AT=465.025n

.meas tran vdout1_46ck920 FIND v(dout1_46) AT=465.025n

.meas tran vdout1_47ck920 FIND v(dout1_47) AT=465.025n

.meas tran vdout1_48ck920 FIND v(dout1_48) AT=465.025n

.meas tran vdout1_49ck920 FIND v(dout1_49) AT=465.025n

.meas tran vdout1_50ck920 FIND v(dout1_50) AT=465.025n

.meas tran vdout1_51ck920 FIND v(dout1_51) AT=465.025n

.meas tran vdout1_52ck920 FIND v(dout1_52) AT=465.025n

.meas tran vdout1_53ck920 FIND v(dout1_53) AT=465.025n

.meas tran vdout1_54ck920 FIND v(dout1_54) AT=465.025n

.meas tran vdout1_55ck920 FIND v(dout1_55) AT=465.025n

.meas tran vdout1_56ck920 FIND v(dout1_56) AT=465.025n

.meas tran vdout1_57ck920 FIND v(dout1_57) AT=465.025n

.meas tran vdout1_58ck920 FIND v(dout1_58) AT=465.025n

.meas tran vdout1_59ck920 FIND v(dout1_59) AT=465.025n

.meas tran vdout1_60ck920 FIND v(dout1_60) AT=465.025n

.meas tran vdout1_61ck920 FIND v(dout1_61) AT=465.025n

.meas tran vdout1_62ck920 FIND v(dout1_62) AT=465.025n

.meas tran vdout1_63ck920 FIND v(dout1_63) AT=465.025n

.meas tran vdout1_64ck920 FIND v(dout1_64) AT=465.025n

.meas tran vdout1_65ck920 FIND v(dout1_65) AT=465.025n

.meas tran vdout1_66ck920 FIND v(dout1_66) AT=465.025n

.meas tran vdout1_67ck920 FIND v(dout1_67) AT=465.025n

.meas tran vdout1_68ck920 FIND v(dout1_68) AT=465.025n

.meas tran vdout1_69ck920 FIND v(dout1_69) AT=465.025n

.meas tran vdout1_70ck920 FIND v(dout1_70) AT=465.025n

.meas tran vdout1_71ck920 FIND v(dout1_71) AT=465.025n

.meas tran vdout1_72ck920 FIND v(dout1_72) AT=465.025n

.meas tran vdout1_73ck920 FIND v(dout1_73) AT=465.025n

.meas tran vdout1_74ck920 FIND v(dout1_74) AT=465.025n

.meas tran vdout1_75ck920 FIND v(dout1_75) AT=465.025n

.meas tran vdout1_76ck920 FIND v(dout1_76) AT=465.025n

.meas tran vdout1_77ck920 FIND v(dout1_77) AT=465.025n

.meas tran vdout1_78ck920 FIND v(dout1_78) AT=465.025n

.meas tran vdout1_79ck920 FIND v(dout1_79) AT=465.025n

.meas tran vdout1_80ck920 FIND v(dout1_80) AT=465.025n

.meas tran vdout1_81ck920 FIND v(dout1_81) AT=465.025n

.meas tran vdout1_82ck920 FIND v(dout1_82) AT=465.025n

.meas tran vdout1_83ck920 FIND v(dout1_83) AT=465.025n

.meas tran vdout1_84ck920 FIND v(dout1_84) AT=465.025n

.meas tran vdout1_85ck920 FIND v(dout1_85) AT=465.025n

.meas tran vdout1_86ck920 FIND v(dout1_86) AT=465.025n

.meas tran vdout1_87ck920 FIND v(dout1_87) AT=465.025n

.meas tran vdout1_88ck920 FIND v(dout1_88) AT=465.025n

.meas tran vdout1_89ck920 FIND v(dout1_89) AT=465.025n

.meas tran vdout1_90ck920 FIND v(dout1_90) AT=465.025n

.meas tran vdout1_91ck920 FIND v(dout1_91) AT=465.025n

.meas tran vdout1_92ck920 FIND v(dout1_92) AT=465.025n

.meas tran vdout1_93ck920 FIND v(dout1_93) AT=465.025n

.meas tran vdout1_94ck920 FIND v(dout1_94) AT=465.025n

.meas tran vdout1_95ck920 FIND v(dout1_95) AT=465.025n

.meas tran vdout1_96ck920 FIND v(dout1_96) AT=465.025n

.meas tran vdout1_97ck920 FIND v(dout1_97) AT=465.025n

.meas tran vdout1_98ck920 FIND v(dout1_98) AT=465.025n

.meas tran vdout1_99ck920 FIND v(dout1_99) AT=465.025n

.meas tran vdout1_100ck920 FIND v(dout1_100) AT=465.025n

.meas tran vdout1_101ck920 FIND v(dout1_101) AT=465.025n

.meas tran vdout1_102ck920 FIND v(dout1_102) AT=465.025n

.meas tran vdout1_103ck920 FIND v(dout1_103) AT=465.025n

.meas tran vdout1_104ck920 FIND v(dout1_104) AT=465.025n

.meas tran vdout1_105ck920 FIND v(dout1_105) AT=465.025n

.meas tran vdout1_106ck920 FIND v(dout1_106) AT=465.025n

.meas tran vdout1_107ck920 FIND v(dout1_107) AT=465.025n

.meas tran vdout1_108ck920 FIND v(dout1_108) AT=465.025n

.meas tran vdout1_109ck920 FIND v(dout1_109) AT=465.025n

.meas tran vdout1_110ck920 FIND v(dout1_110) AT=465.025n

.meas tran vdout1_111ck920 FIND v(dout1_111) AT=465.025n

.meas tran vdout1_112ck920 FIND v(dout1_112) AT=465.025n

.meas tran vdout1_113ck920 FIND v(dout1_113) AT=465.025n

.meas tran vdout1_114ck920 FIND v(dout1_114) AT=465.025n

.meas tran vdout1_115ck920 FIND v(dout1_115) AT=465.025n

.meas tran vdout1_116ck920 FIND v(dout1_116) AT=465.025n

.meas tran vdout1_117ck920 FIND v(dout1_117) AT=465.025n

.meas tran vdout1_118ck920 FIND v(dout1_118) AT=465.025n

.meas tran vdout1_119ck920 FIND v(dout1_119) AT=465.025n

.meas tran vdout1_120ck920 FIND v(dout1_120) AT=465.025n

.meas tran vdout1_121ck920 FIND v(dout1_121) AT=465.025n

.meas tran vdout1_122ck920 FIND v(dout1_122) AT=465.025n

.meas tran vdout1_123ck920 FIND v(dout1_123) AT=465.025n

.meas tran vdout1_124ck920 FIND v(dout1_124) AT=465.025n

.meas tran vdout1_125ck920 FIND v(dout1_125) AT=465.025n

.meas tran vdout1_126ck920 FIND v(dout1_126) AT=465.025n

.meas tran vdout1_127ck920 FIND v(dout1_127) AT=465.025n

.meas tran vdout1_128ck920 FIND v(dout1_128) AT=465.025n

.meas tran vdout1_129ck920 FIND v(dout1_129) AT=465.025n

.meas tran vdout1_130ck920 FIND v(dout1_130) AT=465.025n

.meas tran vdout1_131ck920 FIND v(dout1_131) AT=465.025n

.meas tran vdout1_132ck920 FIND v(dout1_132) AT=465.025n

.meas tran vdout1_133ck920 FIND v(dout1_133) AT=465.025n

.meas tran vdout1_134ck920 FIND v(dout1_134) AT=465.025n

.meas tran vdout1_135ck920 FIND v(dout1_135) AT=465.025n

.meas tran vdout1_136ck920 FIND v(dout1_136) AT=465.025n

.meas tran vdout1_137ck920 FIND v(dout1_137) AT=465.025n

.meas tran vdout1_138ck920 FIND v(dout1_138) AT=465.025n

.meas tran vdout1_139ck920 FIND v(dout1_139) AT=465.025n

.meas tran vdout1_140ck920 FIND v(dout1_140) AT=465.025n

.meas tran vdout1_141ck920 FIND v(dout1_141) AT=465.025n

.meas tran vdout1_142ck920 FIND v(dout1_142) AT=465.025n

.meas tran vdout1_143ck920 FIND v(dout1_143) AT=465.025n

.meas tran vdout1_144ck920 FIND v(dout1_144) AT=465.025n

.meas tran vdout1_145ck920 FIND v(dout1_145) AT=465.025n

.meas tran vdout1_146ck920 FIND v(dout1_146) AT=465.025n

.meas tran vdout1_147ck920 FIND v(dout1_147) AT=465.025n

.meas tran vdout1_148ck920 FIND v(dout1_148) AT=465.025n

.meas tran vdout1_149ck920 FIND v(dout1_149) AT=465.025n

.meas tran vdout1_150ck920 FIND v(dout1_150) AT=465.025n

.meas tran vdout1_151ck920 FIND v(dout1_151) AT=465.025n

.meas tran vdout1_152ck920 FIND v(dout1_152) AT=465.025n

.meas tran vdout1_153ck920 FIND v(dout1_153) AT=465.025n

.meas tran vdout1_154ck920 FIND v(dout1_154) AT=465.025n

.meas tran vdout1_155ck920 FIND v(dout1_155) AT=465.025n

.meas tran vdout1_156ck920 FIND v(dout1_156) AT=465.025n

.meas tran vdout1_157ck920 FIND v(dout1_157) AT=465.025n

.meas tran vdout1_158ck920 FIND v(dout1_158) AT=465.025n

.meas tran vdout1_159ck920 FIND v(dout1_159) AT=465.025n

.meas tran vdout1_160ck920 FIND v(dout1_160) AT=465.025n

.meas tran vdout1_161ck920 FIND v(dout1_161) AT=465.025n

.meas tran vdout1_162ck920 FIND v(dout1_162) AT=465.025n

.meas tran vdout1_163ck920 FIND v(dout1_163) AT=465.025n

.meas tran vdout1_164ck920 FIND v(dout1_164) AT=465.025n

.meas tran vdout1_165ck920 FIND v(dout1_165) AT=465.025n

.meas tran vdout1_166ck920 FIND v(dout1_166) AT=465.025n

.meas tran vdout1_167ck920 FIND v(dout1_167) AT=465.025n

.meas tran vdout1_168ck920 FIND v(dout1_168) AT=465.025n

.meas tran vdout1_169ck920 FIND v(dout1_169) AT=465.025n

.meas tran vdout1_170ck920 FIND v(dout1_170) AT=465.025n

.meas tran vdout1_171ck920 FIND v(dout1_171) AT=465.025n

.meas tran vdout1_172ck920 FIND v(dout1_172) AT=465.025n

.meas tran vdout1_173ck920 FIND v(dout1_173) AT=465.025n

.meas tran vdout1_174ck920 FIND v(dout1_174) AT=465.025n

.meas tran vdout1_175ck920 FIND v(dout1_175) AT=465.025n

.meas tran vdout1_176ck920 FIND v(dout1_176) AT=465.025n

.meas tran vdout1_177ck920 FIND v(dout1_177) AT=465.025n

.meas tran vdout1_178ck920 FIND v(dout1_178) AT=465.025n

.meas tran vdout1_179ck920 FIND v(dout1_179) AT=465.025n

.meas tran vdout1_180ck920 FIND v(dout1_180) AT=465.025n

.meas tran vdout1_181ck920 FIND v(dout1_181) AT=465.025n

.meas tran vdout1_182ck920 FIND v(dout1_182) AT=465.025n

.meas tran vdout1_183ck920 FIND v(dout1_183) AT=465.025n

.meas tran vdout1_184ck920 FIND v(dout1_184) AT=465.025n

.meas tran vdout1_185ck920 FIND v(dout1_185) AT=465.025n

.meas tran vdout1_186ck920 FIND v(dout1_186) AT=465.025n

.meas tran vdout1_187ck920 FIND v(dout1_187) AT=465.025n

.meas tran vdout1_188ck920 FIND v(dout1_188) AT=465.025n

.meas tran vdout1_189ck920 FIND v(dout1_189) AT=465.025n

.meas tran vdout1_190ck920 FIND v(dout1_190) AT=465.025n

.meas tran vdout1_191ck920 FIND v(dout1_191) AT=465.025n

.meas tran vdout1_192ck920 FIND v(dout1_192) AT=465.025n

.meas tran vdout1_193ck920 FIND v(dout1_193) AT=465.025n

.meas tran vdout1_194ck920 FIND v(dout1_194) AT=465.025n

.meas tran vdout1_195ck920 FIND v(dout1_195) AT=465.025n

.meas tran vdout1_196ck920 FIND v(dout1_196) AT=465.025n

.meas tran vdout1_197ck920 FIND v(dout1_197) AT=465.025n

.meas tran vdout1_198ck920 FIND v(dout1_198) AT=465.025n

.meas tran vdout1_199ck920 FIND v(dout1_199) AT=465.025n

.meas tran vdout1_200ck920 FIND v(dout1_200) AT=465.025n

.meas tran vdout1_201ck920 FIND v(dout1_201) AT=465.025n

.meas tran vdout1_202ck920 FIND v(dout1_202) AT=465.025n

.meas tran vdout1_203ck920 FIND v(dout1_203) AT=465.025n

.meas tran vdout1_204ck920 FIND v(dout1_204) AT=465.025n

.meas tran vdout1_205ck920 FIND v(dout1_205) AT=465.025n

.meas tran vdout1_206ck920 FIND v(dout1_206) AT=465.025n

.meas tran vdout1_207ck920 FIND v(dout1_207) AT=465.025n

.meas tran vdout1_208ck920 FIND v(dout1_208) AT=465.025n

.meas tran vdout1_209ck920 FIND v(dout1_209) AT=465.025n

.meas tran vdout1_210ck920 FIND v(dout1_210) AT=465.025n

.meas tran vdout1_211ck920 FIND v(dout1_211) AT=465.025n

.meas tran vdout1_212ck920 FIND v(dout1_212) AT=465.025n

.meas tran vdout1_213ck920 FIND v(dout1_213) AT=465.025n

.meas tran vdout1_214ck920 FIND v(dout1_214) AT=465.025n

.meas tran vdout1_215ck920 FIND v(dout1_215) AT=465.025n

.meas tran vdout1_216ck920 FIND v(dout1_216) AT=465.025n

.meas tran vdout1_217ck920 FIND v(dout1_217) AT=465.025n

.meas tran vdout1_218ck920 FIND v(dout1_218) AT=465.025n

.meas tran vdout1_219ck920 FIND v(dout1_219) AT=465.025n

.meas tran vdout1_220ck920 FIND v(dout1_220) AT=465.025n

.meas tran vdout1_221ck920 FIND v(dout1_221) AT=465.025n

.meas tran vdout1_222ck920 FIND v(dout1_222) AT=465.025n

.meas tran vdout1_223ck920 FIND v(dout1_223) AT=465.025n

.meas tran vdout1_224ck920 FIND v(dout1_224) AT=465.025n

.meas tran vdout1_225ck920 FIND v(dout1_225) AT=465.025n

.meas tran vdout1_226ck920 FIND v(dout1_226) AT=465.025n

.meas tran vdout1_227ck920 FIND v(dout1_227) AT=465.025n

.meas tran vdout1_228ck920 FIND v(dout1_228) AT=465.025n

.meas tran vdout1_229ck920 FIND v(dout1_229) AT=465.025n

.meas tran vdout1_230ck920 FIND v(dout1_230) AT=465.025n

.meas tran vdout1_231ck920 FIND v(dout1_231) AT=465.025n

.meas tran vdout1_232ck920 FIND v(dout1_232) AT=465.025n

.meas tran vdout1_233ck920 FIND v(dout1_233) AT=465.025n

.meas tran vdout1_234ck920 FIND v(dout1_234) AT=465.025n

.meas tran vdout1_235ck920 FIND v(dout1_235) AT=465.025n

.meas tran vdout1_236ck920 FIND v(dout1_236) AT=465.025n

.meas tran vdout1_237ck920 FIND v(dout1_237) AT=465.025n

.meas tran vdout1_238ck920 FIND v(dout1_238) AT=465.025n

.meas tran vdout1_239ck920 FIND v(dout1_239) AT=465.025n

.meas tran vdout1_240ck920 FIND v(dout1_240) AT=465.025n

.meas tran vdout1_241ck920 FIND v(dout1_241) AT=465.025n

.meas tran vdout1_242ck920 FIND v(dout1_242) AT=465.025n

.meas tran vdout1_243ck920 FIND v(dout1_243) AT=465.025n

.meas tran vdout1_244ck920 FIND v(dout1_244) AT=465.025n

.meas tran vdout1_245ck920 FIND v(dout1_245) AT=465.025n

.meas tran vdout1_246ck920 FIND v(dout1_246) AT=465.025n

.meas tran vdout1_247ck920 FIND v(dout1_247) AT=465.025n

.meas tran vdout1_248ck920 FIND v(dout1_248) AT=465.025n

.meas tran vdout1_249ck920 FIND v(dout1_249) AT=465.025n

.meas tran vdout1_250ck920 FIND v(dout1_250) AT=465.025n

.meas tran vdout1_251ck920 FIND v(dout1_251) AT=465.025n

.meas tran vdout1_252ck920 FIND v(dout1_252) AT=465.025n

.meas tran vdout1_253ck920 FIND v(dout1_253) AT=465.025n

.meas tran vdout1_254ck920 FIND v(dout1_254) AT=465.025n

.meas tran vdout1_255ck920 FIND v(dout1_255) AT=465.025n

.meas tran vdout1_256ck920 FIND v(dout1_256) AT=465.025n

.meas tran vdout1_257ck920 FIND v(dout1_257) AT=465.025n

.meas tran vdout1_258ck920 FIND v(dout1_258) AT=465.025n

.meas tran vdout1_259ck920 FIND v(dout1_259) AT=465.025n

.meas tran vdout1_260ck920 FIND v(dout1_260) AT=465.025n

.meas tran vdout1_261ck920 FIND v(dout1_261) AT=465.025n

.meas tran vdout1_262ck920 FIND v(dout1_262) AT=465.025n

.meas tran vdout1_263ck920 FIND v(dout1_263) AT=465.025n

.meas tran vdout1_264ck920 FIND v(dout1_264) AT=465.025n

.meas tran vdout1_265ck920 FIND v(dout1_265) AT=465.025n

.meas tran vdout1_266ck920 FIND v(dout1_266) AT=465.025n

.meas tran vdout1_267ck920 FIND v(dout1_267) AT=465.025n

.meas tran vdout1_268ck920 FIND v(dout1_268) AT=465.025n

.meas tran vdout1_269ck920 FIND v(dout1_269) AT=465.025n

.meas tran vdout1_270ck920 FIND v(dout1_270) AT=465.025n

.meas tran vdout1_271ck920 FIND v(dout1_271) AT=465.025n

.meas tran vdout1_272ck920 FIND v(dout1_272) AT=465.025n

.meas tran vdout1_273ck920 FIND v(dout1_273) AT=465.025n

.meas tran vdout1_274ck920 FIND v(dout1_274) AT=465.025n

.meas tran vdout1_275ck920 FIND v(dout1_275) AT=465.025n

.meas tran vdout1_276ck920 FIND v(dout1_276) AT=465.025n

.meas tran vdout1_277ck920 FIND v(dout1_277) AT=465.025n

.meas tran vdout1_278ck920 FIND v(dout1_278) AT=465.025n

.meas tran vdout1_279ck920 FIND v(dout1_279) AT=465.025n

.meas tran vdout1_280ck920 FIND v(dout1_280) AT=465.025n

.meas tran vdout1_281ck920 FIND v(dout1_281) AT=465.025n

.meas tran vdout1_282ck920 FIND v(dout1_282) AT=465.025n

.meas tran vdout1_283ck920 FIND v(dout1_283) AT=465.025n

.meas tran vdout1_284ck920 FIND v(dout1_284) AT=465.025n

.meas tran vdout1_285ck920 FIND v(dout1_285) AT=465.025n

.meas tran vdout1_286ck920 FIND v(dout1_286) AT=465.025n

.meas tran vdout1_287ck920 FIND v(dout1_287) AT=465.025n

.meas tran vdout1_288ck920 FIND v(dout1_288) AT=465.025n

.meas tran vdout1_289ck920 FIND v(dout1_289) AT=465.025n

.meas tran vdout1_290ck920 FIND v(dout1_290) AT=465.025n

.meas tran vdout1_291ck920 FIND v(dout1_291) AT=465.025n

.meas tran vdout1_292ck920 FIND v(dout1_292) AT=465.025n

.meas tran vdout1_293ck920 FIND v(dout1_293) AT=465.025n

.meas tran vdout1_294ck920 FIND v(dout1_294) AT=465.025n

.meas tran vdout1_295ck920 FIND v(dout1_295) AT=465.025n

.meas tran vdout1_296ck920 FIND v(dout1_296) AT=465.025n

.meas tran vdout1_297ck920 FIND v(dout1_297) AT=465.025n

.meas tran vdout1_298ck920 FIND v(dout1_298) AT=465.025n

.meas tran vdout1_299ck920 FIND v(dout1_299) AT=465.025n

.meas tran vdout1_300ck920 FIND v(dout1_300) AT=465.025n

.meas tran vdout1_301ck920 FIND v(dout1_301) AT=465.025n

.meas tran vdout1_302ck920 FIND v(dout1_302) AT=465.025n

.meas tran vdout1_303ck920 FIND v(dout1_303) AT=465.025n

.meas tran vdout1_304ck920 FIND v(dout1_304) AT=465.025n

.meas tran vdout1_305ck920 FIND v(dout1_305) AT=465.025n

.meas tran vdout1_306ck920 FIND v(dout1_306) AT=465.025n

.meas tran vdout1_307ck920 FIND v(dout1_307) AT=465.025n

.meas tran vdout1_308ck920 FIND v(dout1_308) AT=465.025n

.meas tran vdout1_309ck920 FIND v(dout1_309) AT=465.025n

.meas tran vdout1_310ck920 FIND v(dout1_310) AT=465.025n

.meas tran vdout1_311ck920 FIND v(dout1_311) AT=465.025n

.meas tran vdout1_312ck920 FIND v(dout1_312) AT=465.025n

.meas tran vdout1_313ck920 FIND v(dout1_313) AT=465.025n

.meas tran vdout1_314ck920 FIND v(dout1_314) AT=465.025n

.meas tran vdout1_315ck920 FIND v(dout1_315) AT=465.025n

.meas tran vdout1_316ck920 FIND v(dout1_316) AT=465.025n

.meas tran vdout1_317ck920 FIND v(dout1_317) AT=465.025n

.meas tran vdout1_318ck920 FIND v(dout1_318) AT=465.025n

.meas tran vdout1_319ck920 FIND v(dout1_319) AT=465.025n

.meas tran vdout1_320ck920 FIND v(dout1_320) AT=465.025n

.meas tran vdout1_321ck920 FIND v(dout1_321) AT=465.025n

.meas tran vdout1_322ck920 FIND v(dout1_322) AT=465.025n

.meas tran vdout1_323ck920 FIND v(dout1_323) AT=465.025n

.meas tran vdout1_324ck920 FIND v(dout1_324) AT=465.025n

.meas tran vdout1_325ck920 FIND v(dout1_325) AT=465.025n

.meas tran vdout1_326ck920 FIND v(dout1_326) AT=465.025n

.meas tran vdout1_327ck920 FIND v(dout1_327) AT=465.025n

.meas tran vdout1_328ck920 FIND v(dout1_328) AT=465.025n

.meas tran vdout1_329ck920 FIND v(dout1_329) AT=465.025n

.meas tran vdout1_330ck920 FIND v(dout1_330) AT=465.025n

.meas tran vdout1_331ck920 FIND v(dout1_331) AT=465.025n

.meas tran vdout1_332ck920 FIND v(dout1_332) AT=465.025n

.meas tran vdout1_333ck920 FIND v(dout1_333) AT=465.025n

.meas tran vdout1_334ck920 FIND v(dout1_334) AT=465.025n

.meas tran vdout1_335ck920 FIND v(dout1_335) AT=465.025n

.meas tran vdout1_336ck920 FIND v(dout1_336) AT=465.025n

.meas tran vdout1_337ck920 FIND v(dout1_337) AT=465.025n

.meas tran vdout1_338ck920 FIND v(dout1_338) AT=465.025n

.meas tran vdout1_339ck920 FIND v(dout1_339) AT=465.025n

.meas tran vdout1_340ck920 FIND v(dout1_340) AT=465.025n

.meas tran vdout1_341ck920 FIND v(dout1_341) AT=465.025n

.meas tran vdout1_342ck920 FIND v(dout1_342) AT=465.025n

.meas tran vdout1_343ck920 FIND v(dout1_343) AT=465.025n

.meas tran vdout1_344ck920 FIND v(dout1_344) AT=465.025n

.meas tran vdout1_345ck920 FIND v(dout1_345) AT=465.025n

.meas tran vdout1_346ck920 FIND v(dout1_346) AT=465.025n

.meas tran vdout1_347ck920 FIND v(dout1_347) AT=465.025n

.meas tran vdout1_348ck920 FIND v(dout1_348) AT=465.025n

.meas tran vdout1_349ck920 FIND v(dout1_349) AT=465.025n

.meas tran vdout1_350ck920 FIND v(dout1_350) AT=465.025n

.meas tran vdout1_351ck920 FIND v(dout1_351) AT=465.025n

.meas tran vdout1_352ck920 FIND v(dout1_352) AT=465.025n

.meas tran vdout1_353ck920 FIND v(dout1_353) AT=465.025n

.meas tran vdout1_354ck920 FIND v(dout1_354) AT=465.025n

.meas tran vdout1_355ck920 FIND v(dout1_355) AT=465.025n

.meas tran vdout1_356ck920 FIND v(dout1_356) AT=465.025n

.meas tran vdout1_357ck920 FIND v(dout1_357) AT=465.025n

.meas tran vdout1_358ck920 FIND v(dout1_358) AT=465.025n

.meas tran vdout1_359ck920 FIND v(dout1_359) AT=465.025n

.meas tran vdout1_360ck920 FIND v(dout1_360) AT=465.025n

.meas tran vdout1_361ck920 FIND v(dout1_361) AT=465.025n

.meas tran vdout1_362ck920 FIND v(dout1_362) AT=465.025n

.meas tran vdout1_363ck920 FIND v(dout1_363) AT=465.025n

.meas tran vdout1_364ck920 FIND v(dout1_364) AT=465.025n

.meas tran vdout1_365ck920 FIND v(dout1_365) AT=465.025n

.meas tran vdout1_366ck920 FIND v(dout1_366) AT=465.025n

.meas tran vdout1_367ck920 FIND v(dout1_367) AT=465.025n

.meas tran vdout1_368ck920 FIND v(dout1_368) AT=465.025n

.meas tran vdout1_369ck920 FIND v(dout1_369) AT=465.025n

.meas tran vdout1_370ck920 FIND v(dout1_370) AT=465.025n

.meas tran vdout1_371ck920 FIND v(dout1_371) AT=465.025n

.meas tran vdout1_372ck920 FIND v(dout1_372) AT=465.025n

.meas tran vdout1_373ck920 FIND v(dout1_373) AT=465.025n

.meas tran vdout1_374ck920 FIND v(dout1_374) AT=465.025n

.meas tran vdout1_375ck920 FIND v(dout1_375) AT=465.025n

.meas tran vdout1_376ck920 FIND v(dout1_376) AT=465.025n

.meas tran vdout1_377ck920 FIND v(dout1_377) AT=465.025n

.meas tran vdout1_378ck920 FIND v(dout1_378) AT=465.025n

.meas tran vdout1_379ck920 FIND v(dout1_379) AT=465.025n

.meas tran vdout1_380ck920 FIND v(dout1_380) AT=465.025n

.meas tran vdout1_381ck920 FIND v(dout1_381) AT=465.025n

.meas tran vdout1_382ck920 FIND v(dout1_382) AT=465.025n

.meas tran vdout1_383ck920 FIND v(dout1_383) AT=465.025n

.meas tran vdout1_384ck920 FIND v(dout1_384) AT=465.025n

.meas tran vdout1_385ck920 FIND v(dout1_385) AT=465.025n

.meas tran vdout1_386ck920 FIND v(dout1_386) AT=465.025n

.meas tran vdout1_387ck920 FIND v(dout1_387) AT=465.025n

.meas tran vdout1_388ck920 FIND v(dout1_388) AT=465.025n

.meas tran vdout1_389ck920 FIND v(dout1_389) AT=465.025n

.meas tran vdout1_390ck920 FIND v(dout1_390) AT=465.025n

.meas tran vdout1_391ck920 FIND v(dout1_391) AT=465.025n

.meas tran vdout1_392ck920 FIND v(dout1_392) AT=465.025n

.meas tran vdout1_393ck920 FIND v(dout1_393) AT=465.025n

.meas tran vdout1_394ck920 FIND v(dout1_394) AT=465.025n

.meas tran vdout1_395ck920 FIND v(dout1_395) AT=465.025n

.meas tran vdout1_396ck920 FIND v(dout1_396) AT=465.025n

.meas tran vdout1_397ck920 FIND v(dout1_397) AT=465.025n

.meas tran vdout1_398ck920 FIND v(dout1_398) AT=465.025n

.meas tran vdout1_399ck920 FIND v(dout1_399) AT=465.025n

.meas tran vdout1_400ck920 FIND v(dout1_400) AT=465.025n

.meas tran vdout1_401ck920 FIND v(dout1_401) AT=465.025n

.meas tran vdout1_402ck920 FIND v(dout1_402) AT=465.025n

.meas tran vdout1_403ck920 FIND v(dout1_403) AT=465.025n

.meas tran vdout1_404ck920 FIND v(dout1_404) AT=465.025n

.meas tran vdout1_405ck920 FIND v(dout1_405) AT=465.025n

.meas tran vdout1_406ck920 FIND v(dout1_406) AT=465.025n

.meas tran vdout1_407ck920 FIND v(dout1_407) AT=465.025n

.meas tran vdout1_408ck920 FIND v(dout1_408) AT=465.025n

.meas tran vdout1_409ck920 FIND v(dout1_409) AT=465.025n

.meas tran vdout1_410ck920 FIND v(dout1_410) AT=465.025n

.meas tran vdout1_411ck920 FIND v(dout1_411) AT=465.025n

.meas tran vdout1_412ck920 FIND v(dout1_412) AT=465.025n

.meas tran vdout1_413ck920 FIND v(dout1_413) AT=465.025n

.meas tran vdout1_414ck920 FIND v(dout1_414) AT=465.025n

.meas tran vdout1_415ck920 FIND v(dout1_415) AT=465.025n

.meas tran vdout1_416ck920 FIND v(dout1_416) AT=465.025n

.meas tran vdout1_417ck920 FIND v(dout1_417) AT=465.025n

.meas tran vdout1_418ck920 FIND v(dout1_418) AT=465.025n

.meas tran vdout1_419ck920 FIND v(dout1_419) AT=465.025n

.meas tran vdout1_420ck920 FIND v(dout1_420) AT=465.025n

.meas tran vdout1_421ck920 FIND v(dout1_421) AT=465.025n

.meas tran vdout1_422ck920 FIND v(dout1_422) AT=465.025n

.meas tran vdout1_423ck920 FIND v(dout1_423) AT=465.025n

.meas tran vdout1_424ck920 FIND v(dout1_424) AT=465.025n

.meas tran vdout1_425ck920 FIND v(dout1_425) AT=465.025n

.meas tran vdout1_426ck920 FIND v(dout1_426) AT=465.025n

.meas tran vdout1_427ck920 FIND v(dout1_427) AT=465.025n

.meas tran vdout1_428ck920 FIND v(dout1_428) AT=465.025n

.meas tran vdout1_429ck920 FIND v(dout1_429) AT=465.025n

.meas tran vdout1_430ck920 FIND v(dout1_430) AT=465.025n

.meas tran vdout1_431ck920 FIND v(dout1_431) AT=465.025n

.meas tran vdout1_432ck920 FIND v(dout1_432) AT=465.025n

.meas tran vdout1_433ck920 FIND v(dout1_433) AT=465.025n

.meas tran vdout1_434ck920 FIND v(dout1_434) AT=465.025n

.meas tran vdout1_435ck920 FIND v(dout1_435) AT=465.025n

.meas tran vdout1_436ck920 FIND v(dout1_436) AT=465.025n

.meas tran vdout1_437ck920 FIND v(dout1_437) AT=465.025n

.meas tran vdout1_438ck920 FIND v(dout1_438) AT=465.025n

.meas tran vdout1_439ck920 FIND v(dout1_439) AT=465.025n

.meas tran vdout1_440ck920 FIND v(dout1_440) AT=465.025n

.meas tran vdout1_441ck920 FIND v(dout1_441) AT=465.025n

.meas tran vdout1_442ck920 FIND v(dout1_442) AT=465.025n

.meas tran vdout1_443ck920 FIND v(dout1_443) AT=465.025n

.meas tran vdout1_444ck920 FIND v(dout1_444) AT=465.025n

.meas tran vdout1_445ck920 FIND v(dout1_445) AT=465.025n

.meas tran vdout1_446ck920 FIND v(dout1_446) AT=465.025n

.meas tran vdout1_447ck920 FIND v(dout1_447) AT=465.025n

.meas tran vdout1_448ck920 FIND v(dout1_448) AT=465.025n

.meas tran vdout1_449ck920 FIND v(dout1_449) AT=465.025n

.meas tran vdout1_450ck920 FIND v(dout1_450) AT=465.025n

.meas tran vdout1_451ck920 FIND v(dout1_451) AT=465.025n

.meas tran vdout1_452ck920 FIND v(dout1_452) AT=465.025n

.meas tran vdout1_453ck920 FIND v(dout1_453) AT=465.025n

.meas tran vdout1_454ck920 FIND v(dout1_454) AT=465.025n

.meas tran vdout1_455ck920 FIND v(dout1_455) AT=465.025n

.meas tran vdout1_456ck920 FIND v(dout1_456) AT=465.025n

.meas tran vdout1_457ck920 FIND v(dout1_457) AT=465.025n

.meas tran vdout1_458ck920 FIND v(dout1_458) AT=465.025n

.meas tran vdout1_459ck920 FIND v(dout1_459) AT=465.025n

.meas tran vdout1_460ck920 FIND v(dout1_460) AT=465.025n

.meas tran vdout1_461ck920 FIND v(dout1_461) AT=465.025n

.meas tran vdout1_462ck920 FIND v(dout1_462) AT=465.025n

.meas tran vdout1_463ck920 FIND v(dout1_463) AT=465.025n

.meas tran vdout1_464ck920 FIND v(dout1_464) AT=465.025n

.meas tran vdout1_465ck920 FIND v(dout1_465) AT=465.025n

.meas tran vdout1_466ck920 FIND v(dout1_466) AT=465.025n

.meas tran vdout1_467ck920 FIND v(dout1_467) AT=465.025n

.meas tran vdout1_468ck920 FIND v(dout1_468) AT=465.025n

.meas tran vdout1_469ck920 FIND v(dout1_469) AT=465.025n

.meas tran vdout1_470ck920 FIND v(dout1_470) AT=465.025n

.meas tran vdout1_471ck920 FIND v(dout1_471) AT=465.025n

.meas tran vdout1_472ck920 FIND v(dout1_472) AT=465.025n

.meas tran vdout1_473ck920 FIND v(dout1_473) AT=465.025n

.meas tran vdout1_474ck920 FIND v(dout1_474) AT=465.025n

.meas tran vdout1_475ck920 FIND v(dout1_475) AT=465.025n

.meas tran vdout1_476ck920 FIND v(dout1_476) AT=465.025n

.meas tran vdout1_477ck920 FIND v(dout1_477) AT=465.025n

.meas tran vdout1_478ck920 FIND v(dout1_478) AT=465.025n

.meas tran vdout1_479ck920 FIND v(dout1_479) AT=465.025n

.meas tran vdout1_480ck920 FIND v(dout1_480) AT=465.025n

.meas tran vdout1_481ck920 FIND v(dout1_481) AT=465.025n

.meas tran vdout1_482ck920 FIND v(dout1_482) AT=465.025n

.meas tran vdout1_483ck920 FIND v(dout1_483) AT=465.025n

.meas tran vdout1_484ck920 FIND v(dout1_484) AT=465.025n

.meas tran vdout1_485ck920 FIND v(dout1_485) AT=465.025n

.meas tran vdout1_486ck920 FIND v(dout1_486) AT=465.025n

.meas tran vdout1_487ck920 FIND v(dout1_487) AT=465.025n

.meas tran vdout1_488ck920 FIND v(dout1_488) AT=465.025n

.meas tran vdout1_489ck920 FIND v(dout1_489) AT=465.025n

.meas tran vdout1_490ck920 FIND v(dout1_490) AT=465.025n

.meas tran vdout1_491ck920 FIND v(dout1_491) AT=465.025n

.meas tran vdout1_492ck920 FIND v(dout1_492) AT=465.025n

.meas tran vdout1_493ck920 FIND v(dout1_493) AT=465.025n

.meas tran vdout1_494ck920 FIND v(dout1_494) AT=465.025n

.meas tran vdout1_495ck920 FIND v(dout1_495) AT=465.025n

.meas tran vdout1_496ck920 FIND v(dout1_496) AT=465.025n

.meas tran vdout1_497ck920 FIND v(dout1_497) AT=465.025n

.meas tran vdout1_498ck920 FIND v(dout1_498) AT=465.025n

.meas tran vdout1_499ck920 FIND v(dout1_499) AT=465.025n

.meas tran vdout1_500ck920 FIND v(dout1_500) AT=465.025n

.meas tran vdout1_501ck920 FIND v(dout1_501) AT=465.025n

.meas tran vdout1_502ck920 FIND v(dout1_502) AT=465.025n

.meas tran vdout1_503ck920 FIND v(dout1_503) AT=465.025n

.meas tran vdout1_504ck920 FIND v(dout1_504) AT=465.025n

.meas tran vdout1_505ck920 FIND v(dout1_505) AT=465.025n

.meas tran vdout1_506ck920 FIND v(dout1_506) AT=465.025n

.meas tran vdout1_507ck920 FIND v(dout1_507) AT=465.025n

.meas tran vdout1_508ck920 FIND v(dout1_508) AT=465.025n

.meas tran vdout1_509ck920 FIND v(dout1_509) AT=465.025n

.meas tran vdout1_510ck920 FIND v(dout1_510) AT=465.025n

.meas tran vdout1_511ck920 FIND v(dout1_511) AT=465.025n

.meas tran vdout1_0ck1010 FIND v(dout1_0) AT=510.025n

.meas tran vdout1_1ck1010 FIND v(dout1_1) AT=510.025n

.meas tran vdout1_2ck1010 FIND v(dout1_2) AT=510.025n

.meas tran vdout1_3ck1010 FIND v(dout1_3) AT=510.025n

.meas tran vdout1_4ck1010 FIND v(dout1_4) AT=510.025n

.meas tran vdout1_5ck1010 FIND v(dout1_5) AT=510.025n

.meas tran vdout1_6ck1010 FIND v(dout1_6) AT=510.025n

.meas tran vdout1_7ck1010 FIND v(dout1_7) AT=510.025n

.meas tran vdout1_8ck1010 FIND v(dout1_8) AT=510.025n

.meas tran vdout1_9ck1010 FIND v(dout1_9) AT=510.025n

.meas tran vdout1_10ck1010 FIND v(dout1_10) AT=510.025n

.meas tran vdout1_11ck1010 FIND v(dout1_11) AT=510.025n

.meas tran vdout1_12ck1010 FIND v(dout1_12) AT=510.025n

.meas tran vdout1_13ck1010 FIND v(dout1_13) AT=510.025n

.meas tran vdout1_14ck1010 FIND v(dout1_14) AT=510.025n

.meas tran vdout1_15ck1010 FIND v(dout1_15) AT=510.025n

.meas tran vdout1_16ck1010 FIND v(dout1_16) AT=510.025n

.meas tran vdout1_17ck1010 FIND v(dout1_17) AT=510.025n

.meas tran vdout1_18ck1010 FIND v(dout1_18) AT=510.025n

.meas tran vdout1_19ck1010 FIND v(dout1_19) AT=510.025n

.meas tran vdout1_20ck1010 FIND v(dout1_20) AT=510.025n

.meas tran vdout1_21ck1010 FIND v(dout1_21) AT=510.025n

.meas tran vdout1_22ck1010 FIND v(dout1_22) AT=510.025n

.meas tran vdout1_23ck1010 FIND v(dout1_23) AT=510.025n

.meas tran vdout1_24ck1010 FIND v(dout1_24) AT=510.025n

.meas tran vdout1_25ck1010 FIND v(dout1_25) AT=510.025n

.meas tran vdout1_26ck1010 FIND v(dout1_26) AT=510.025n

.meas tran vdout1_27ck1010 FIND v(dout1_27) AT=510.025n

.meas tran vdout1_28ck1010 FIND v(dout1_28) AT=510.025n

.meas tran vdout1_29ck1010 FIND v(dout1_29) AT=510.025n

.meas tran vdout1_30ck1010 FIND v(dout1_30) AT=510.025n

.meas tran vdout1_31ck1010 FIND v(dout1_31) AT=510.025n

.meas tran vdout1_32ck1010 FIND v(dout1_32) AT=510.025n

.meas tran vdout1_33ck1010 FIND v(dout1_33) AT=510.025n

.meas tran vdout1_34ck1010 FIND v(dout1_34) AT=510.025n

.meas tran vdout1_35ck1010 FIND v(dout1_35) AT=510.025n

.meas tran vdout1_36ck1010 FIND v(dout1_36) AT=510.025n

.meas tran vdout1_37ck1010 FIND v(dout1_37) AT=510.025n

.meas tran vdout1_38ck1010 FIND v(dout1_38) AT=510.025n

.meas tran vdout1_39ck1010 FIND v(dout1_39) AT=510.025n

.meas tran vdout1_40ck1010 FIND v(dout1_40) AT=510.025n

.meas tran vdout1_41ck1010 FIND v(dout1_41) AT=510.025n

.meas tran vdout1_42ck1010 FIND v(dout1_42) AT=510.025n

.meas tran vdout1_43ck1010 FIND v(dout1_43) AT=510.025n

.meas tran vdout1_44ck1010 FIND v(dout1_44) AT=510.025n

.meas tran vdout1_45ck1010 FIND v(dout1_45) AT=510.025n

.meas tran vdout1_46ck1010 FIND v(dout1_46) AT=510.025n

.meas tran vdout1_47ck1010 FIND v(dout1_47) AT=510.025n

.meas tran vdout1_48ck1010 FIND v(dout1_48) AT=510.025n

.meas tran vdout1_49ck1010 FIND v(dout1_49) AT=510.025n

.meas tran vdout1_50ck1010 FIND v(dout1_50) AT=510.025n

.meas tran vdout1_51ck1010 FIND v(dout1_51) AT=510.025n

.meas tran vdout1_52ck1010 FIND v(dout1_52) AT=510.025n

.meas tran vdout1_53ck1010 FIND v(dout1_53) AT=510.025n

.meas tran vdout1_54ck1010 FIND v(dout1_54) AT=510.025n

.meas tran vdout1_55ck1010 FIND v(dout1_55) AT=510.025n

.meas tran vdout1_56ck1010 FIND v(dout1_56) AT=510.025n

.meas tran vdout1_57ck1010 FIND v(dout1_57) AT=510.025n

.meas tran vdout1_58ck1010 FIND v(dout1_58) AT=510.025n

.meas tran vdout1_59ck1010 FIND v(dout1_59) AT=510.025n

.meas tran vdout1_60ck1010 FIND v(dout1_60) AT=510.025n

.meas tran vdout1_61ck1010 FIND v(dout1_61) AT=510.025n

.meas tran vdout1_62ck1010 FIND v(dout1_62) AT=510.025n

.meas tran vdout1_63ck1010 FIND v(dout1_63) AT=510.025n

.meas tran vdout1_64ck1010 FIND v(dout1_64) AT=510.025n

.meas tran vdout1_65ck1010 FIND v(dout1_65) AT=510.025n

.meas tran vdout1_66ck1010 FIND v(dout1_66) AT=510.025n

.meas tran vdout1_67ck1010 FIND v(dout1_67) AT=510.025n

.meas tran vdout1_68ck1010 FIND v(dout1_68) AT=510.025n

.meas tran vdout1_69ck1010 FIND v(dout1_69) AT=510.025n

.meas tran vdout1_70ck1010 FIND v(dout1_70) AT=510.025n

.meas tran vdout1_71ck1010 FIND v(dout1_71) AT=510.025n

.meas tran vdout1_72ck1010 FIND v(dout1_72) AT=510.025n

.meas tran vdout1_73ck1010 FIND v(dout1_73) AT=510.025n

.meas tran vdout1_74ck1010 FIND v(dout1_74) AT=510.025n

.meas tran vdout1_75ck1010 FIND v(dout1_75) AT=510.025n

.meas tran vdout1_76ck1010 FIND v(dout1_76) AT=510.025n

.meas tran vdout1_77ck1010 FIND v(dout1_77) AT=510.025n

.meas tran vdout1_78ck1010 FIND v(dout1_78) AT=510.025n

.meas tran vdout1_79ck1010 FIND v(dout1_79) AT=510.025n

.meas tran vdout1_80ck1010 FIND v(dout1_80) AT=510.025n

.meas tran vdout1_81ck1010 FIND v(dout1_81) AT=510.025n

.meas tran vdout1_82ck1010 FIND v(dout1_82) AT=510.025n

.meas tran vdout1_83ck1010 FIND v(dout1_83) AT=510.025n

.meas tran vdout1_84ck1010 FIND v(dout1_84) AT=510.025n

.meas tran vdout1_85ck1010 FIND v(dout1_85) AT=510.025n

.meas tran vdout1_86ck1010 FIND v(dout1_86) AT=510.025n

.meas tran vdout1_87ck1010 FIND v(dout1_87) AT=510.025n

.meas tran vdout1_88ck1010 FIND v(dout1_88) AT=510.025n

.meas tran vdout1_89ck1010 FIND v(dout1_89) AT=510.025n

.meas tran vdout1_90ck1010 FIND v(dout1_90) AT=510.025n

.meas tran vdout1_91ck1010 FIND v(dout1_91) AT=510.025n

.meas tran vdout1_92ck1010 FIND v(dout1_92) AT=510.025n

.meas tran vdout1_93ck1010 FIND v(dout1_93) AT=510.025n

.meas tran vdout1_94ck1010 FIND v(dout1_94) AT=510.025n

.meas tran vdout1_95ck1010 FIND v(dout1_95) AT=510.025n

.meas tran vdout1_96ck1010 FIND v(dout1_96) AT=510.025n

.meas tran vdout1_97ck1010 FIND v(dout1_97) AT=510.025n

.meas tran vdout1_98ck1010 FIND v(dout1_98) AT=510.025n

.meas tran vdout1_99ck1010 FIND v(dout1_99) AT=510.025n

.meas tran vdout1_100ck1010 FIND v(dout1_100) AT=510.025n

.meas tran vdout1_101ck1010 FIND v(dout1_101) AT=510.025n

.meas tran vdout1_102ck1010 FIND v(dout1_102) AT=510.025n

.meas tran vdout1_103ck1010 FIND v(dout1_103) AT=510.025n

.meas tran vdout1_104ck1010 FIND v(dout1_104) AT=510.025n

.meas tran vdout1_105ck1010 FIND v(dout1_105) AT=510.025n

.meas tran vdout1_106ck1010 FIND v(dout1_106) AT=510.025n

.meas tran vdout1_107ck1010 FIND v(dout1_107) AT=510.025n

.meas tran vdout1_108ck1010 FIND v(dout1_108) AT=510.025n

.meas tran vdout1_109ck1010 FIND v(dout1_109) AT=510.025n

.meas tran vdout1_110ck1010 FIND v(dout1_110) AT=510.025n

.meas tran vdout1_111ck1010 FIND v(dout1_111) AT=510.025n

.meas tran vdout1_112ck1010 FIND v(dout1_112) AT=510.025n

.meas tran vdout1_113ck1010 FIND v(dout1_113) AT=510.025n

.meas tran vdout1_114ck1010 FIND v(dout1_114) AT=510.025n

.meas tran vdout1_115ck1010 FIND v(dout1_115) AT=510.025n

.meas tran vdout1_116ck1010 FIND v(dout1_116) AT=510.025n

.meas tran vdout1_117ck1010 FIND v(dout1_117) AT=510.025n

.meas tran vdout1_118ck1010 FIND v(dout1_118) AT=510.025n

.meas tran vdout1_119ck1010 FIND v(dout1_119) AT=510.025n

.meas tran vdout1_120ck1010 FIND v(dout1_120) AT=510.025n

.meas tran vdout1_121ck1010 FIND v(dout1_121) AT=510.025n

.meas tran vdout1_122ck1010 FIND v(dout1_122) AT=510.025n

.meas tran vdout1_123ck1010 FIND v(dout1_123) AT=510.025n

.meas tran vdout1_124ck1010 FIND v(dout1_124) AT=510.025n

.meas tran vdout1_125ck1010 FIND v(dout1_125) AT=510.025n

.meas tran vdout1_126ck1010 FIND v(dout1_126) AT=510.025n

.meas tran vdout1_127ck1010 FIND v(dout1_127) AT=510.025n

.meas tran vdout1_128ck1010 FIND v(dout1_128) AT=510.025n

.meas tran vdout1_129ck1010 FIND v(dout1_129) AT=510.025n

.meas tran vdout1_130ck1010 FIND v(dout1_130) AT=510.025n

.meas tran vdout1_131ck1010 FIND v(dout1_131) AT=510.025n

.meas tran vdout1_132ck1010 FIND v(dout1_132) AT=510.025n

.meas tran vdout1_133ck1010 FIND v(dout1_133) AT=510.025n

.meas tran vdout1_134ck1010 FIND v(dout1_134) AT=510.025n

.meas tran vdout1_135ck1010 FIND v(dout1_135) AT=510.025n

.meas tran vdout1_136ck1010 FIND v(dout1_136) AT=510.025n

.meas tran vdout1_137ck1010 FIND v(dout1_137) AT=510.025n

.meas tran vdout1_138ck1010 FIND v(dout1_138) AT=510.025n

.meas tran vdout1_139ck1010 FIND v(dout1_139) AT=510.025n

.meas tran vdout1_140ck1010 FIND v(dout1_140) AT=510.025n

.meas tran vdout1_141ck1010 FIND v(dout1_141) AT=510.025n

.meas tran vdout1_142ck1010 FIND v(dout1_142) AT=510.025n

.meas tran vdout1_143ck1010 FIND v(dout1_143) AT=510.025n

.meas tran vdout1_144ck1010 FIND v(dout1_144) AT=510.025n

.meas tran vdout1_145ck1010 FIND v(dout1_145) AT=510.025n

.meas tran vdout1_146ck1010 FIND v(dout1_146) AT=510.025n

.meas tran vdout1_147ck1010 FIND v(dout1_147) AT=510.025n

.meas tran vdout1_148ck1010 FIND v(dout1_148) AT=510.025n

.meas tran vdout1_149ck1010 FIND v(dout1_149) AT=510.025n

.meas tran vdout1_150ck1010 FIND v(dout1_150) AT=510.025n

.meas tran vdout1_151ck1010 FIND v(dout1_151) AT=510.025n

.meas tran vdout1_152ck1010 FIND v(dout1_152) AT=510.025n

.meas tran vdout1_153ck1010 FIND v(dout1_153) AT=510.025n

.meas tran vdout1_154ck1010 FIND v(dout1_154) AT=510.025n

.meas tran vdout1_155ck1010 FIND v(dout1_155) AT=510.025n

.meas tran vdout1_156ck1010 FIND v(dout1_156) AT=510.025n

.meas tran vdout1_157ck1010 FIND v(dout1_157) AT=510.025n

.meas tran vdout1_158ck1010 FIND v(dout1_158) AT=510.025n

.meas tran vdout1_159ck1010 FIND v(dout1_159) AT=510.025n

.meas tran vdout1_160ck1010 FIND v(dout1_160) AT=510.025n

.meas tran vdout1_161ck1010 FIND v(dout1_161) AT=510.025n

.meas tran vdout1_162ck1010 FIND v(dout1_162) AT=510.025n

.meas tran vdout1_163ck1010 FIND v(dout1_163) AT=510.025n

.meas tran vdout1_164ck1010 FIND v(dout1_164) AT=510.025n

.meas tran vdout1_165ck1010 FIND v(dout1_165) AT=510.025n

.meas tran vdout1_166ck1010 FIND v(dout1_166) AT=510.025n

.meas tran vdout1_167ck1010 FIND v(dout1_167) AT=510.025n

.meas tran vdout1_168ck1010 FIND v(dout1_168) AT=510.025n

.meas tran vdout1_169ck1010 FIND v(dout1_169) AT=510.025n

.meas tran vdout1_170ck1010 FIND v(dout1_170) AT=510.025n

.meas tran vdout1_171ck1010 FIND v(dout1_171) AT=510.025n

.meas tran vdout1_172ck1010 FIND v(dout1_172) AT=510.025n

.meas tran vdout1_173ck1010 FIND v(dout1_173) AT=510.025n

.meas tran vdout1_174ck1010 FIND v(dout1_174) AT=510.025n

.meas tran vdout1_175ck1010 FIND v(dout1_175) AT=510.025n

.meas tran vdout1_176ck1010 FIND v(dout1_176) AT=510.025n

.meas tran vdout1_177ck1010 FIND v(dout1_177) AT=510.025n

.meas tran vdout1_178ck1010 FIND v(dout1_178) AT=510.025n

.meas tran vdout1_179ck1010 FIND v(dout1_179) AT=510.025n

.meas tran vdout1_180ck1010 FIND v(dout1_180) AT=510.025n

.meas tran vdout1_181ck1010 FIND v(dout1_181) AT=510.025n

.meas tran vdout1_182ck1010 FIND v(dout1_182) AT=510.025n

.meas tran vdout1_183ck1010 FIND v(dout1_183) AT=510.025n

.meas tran vdout1_184ck1010 FIND v(dout1_184) AT=510.025n

.meas tran vdout1_185ck1010 FIND v(dout1_185) AT=510.025n

.meas tran vdout1_186ck1010 FIND v(dout1_186) AT=510.025n

.meas tran vdout1_187ck1010 FIND v(dout1_187) AT=510.025n

.meas tran vdout1_188ck1010 FIND v(dout1_188) AT=510.025n

.meas tran vdout1_189ck1010 FIND v(dout1_189) AT=510.025n

.meas tran vdout1_190ck1010 FIND v(dout1_190) AT=510.025n

.meas tran vdout1_191ck1010 FIND v(dout1_191) AT=510.025n

.meas tran vdout1_192ck1010 FIND v(dout1_192) AT=510.025n

.meas tran vdout1_193ck1010 FIND v(dout1_193) AT=510.025n

.meas tran vdout1_194ck1010 FIND v(dout1_194) AT=510.025n

.meas tran vdout1_195ck1010 FIND v(dout1_195) AT=510.025n

.meas tran vdout1_196ck1010 FIND v(dout1_196) AT=510.025n

.meas tran vdout1_197ck1010 FIND v(dout1_197) AT=510.025n

.meas tran vdout1_198ck1010 FIND v(dout1_198) AT=510.025n

.meas tran vdout1_199ck1010 FIND v(dout1_199) AT=510.025n

.meas tran vdout1_200ck1010 FIND v(dout1_200) AT=510.025n

.meas tran vdout1_201ck1010 FIND v(dout1_201) AT=510.025n

.meas tran vdout1_202ck1010 FIND v(dout1_202) AT=510.025n

.meas tran vdout1_203ck1010 FIND v(dout1_203) AT=510.025n

.meas tran vdout1_204ck1010 FIND v(dout1_204) AT=510.025n

.meas tran vdout1_205ck1010 FIND v(dout1_205) AT=510.025n

.meas tran vdout1_206ck1010 FIND v(dout1_206) AT=510.025n

.meas tran vdout1_207ck1010 FIND v(dout1_207) AT=510.025n

.meas tran vdout1_208ck1010 FIND v(dout1_208) AT=510.025n

.meas tran vdout1_209ck1010 FIND v(dout1_209) AT=510.025n

.meas tran vdout1_210ck1010 FIND v(dout1_210) AT=510.025n

.meas tran vdout1_211ck1010 FIND v(dout1_211) AT=510.025n

.meas tran vdout1_212ck1010 FIND v(dout1_212) AT=510.025n

.meas tran vdout1_213ck1010 FIND v(dout1_213) AT=510.025n

.meas tran vdout1_214ck1010 FIND v(dout1_214) AT=510.025n

.meas tran vdout1_215ck1010 FIND v(dout1_215) AT=510.025n

.meas tran vdout1_216ck1010 FIND v(dout1_216) AT=510.025n

.meas tran vdout1_217ck1010 FIND v(dout1_217) AT=510.025n

.meas tran vdout1_218ck1010 FIND v(dout1_218) AT=510.025n

.meas tran vdout1_219ck1010 FIND v(dout1_219) AT=510.025n

.meas tran vdout1_220ck1010 FIND v(dout1_220) AT=510.025n

.meas tran vdout1_221ck1010 FIND v(dout1_221) AT=510.025n

.meas tran vdout1_222ck1010 FIND v(dout1_222) AT=510.025n

.meas tran vdout1_223ck1010 FIND v(dout1_223) AT=510.025n

.meas tran vdout1_224ck1010 FIND v(dout1_224) AT=510.025n

.meas tran vdout1_225ck1010 FIND v(dout1_225) AT=510.025n

.meas tran vdout1_226ck1010 FIND v(dout1_226) AT=510.025n

.meas tran vdout1_227ck1010 FIND v(dout1_227) AT=510.025n

.meas tran vdout1_228ck1010 FIND v(dout1_228) AT=510.025n

.meas tran vdout1_229ck1010 FIND v(dout1_229) AT=510.025n

.meas tran vdout1_230ck1010 FIND v(dout1_230) AT=510.025n

.meas tran vdout1_231ck1010 FIND v(dout1_231) AT=510.025n

.meas tran vdout1_232ck1010 FIND v(dout1_232) AT=510.025n

.meas tran vdout1_233ck1010 FIND v(dout1_233) AT=510.025n

.meas tran vdout1_234ck1010 FIND v(dout1_234) AT=510.025n

.meas tran vdout1_235ck1010 FIND v(dout1_235) AT=510.025n

.meas tran vdout1_236ck1010 FIND v(dout1_236) AT=510.025n

.meas tran vdout1_237ck1010 FIND v(dout1_237) AT=510.025n

.meas tran vdout1_238ck1010 FIND v(dout1_238) AT=510.025n

.meas tran vdout1_239ck1010 FIND v(dout1_239) AT=510.025n

.meas tran vdout1_240ck1010 FIND v(dout1_240) AT=510.025n

.meas tran vdout1_241ck1010 FIND v(dout1_241) AT=510.025n

.meas tran vdout1_242ck1010 FIND v(dout1_242) AT=510.025n

.meas tran vdout1_243ck1010 FIND v(dout1_243) AT=510.025n

.meas tran vdout1_244ck1010 FIND v(dout1_244) AT=510.025n

.meas tran vdout1_245ck1010 FIND v(dout1_245) AT=510.025n

.meas tran vdout1_246ck1010 FIND v(dout1_246) AT=510.025n

.meas tran vdout1_247ck1010 FIND v(dout1_247) AT=510.025n

.meas tran vdout1_248ck1010 FIND v(dout1_248) AT=510.025n

.meas tran vdout1_249ck1010 FIND v(dout1_249) AT=510.025n

.meas tran vdout1_250ck1010 FIND v(dout1_250) AT=510.025n

.meas tran vdout1_251ck1010 FIND v(dout1_251) AT=510.025n

.meas tran vdout1_252ck1010 FIND v(dout1_252) AT=510.025n

.meas tran vdout1_253ck1010 FIND v(dout1_253) AT=510.025n

.meas tran vdout1_254ck1010 FIND v(dout1_254) AT=510.025n

.meas tran vdout1_255ck1010 FIND v(dout1_255) AT=510.025n

.meas tran vdout1_256ck1010 FIND v(dout1_256) AT=510.025n

.meas tran vdout1_257ck1010 FIND v(dout1_257) AT=510.025n

.meas tran vdout1_258ck1010 FIND v(dout1_258) AT=510.025n

.meas tran vdout1_259ck1010 FIND v(dout1_259) AT=510.025n

.meas tran vdout1_260ck1010 FIND v(dout1_260) AT=510.025n

.meas tran vdout1_261ck1010 FIND v(dout1_261) AT=510.025n

.meas tran vdout1_262ck1010 FIND v(dout1_262) AT=510.025n

.meas tran vdout1_263ck1010 FIND v(dout1_263) AT=510.025n

.meas tran vdout1_264ck1010 FIND v(dout1_264) AT=510.025n

.meas tran vdout1_265ck1010 FIND v(dout1_265) AT=510.025n

.meas tran vdout1_266ck1010 FIND v(dout1_266) AT=510.025n

.meas tran vdout1_267ck1010 FIND v(dout1_267) AT=510.025n

.meas tran vdout1_268ck1010 FIND v(dout1_268) AT=510.025n

.meas tran vdout1_269ck1010 FIND v(dout1_269) AT=510.025n

.meas tran vdout1_270ck1010 FIND v(dout1_270) AT=510.025n

.meas tran vdout1_271ck1010 FIND v(dout1_271) AT=510.025n

.meas tran vdout1_272ck1010 FIND v(dout1_272) AT=510.025n

.meas tran vdout1_273ck1010 FIND v(dout1_273) AT=510.025n

.meas tran vdout1_274ck1010 FIND v(dout1_274) AT=510.025n

.meas tran vdout1_275ck1010 FIND v(dout1_275) AT=510.025n

.meas tran vdout1_276ck1010 FIND v(dout1_276) AT=510.025n

.meas tran vdout1_277ck1010 FIND v(dout1_277) AT=510.025n

.meas tran vdout1_278ck1010 FIND v(dout1_278) AT=510.025n

.meas tran vdout1_279ck1010 FIND v(dout1_279) AT=510.025n

.meas tran vdout1_280ck1010 FIND v(dout1_280) AT=510.025n

.meas tran vdout1_281ck1010 FIND v(dout1_281) AT=510.025n

.meas tran vdout1_282ck1010 FIND v(dout1_282) AT=510.025n

.meas tran vdout1_283ck1010 FIND v(dout1_283) AT=510.025n

.meas tran vdout1_284ck1010 FIND v(dout1_284) AT=510.025n

.meas tran vdout1_285ck1010 FIND v(dout1_285) AT=510.025n

.meas tran vdout1_286ck1010 FIND v(dout1_286) AT=510.025n

.meas tran vdout1_287ck1010 FIND v(dout1_287) AT=510.025n

.meas tran vdout1_288ck1010 FIND v(dout1_288) AT=510.025n

.meas tran vdout1_289ck1010 FIND v(dout1_289) AT=510.025n

.meas tran vdout1_290ck1010 FIND v(dout1_290) AT=510.025n

.meas tran vdout1_291ck1010 FIND v(dout1_291) AT=510.025n

.meas tran vdout1_292ck1010 FIND v(dout1_292) AT=510.025n

.meas tran vdout1_293ck1010 FIND v(dout1_293) AT=510.025n

.meas tran vdout1_294ck1010 FIND v(dout1_294) AT=510.025n

.meas tran vdout1_295ck1010 FIND v(dout1_295) AT=510.025n

.meas tran vdout1_296ck1010 FIND v(dout1_296) AT=510.025n

.meas tran vdout1_297ck1010 FIND v(dout1_297) AT=510.025n

.meas tran vdout1_298ck1010 FIND v(dout1_298) AT=510.025n

.meas tran vdout1_299ck1010 FIND v(dout1_299) AT=510.025n

.meas tran vdout1_300ck1010 FIND v(dout1_300) AT=510.025n

.meas tran vdout1_301ck1010 FIND v(dout1_301) AT=510.025n

.meas tran vdout1_302ck1010 FIND v(dout1_302) AT=510.025n

.meas tran vdout1_303ck1010 FIND v(dout1_303) AT=510.025n

.meas tran vdout1_304ck1010 FIND v(dout1_304) AT=510.025n

.meas tran vdout1_305ck1010 FIND v(dout1_305) AT=510.025n

.meas tran vdout1_306ck1010 FIND v(dout1_306) AT=510.025n

.meas tran vdout1_307ck1010 FIND v(dout1_307) AT=510.025n

.meas tran vdout1_308ck1010 FIND v(dout1_308) AT=510.025n

.meas tran vdout1_309ck1010 FIND v(dout1_309) AT=510.025n

.meas tran vdout1_310ck1010 FIND v(dout1_310) AT=510.025n

.meas tran vdout1_311ck1010 FIND v(dout1_311) AT=510.025n

.meas tran vdout1_312ck1010 FIND v(dout1_312) AT=510.025n

.meas tran vdout1_313ck1010 FIND v(dout1_313) AT=510.025n

.meas tran vdout1_314ck1010 FIND v(dout1_314) AT=510.025n

.meas tran vdout1_315ck1010 FIND v(dout1_315) AT=510.025n

.meas tran vdout1_316ck1010 FIND v(dout1_316) AT=510.025n

.meas tran vdout1_317ck1010 FIND v(dout1_317) AT=510.025n

.meas tran vdout1_318ck1010 FIND v(dout1_318) AT=510.025n

.meas tran vdout1_319ck1010 FIND v(dout1_319) AT=510.025n

.meas tran vdout1_320ck1010 FIND v(dout1_320) AT=510.025n

.meas tran vdout1_321ck1010 FIND v(dout1_321) AT=510.025n

.meas tran vdout1_322ck1010 FIND v(dout1_322) AT=510.025n

.meas tran vdout1_323ck1010 FIND v(dout1_323) AT=510.025n

.meas tran vdout1_324ck1010 FIND v(dout1_324) AT=510.025n

.meas tran vdout1_325ck1010 FIND v(dout1_325) AT=510.025n

.meas tran vdout1_326ck1010 FIND v(dout1_326) AT=510.025n

.meas tran vdout1_327ck1010 FIND v(dout1_327) AT=510.025n

.meas tran vdout1_328ck1010 FIND v(dout1_328) AT=510.025n

.meas tran vdout1_329ck1010 FIND v(dout1_329) AT=510.025n

.meas tran vdout1_330ck1010 FIND v(dout1_330) AT=510.025n

.meas tran vdout1_331ck1010 FIND v(dout1_331) AT=510.025n

.meas tran vdout1_332ck1010 FIND v(dout1_332) AT=510.025n

.meas tran vdout1_333ck1010 FIND v(dout1_333) AT=510.025n

.meas tran vdout1_334ck1010 FIND v(dout1_334) AT=510.025n

.meas tran vdout1_335ck1010 FIND v(dout1_335) AT=510.025n

.meas tran vdout1_336ck1010 FIND v(dout1_336) AT=510.025n

.meas tran vdout1_337ck1010 FIND v(dout1_337) AT=510.025n

.meas tran vdout1_338ck1010 FIND v(dout1_338) AT=510.025n

.meas tran vdout1_339ck1010 FIND v(dout1_339) AT=510.025n

.meas tran vdout1_340ck1010 FIND v(dout1_340) AT=510.025n

.meas tran vdout1_341ck1010 FIND v(dout1_341) AT=510.025n

.meas tran vdout1_342ck1010 FIND v(dout1_342) AT=510.025n

.meas tran vdout1_343ck1010 FIND v(dout1_343) AT=510.025n

.meas tran vdout1_344ck1010 FIND v(dout1_344) AT=510.025n

.meas tran vdout1_345ck1010 FIND v(dout1_345) AT=510.025n

.meas tran vdout1_346ck1010 FIND v(dout1_346) AT=510.025n

.meas tran vdout1_347ck1010 FIND v(dout1_347) AT=510.025n

.meas tran vdout1_348ck1010 FIND v(dout1_348) AT=510.025n

.meas tran vdout1_349ck1010 FIND v(dout1_349) AT=510.025n

.meas tran vdout1_350ck1010 FIND v(dout1_350) AT=510.025n

.meas tran vdout1_351ck1010 FIND v(dout1_351) AT=510.025n

.meas tran vdout1_352ck1010 FIND v(dout1_352) AT=510.025n

.meas tran vdout1_353ck1010 FIND v(dout1_353) AT=510.025n

.meas tran vdout1_354ck1010 FIND v(dout1_354) AT=510.025n

.meas tran vdout1_355ck1010 FIND v(dout1_355) AT=510.025n

.meas tran vdout1_356ck1010 FIND v(dout1_356) AT=510.025n

.meas tran vdout1_357ck1010 FIND v(dout1_357) AT=510.025n

.meas tran vdout1_358ck1010 FIND v(dout1_358) AT=510.025n

.meas tran vdout1_359ck1010 FIND v(dout1_359) AT=510.025n

.meas tran vdout1_360ck1010 FIND v(dout1_360) AT=510.025n

.meas tran vdout1_361ck1010 FIND v(dout1_361) AT=510.025n

.meas tran vdout1_362ck1010 FIND v(dout1_362) AT=510.025n

.meas tran vdout1_363ck1010 FIND v(dout1_363) AT=510.025n

.meas tran vdout1_364ck1010 FIND v(dout1_364) AT=510.025n

.meas tran vdout1_365ck1010 FIND v(dout1_365) AT=510.025n

.meas tran vdout1_366ck1010 FIND v(dout1_366) AT=510.025n

.meas tran vdout1_367ck1010 FIND v(dout1_367) AT=510.025n

.meas tran vdout1_368ck1010 FIND v(dout1_368) AT=510.025n

.meas tran vdout1_369ck1010 FIND v(dout1_369) AT=510.025n

.meas tran vdout1_370ck1010 FIND v(dout1_370) AT=510.025n

.meas tran vdout1_371ck1010 FIND v(dout1_371) AT=510.025n

.meas tran vdout1_372ck1010 FIND v(dout1_372) AT=510.025n

.meas tran vdout1_373ck1010 FIND v(dout1_373) AT=510.025n

.meas tran vdout1_374ck1010 FIND v(dout1_374) AT=510.025n

.meas tran vdout1_375ck1010 FIND v(dout1_375) AT=510.025n

.meas tran vdout1_376ck1010 FIND v(dout1_376) AT=510.025n

.meas tran vdout1_377ck1010 FIND v(dout1_377) AT=510.025n

.meas tran vdout1_378ck1010 FIND v(dout1_378) AT=510.025n

.meas tran vdout1_379ck1010 FIND v(dout1_379) AT=510.025n

.meas tran vdout1_380ck1010 FIND v(dout1_380) AT=510.025n

.meas tran vdout1_381ck1010 FIND v(dout1_381) AT=510.025n

.meas tran vdout1_382ck1010 FIND v(dout1_382) AT=510.025n

.meas tran vdout1_383ck1010 FIND v(dout1_383) AT=510.025n

.meas tran vdout1_384ck1010 FIND v(dout1_384) AT=510.025n

.meas tran vdout1_385ck1010 FIND v(dout1_385) AT=510.025n

.meas tran vdout1_386ck1010 FIND v(dout1_386) AT=510.025n

.meas tran vdout1_387ck1010 FIND v(dout1_387) AT=510.025n

.meas tran vdout1_388ck1010 FIND v(dout1_388) AT=510.025n

.meas tran vdout1_389ck1010 FIND v(dout1_389) AT=510.025n

.meas tran vdout1_390ck1010 FIND v(dout1_390) AT=510.025n

.meas tran vdout1_391ck1010 FIND v(dout1_391) AT=510.025n

.meas tran vdout1_392ck1010 FIND v(dout1_392) AT=510.025n

.meas tran vdout1_393ck1010 FIND v(dout1_393) AT=510.025n

.meas tran vdout1_394ck1010 FIND v(dout1_394) AT=510.025n

.meas tran vdout1_395ck1010 FIND v(dout1_395) AT=510.025n

.meas tran vdout1_396ck1010 FIND v(dout1_396) AT=510.025n

.meas tran vdout1_397ck1010 FIND v(dout1_397) AT=510.025n

.meas tran vdout1_398ck1010 FIND v(dout1_398) AT=510.025n

.meas tran vdout1_399ck1010 FIND v(dout1_399) AT=510.025n

.meas tran vdout1_400ck1010 FIND v(dout1_400) AT=510.025n

.meas tran vdout1_401ck1010 FIND v(dout1_401) AT=510.025n

.meas tran vdout1_402ck1010 FIND v(dout1_402) AT=510.025n

.meas tran vdout1_403ck1010 FIND v(dout1_403) AT=510.025n

.meas tran vdout1_404ck1010 FIND v(dout1_404) AT=510.025n

.meas tran vdout1_405ck1010 FIND v(dout1_405) AT=510.025n

.meas tran vdout1_406ck1010 FIND v(dout1_406) AT=510.025n

.meas tran vdout1_407ck1010 FIND v(dout1_407) AT=510.025n

.meas tran vdout1_408ck1010 FIND v(dout1_408) AT=510.025n

.meas tran vdout1_409ck1010 FIND v(dout1_409) AT=510.025n

.meas tran vdout1_410ck1010 FIND v(dout1_410) AT=510.025n

.meas tran vdout1_411ck1010 FIND v(dout1_411) AT=510.025n

.meas tran vdout1_412ck1010 FIND v(dout1_412) AT=510.025n

.meas tran vdout1_413ck1010 FIND v(dout1_413) AT=510.025n

.meas tran vdout1_414ck1010 FIND v(dout1_414) AT=510.025n

.meas tran vdout1_415ck1010 FIND v(dout1_415) AT=510.025n

.meas tran vdout1_416ck1010 FIND v(dout1_416) AT=510.025n

.meas tran vdout1_417ck1010 FIND v(dout1_417) AT=510.025n

.meas tran vdout1_418ck1010 FIND v(dout1_418) AT=510.025n

.meas tran vdout1_419ck1010 FIND v(dout1_419) AT=510.025n

.meas tran vdout1_420ck1010 FIND v(dout1_420) AT=510.025n

.meas tran vdout1_421ck1010 FIND v(dout1_421) AT=510.025n

.meas tran vdout1_422ck1010 FIND v(dout1_422) AT=510.025n

.meas tran vdout1_423ck1010 FIND v(dout1_423) AT=510.025n

.meas tran vdout1_424ck1010 FIND v(dout1_424) AT=510.025n

.meas tran vdout1_425ck1010 FIND v(dout1_425) AT=510.025n

.meas tran vdout1_426ck1010 FIND v(dout1_426) AT=510.025n

.meas tran vdout1_427ck1010 FIND v(dout1_427) AT=510.025n

.meas tran vdout1_428ck1010 FIND v(dout1_428) AT=510.025n

.meas tran vdout1_429ck1010 FIND v(dout1_429) AT=510.025n

.meas tran vdout1_430ck1010 FIND v(dout1_430) AT=510.025n

.meas tran vdout1_431ck1010 FIND v(dout1_431) AT=510.025n

.meas tran vdout1_432ck1010 FIND v(dout1_432) AT=510.025n

.meas tran vdout1_433ck1010 FIND v(dout1_433) AT=510.025n

.meas tran vdout1_434ck1010 FIND v(dout1_434) AT=510.025n

.meas tran vdout1_435ck1010 FIND v(dout1_435) AT=510.025n

.meas tran vdout1_436ck1010 FIND v(dout1_436) AT=510.025n

.meas tran vdout1_437ck1010 FIND v(dout1_437) AT=510.025n

.meas tran vdout1_438ck1010 FIND v(dout1_438) AT=510.025n

.meas tran vdout1_439ck1010 FIND v(dout1_439) AT=510.025n

.meas tran vdout1_440ck1010 FIND v(dout1_440) AT=510.025n

.meas tran vdout1_441ck1010 FIND v(dout1_441) AT=510.025n

.meas tran vdout1_442ck1010 FIND v(dout1_442) AT=510.025n

.meas tran vdout1_443ck1010 FIND v(dout1_443) AT=510.025n

.meas tran vdout1_444ck1010 FIND v(dout1_444) AT=510.025n

.meas tran vdout1_445ck1010 FIND v(dout1_445) AT=510.025n

.meas tran vdout1_446ck1010 FIND v(dout1_446) AT=510.025n

.meas tran vdout1_447ck1010 FIND v(dout1_447) AT=510.025n

.meas tran vdout1_448ck1010 FIND v(dout1_448) AT=510.025n

.meas tran vdout1_449ck1010 FIND v(dout1_449) AT=510.025n

.meas tran vdout1_450ck1010 FIND v(dout1_450) AT=510.025n

.meas tran vdout1_451ck1010 FIND v(dout1_451) AT=510.025n

.meas tran vdout1_452ck1010 FIND v(dout1_452) AT=510.025n

.meas tran vdout1_453ck1010 FIND v(dout1_453) AT=510.025n

.meas tran vdout1_454ck1010 FIND v(dout1_454) AT=510.025n

.meas tran vdout1_455ck1010 FIND v(dout1_455) AT=510.025n

.meas tran vdout1_456ck1010 FIND v(dout1_456) AT=510.025n

.meas tran vdout1_457ck1010 FIND v(dout1_457) AT=510.025n

.meas tran vdout1_458ck1010 FIND v(dout1_458) AT=510.025n

.meas tran vdout1_459ck1010 FIND v(dout1_459) AT=510.025n

.meas tran vdout1_460ck1010 FIND v(dout1_460) AT=510.025n

.meas tran vdout1_461ck1010 FIND v(dout1_461) AT=510.025n

.meas tran vdout1_462ck1010 FIND v(dout1_462) AT=510.025n

.meas tran vdout1_463ck1010 FIND v(dout1_463) AT=510.025n

.meas tran vdout1_464ck1010 FIND v(dout1_464) AT=510.025n

.meas tran vdout1_465ck1010 FIND v(dout1_465) AT=510.025n

.meas tran vdout1_466ck1010 FIND v(dout1_466) AT=510.025n

.meas tran vdout1_467ck1010 FIND v(dout1_467) AT=510.025n

.meas tran vdout1_468ck1010 FIND v(dout1_468) AT=510.025n

.meas tran vdout1_469ck1010 FIND v(dout1_469) AT=510.025n

.meas tran vdout1_470ck1010 FIND v(dout1_470) AT=510.025n

.meas tran vdout1_471ck1010 FIND v(dout1_471) AT=510.025n

.meas tran vdout1_472ck1010 FIND v(dout1_472) AT=510.025n

.meas tran vdout1_473ck1010 FIND v(dout1_473) AT=510.025n

.meas tran vdout1_474ck1010 FIND v(dout1_474) AT=510.025n

.meas tran vdout1_475ck1010 FIND v(dout1_475) AT=510.025n

.meas tran vdout1_476ck1010 FIND v(dout1_476) AT=510.025n

.meas tran vdout1_477ck1010 FIND v(dout1_477) AT=510.025n

.meas tran vdout1_478ck1010 FIND v(dout1_478) AT=510.025n

.meas tran vdout1_479ck1010 FIND v(dout1_479) AT=510.025n

.meas tran vdout1_480ck1010 FIND v(dout1_480) AT=510.025n

.meas tran vdout1_481ck1010 FIND v(dout1_481) AT=510.025n

.meas tran vdout1_482ck1010 FIND v(dout1_482) AT=510.025n

.meas tran vdout1_483ck1010 FIND v(dout1_483) AT=510.025n

.meas tran vdout1_484ck1010 FIND v(dout1_484) AT=510.025n

.meas tran vdout1_485ck1010 FIND v(dout1_485) AT=510.025n

.meas tran vdout1_486ck1010 FIND v(dout1_486) AT=510.025n

.meas tran vdout1_487ck1010 FIND v(dout1_487) AT=510.025n

.meas tran vdout1_488ck1010 FIND v(dout1_488) AT=510.025n

.meas tran vdout1_489ck1010 FIND v(dout1_489) AT=510.025n

.meas tran vdout1_490ck1010 FIND v(dout1_490) AT=510.025n

.meas tran vdout1_491ck1010 FIND v(dout1_491) AT=510.025n

.meas tran vdout1_492ck1010 FIND v(dout1_492) AT=510.025n

.meas tran vdout1_493ck1010 FIND v(dout1_493) AT=510.025n

.meas tran vdout1_494ck1010 FIND v(dout1_494) AT=510.025n

.meas tran vdout1_495ck1010 FIND v(dout1_495) AT=510.025n

.meas tran vdout1_496ck1010 FIND v(dout1_496) AT=510.025n

.meas tran vdout1_497ck1010 FIND v(dout1_497) AT=510.025n

.meas tran vdout1_498ck1010 FIND v(dout1_498) AT=510.025n

.meas tran vdout1_499ck1010 FIND v(dout1_499) AT=510.025n

.meas tran vdout1_500ck1010 FIND v(dout1_500) AT=510.025n

.meas tran vdout1_501ck1010 FIND v(dout1_501) AT=510.025n

.meas tran vdout1_502ck1010 FIND v(dout1_502) AT=510.025n

.meas tran vdout1_503ck1010 FIND v(dout1_503) AT=510.025n

.meas tran vdout1_504ck1010 FIND v(dout1_504) AT=510.025n

.meas tran vdout1_505ck1010 FIND v(dout1_505) AT=510.025n

.meas tran vdout1_506ck1010 FIND v(dout1_506) AT=510.025n

.meas tran vdout1_507ck1010 FIND v(dout1_507) AT=510.025n

.meas tran vdout1_508ck1010 FIND v(dout1_508) AT=510.025n

.meas tran vdout1_509ck1010 FIND v(dout1_509) AT=510.025n

.meas tran vdout1_510ck1010 FIND v(dout1_510) AT=510.025n

.meas tran vdout1_511ck1010 FIND v(dout1_511) AT=510.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_17ck1020 FIND v(dout1_17) AT=515.025n

.meas tran vdout1_18ck1020 FIND v(dout1_18) AT=515.025n

.meas tran vdout1_19ck1020 FIND v(dout1_19) AT=515.025n

.meas tran vdout1_20ck1020 FIND v(dout1_20) AT=515.025n

.meas tran vdout1_21ck1020 FIND v(dout1_21) AT=515.025n

.meas tran vdout1_22ck1020 FIND v(dout1_22) AT=515.025n

.meas tran vdout1_23ck1020 FIND v(dout1_23) AT=515.025n

.meas tran vdout1_24ck1020 FIND v(dout1_24) AT=515.025n

.meas tran vdout1_25ck1020 FIND v(dout1_25) AT=515.025n

.meas tran vdout1_26ck1020 FIND v(dout1_26) AT=515.025n

.meas tran vdout1_27ck1020 FIND v(dout1_27) AT=515.025n

.meas tran vdout1_28ck1020 FIND v(dout1_28) AT=515.025n

.meas tran vdout1_29ck1020 FIND v(dout1_29) AT=515.025n

.meas tran vdout1_30ck1020 FIND v(dout1_30) AT=515.025n

.meas tran vdout1_31ck1020 FIND v(dout1_31) AT=515.025n

.meas tran vdout1_32ck1020 FIND v(dout1_32) AT=515.025n

.meas tran vdout1_33ck1020 FIND v(dout1_33) AT=515.025n

.meas tran vdout1_34ck1020 FIND v(dout1_34) AT=515.025n

.meas tran vdout1_35ck1020 FIND v(dout1_35) AT=515.025n

.meas tran vdout1_36ck1020 FIND v(dout1_36) AT=515.025n

.meas tran vdout1_37ck1020 FIND v(dout1_37) AT=515.025n

.meas tran vdout1_38ck1020 FIND v(dout1_38) AT=515.025n

.meas tran vdout1_39ck1020 FIND v(dout1_39) AT=515.025n

.meas tran vdout1_40ck1020 FIND v(dout1_40) AT=515.025n

.meas tran vdout1_41ck1020 FIND v(dout1_41) AT=515.025n

.meas tran vdout1_42ck1020 FIND v(dout1_42) AT=515.025n

.meas tran vdout1_43ck1020 FIND v(dout1_43) AT=515.025n

.meas tran vdout1_44ck1020 FIND v(dout1_44) AT=515.025n

.meas tran vdout1_45ck1020 FIND v(dout1_45) AT=515.025n

.meas tran vdout1_46ck1020 FIND v(dout1_46) AT=515.025n

.meas tran vdout1_47ck1020 FIND v(dout1_47) AT=515.025n

.meas tran vdout1_48ck1020 FIND v(dout1_48) AT=515.025n

.meas tran vdout1_49ck1020 FIND v(dout1_49) AT=515.025n

.meas tran vdout1_50ck1020 FIND v(dout1_50) AT=515.025n

.meas tran vdout1_51ck1020 FIND v(dout1_51) AT=515.025n

.meas tran vdout1_52ck1020 FIND v(dout1_52) AT=515.025n

.meas tran vdout1_53ck1020 FIND v(dout1_53) AT=515.025n

.meas tran vdout1_54ck1020 FIND v(dout1_54) AT=515.025n

.meas tran vdout1_55ck1020 FIND v(dout1_55) AT=515.025n

.meas tran vdout1_56ck1020 FIND v(dout1_56) AT=515.025n

.meas tran vdout1_57ck1020 FIND v(dout1_57) AT=515.025n

.meas tran vdout1_58ck1020 FIND v(dout1_58) AT=515.025n

.meas tran vdout1_59ck1020 FIND v(dout1_59) AT=515.025n

.meas tran vdout1_60ck1020 FIND v(dout1_60) AT=515.025n

.meas tran vdout1_61ck1020 FIND v(dout1_61) AT=515.025n

.meas tran vdout1_62ck1020 FIND v(dout1_62) AT=515.025n

.meas tran vdout1_63ck1020 FIND v(dout1_63) AT=515.025n

.meas tran vdout1_64ck1020 FIND v(dout1_64) AT=515.025n

.meas tran vdout1_65ck1020 FIND v(dout1_65) AT=515.025n

.meas tran vdout1_66ck1020 FIND v(dout1_66) AT=515.025n

.meas tran vdout1_67ck1020 FIND v(dout1_67) AT=515.025n

.meas tran vdout1_68ck1020 FIND v(dout1_68) AT=515.025n

.meas tran vdout1_69ck1020 FIND v(dout1_69) AT=515.025n

.meas tran vdout1_70ck1020 FIND v(dout1_70) AT=515.025n

.meas tran vdout1_71ck1020 FIND v(dout1_71) AT=515.025n

.meas tran vdout1_72ck1020 FIND v(dout1_72) AT=515.025n

.meas tran vdout1_73ck1020 FIND v(dout1_73) AT=515.025n

.meas tran vdout1_74ck1020 FIND v(dout1_74) AT=515.025n

.meas tran vdout1_75ck1020 FIND v(dout1_75) AT=515.025n

.meas tran vdout1_76ck1020 FIND v(dout1_76) AT=515.025n

.meas tran vdout1_77ck1020 FIND v(dout1_77) AT=515.025n

.meas tran vdout1_78ck1020 FIND v(dout1_78) AT=515.025n

.meas tran vdout1_79ck1020 FIND v(dout1_79) AT=515.025n

.meas tran vdout1_80ck1020 FIND v(dout1_80) AT=515.025n

.meas tran vdout1_81ck1020 FIND v(dout1_81) AT=515.025n

.meas tran vdout1_82ck1020 FIND v(dout1_82) AT=515.025n

.meas tran vdout1_83ck1020 FIND v(dout1_83) AT=515.025n

.meas tran vdout1_84ck1020 FIND v(dout1_84) AT=515.025n

.meas tran vdout1_85ck1020 FIND v(dout1_85) AT=515.025n

.meas tran vdout1_86ck1020 FIND v(dout1_86) AT=515.025n

.meas tran vdout1_87ck1020 FIND v(dout1_87) AT=515.025n

.meas tran vdout1_88ck1020 FIND v(dout1_88) AT=515.025n

.meas tran vdout1_89ck1020 FIND v(dout1_89) AT=515.025n

.meas tran vdout1_90ck1020 FIND v(dout1_90) AT=515.025n

.meas tran vdout1_91ck1020 FIND v(dout1_91) AT=515.025n

.meas tran vdout1_92ck1020 FIND v(dout1_92) AT=515.025n

.meas tran vdout1_93ck1020 FIND v(dout1_93) AT=515.025n

.meas tran vdout1_94ck1020 FIND v(dout1_94) AT=515.025n

.meas tran vdout1_95ck1020 FIND v(dout1_95) AT=515.025n

.meas tran vdout1_96ck1020 FIND v(dout1_96) AT=515.025n

.meas tran vdout1_97ck1020 FIND v(dout1_97) AT=515.025n

.meas tran vdout1_98ck1020 FIND v(dout1_98) AT=515.025n

.meas tran vdout1_99ck1020 FIND v(dout1_99) AT=515.025n

.meas tran vdout1_100ck1020 FIND v(dout1_100) AT=515.025n

.meas tran vdout1_101ck1020 FIND v(dout1_101) AT=515.025n

.meas tran vdout1_102ck1020 FIND v(dout1_102) AT=515.025n

.meas tran vdout1_103ck1020 FIND v(dout1_103) AT=515.025n

.meas tran vdout1_104ck1020 FIND v(dout1_104) AT=515.025n

.meas tran vdout1_105ck1020 FIND v(dout1_105) AT=515.025n

.meas tran vdout1_106ck1020 FIND v(dout1_106) AT=515.025n

.meas tran vdout1_107ck1020 FIND v(dout1_107) AT=515.025n

.meas tran vdout1_108ck1020 FIND v(dout1_108) AT=515.025n

.meas tran vdout1_109ck1020 FIND v(dout1_109) AT=515.025n

.meas tran vdout1_110ck1020 FIND v(dout1_110) AT=515.025n

.meas tran vdout1_111ck1020 FIND v(dout1_111) AT=515.025n

.meas tran vdout1_112ck1020 FIND v(dout1_112) AT=515.025n

.meas tran vdout1_113ck1020 FIND v(dout1_113) AT=515.025n

.meas tran vdout1_114ck1020 FIND v(dout1_114) AT=515.025n

.meas tran vdout1_115ck1020 FIND v(dout1_115) AT=515.025n

.meas tran vdout1_116ck1020 FIND v(dout1_116) AT=515.025n

.meas tran vdout1_117ck1020 FIND v(dout1_117) AT=515.025n

.meas tran vdout1_118ck1020 FIND v(dout1_118) AT=515.025n

.meas tran vdout1_119ck1020 FIND v(dout1_119) AT=515.025n

.meas tran vdout1_120ck1020 FIND v(dout1_120) AT=515.025n

.meas tran vdout1_121ck1020 FIND v(dout1_121) AT=515.025n

.meas tran vdout1_122ck1020 FIND v(dout1_122) AT=515.025n

.meas tran vdout1_123ck1020 FIND v(dout1_123) AT=515.025n

.meas tran vdout1_124ck1020 FIND v(dout1_124) AT=515.025n

.meas tran vdout1_125ck1020 FIND v(dout1_125) AT=515.025n

.meas tran vdout1_126ck1020 FIND v(dout1_126) AT=515.025n

.meas tran vdout1_127ck1020 FIND v(dout1_127) AT=515.025n

.meas tran vdout1_128ck1020 FIND v(dout1_128) AT=515.025n

.meas tran vdout1_129ck1020 FIND v(dout1_129) AT=515.025n

.meas tran vdout1_130ck1020 FIND v(dout1_130) AT=515.025n

.meas tran vdout1_131ck1020 FIND v(dout1_131) AT=515.025n

.meas tran vdout1_132ck1020 FIND v(dout1_132) AT=515.025n

.meas tran vdout1_133ck1020 FIND v(dout1_133) AT=515.025n

.meas tran vdout1_134ck1020 FIND v(dout1_134) AT=515.025n

.meas tran vdout1_135ck1020 FIND v(dout1_135) AT=515.025n

.meas tran vdout1_136ck1020 FIND v(dout1_136) AT=515.025n

.meas tran vdout1_137ck1020 FIND v(dout1_137) AT=515.025n

.meas tran vdout1_138ck1020 FIND v(dout1_138) AT=515.025n

.meas tran vdout1_139ck1020 FIND v(dout1_139) AT=515.025n

.meas tran vdout1_140ck1020 FIND v(dout1_140) AT=515.025n

.meas tran vdout1_141ck1020 FIND v(dout1_141) AT=515.025n

.meas tran vdout1_142ck1020 FIND v(dout1_142) AT=515.025n

.meas tran vdout1_143ck1020 FIND v(dout1_143) AT=515.025n

.meas tran vdout1_144ck1020 FIND v(dout1_144) AT=515.025n

.meas tran vdout1_145ck1020 FIND v(dout1_145) AT=515.025n

.meas tran vdout1_146ck1020 FIND v(dout1_146) AT=515.025n

.meas tran vdout1_147ck1020 FIND v(dout1_147) AT=515.025n

.meas tran vdout1_148ck1020 FIND v(dout1_148) AT=515.025n

.meas tran vdout1_149ck1020 FIND v(dout1_149) AT=515.025n

.meas tran vdout1_150ck1020 FIND v(dout1_150) AT=515.025n

.meas tran vdout1_151ck1020 FIND v(dout1_151) AT=515.025n

.meas tran vdout1_152ck1020 FIND v(dout1_152) AT=515.025n

.meas tran vdout1_153ck1020 FIND v(dout1_153) AT=515.025n

.meas tran vdout1_154ck1020 FIND v(dout1_154) AT=515.025n

.meas tran vdout1_155ck1020 FIND v(dout1_155) AT=515.025n

.meas tran vdout1_156ck1020 FIND v(dout1_156) AT=515.025n

.meas tran vdout1_157ck1020 FIND v(dout1_157) AT=515.025n

.meas tran vdout1_158ck1020 FIND v(dout1_158) AT=515.025n

.meas tran vdout1_159ck1020 FIND v(dout1_159) AT=515.025n

.meas tran vdout1_160ck1020 FIND v(dout1_160) AT=515.025n

.meas tran vdout1_161ck1020 FIND v(dout1_161) AT=515.025n

.meas tran vdout1_162ck1020 FIND v(dout1_162) AT=515.025n

.meas tran vdout1_163ck1020 FIND v(dout1_163) AT=515.025n

.meas tran vdout1_164ck1020 FIND v(dout1_164) AT=515.025n

.meas tran vdout1_165ck1020 FIND v(dout1_165) AT=515.025n

.meas tran vdout1_166ck1020 FIND v(dout1_166) AT=515.025n

.meas tran vdout1_167ck1020 FIND v(dout1_167) AT=515.025n

.meas tran vdout1_168ck1020 FIND v(dout1_168) AT=515.025n

.meas tran vdout1_169ck1020 FIND v(dout1_169) AT=515.025n

.meas tran vdout1_170ck1020 FIND v(dout1_170) AT=515.025n

.meas tran vdout1_171ck1020 FIND v(dout1_171) AT=515.025n

.meas tran vdout1_172ck1020 FIND v(dout1_172) AT=515.025n

.meas tran vdout1_173ck1020 FIND v(dout1_173) AT=515.025n

.meas tran vdout1_174ck1020 FIND v(dout1_174) AT=515.025n

.meas tran vdout1_175ck1020 FIND v(dout1_175) AT=515.025n

.meas tran vdout1_176ck1020 FIND v(dout1_176) AT=515.025n

.meas tran vdout1_177ck1020 FIND v(dout1_177) AT=515.025n

.meas tran vdout1_178ck1020 FIND v(dout1_178) AT=515.025n

.meas tran vdout1_179ck1020 FIND v(dout1_179) AT=515.025n

.meas tran vdout1_180ck1020 FIND v(dout1_180) AT=515.025n

.meas tran vdout1_181ck1020 FIND v(dout1_181) AT=515.025n

.meas tran vdout1_182ck1020 FIND v(dout1_182) AT=515.025n

.meas tran vdout1_183ck1020 FIND v(dout1_183) AT=515.025n

.meas tran vdout1_184ck1020 FIND v(dout1_184) AT=515.025n

.meas tran vdout1_185ck1020 FIND v(dout1_185) AT=515.025n

.meas tran vdout1_186ck1020 FIND v(dout1_186) AT=515.025n

.meas tran vdout1_187ck1020 FIND v(dout1_187) AT=515.025n

.meas tran vdout1_188ck1020 FIND v(dout1_188) AT=515.025n

.meas tran vdout1_189ck1020 FIND v(dout1_189) AT=515.025n

.meas tran vdout1_190ck1020 FIND v(dout1_190) AT=515.025n

.meas tran vdout1_191ck1020 FIND v(dout1_191) AT=515.025n

.meas tran vdout1_192ck1020 FIND v(dout1_192) AT=515.025n

.meas tran vdout1_193ck1020 FIND v(dout1_193) AT=515.025n

.meas tran vdout1_194ck1020 FIND v(dout1_194) AT=515.025n

.meas tran vdout1_195ck1020 FIND v(dout1_195) AT=515.025n

.meas tran vdout1_196ck1020 FIND v(dout1_196) AT=515.025n

.meas tran vdout1_197ck1020 FIND v(dout1_197) AT=515.025n

.meas tran vdout1_198ck1020 FIND v(dout1_198) AT=515.025n

.meas tran vdout1_199ck1020 FIND v(dout1_199) AT=515.025n

.meas tran vdout1_200ck1020 FIND v(dout1_200) AT=515.025n

.meas tran vdout1_201ck1020 FIND v(dout1_201) AT=515.025n

.meas tran vdout1_202ck1020 FIND v(dout1_202) AT=515.025n

.meas tran vdout1_203ck1020 FIND v(dout1_203) AT=515.025n

.meas tran vdout1_204ck1020 FIND v(dout1_204) AT=515.025n

.meas tran vdout1_205ck1020 FIND v(dout1_205) AT=515.025n

.meas tran vdout1_206ck1020 FIND v(dout1_206) AT=515.025n

.meas tran vdout1_207ck1020 FIND v(dout1_207) AT=515.025n

.meas tran vdout1_208ck1020 FIND v(dout1_208) AT=515.025n

.meas tran vdout1_209ck1020 FIND v(dout1_209) AT=515.025n

.meas tran vdout1_210ck1020 FIND v(dout1_210) AT=515.025n

.meas tran vdout1_211ck1020 FIND v(dout1_211) AT=515.025n

.meas tran vdout1_212ck1020 FIND v(dout1_212) AT=515.025n

.meas tran vdout1_213ck1020 FIND v(dout1_213) AT=515.025n

.meas tran vdout1_214ck1020 FIND v(dout1_214) AT=515.025n

.meas tran vdout1_215ck1020 FIND v(dout1_215) AT=515.025n

.meas tran vdout1_216ck1020 FIND v(dout1_216) AT=515.025n

.meas tran vdout1_217ck1020 FIND v(dout1_217) AT=515.025n

.meas tran vdout1_218ck1020 FIND v(dout1_218) AT=515.025n

.meas tran vdout1_219ck1020 FIND v(dout1_219) AT=515.025n

.meas tran vdout1_220ck1020 FIND v(dout1_220) AT=515.025n

.meas tran vdout1_221ck1020 FIND v(dout1_221) AT=515.025n

.meas tran vdout1_222ck1020 FIND v(dout1_222) AT=515.025n

.meas tran vdout1_223ck1020 FIND v(dout1_223) AT=515.025n

.meas tran vdout1_224ck1020 FIND v(dout1_224) AT=515.025n

.meas tran vdout1_225ck1020 FIND v(dout1_225) AT=515.025n

.meas tran vdout1_226ck1020 FIND v(dout1_226) AT=515.025n

.meas tran vdout1_227ck1020 FIND v(dout1_227) AT=515.025n

.meas tran vdout1_228ck1020 FIND v(dout1_228) AT=515.025n

.meas tran vdout1_229ck1020 FIND v(dout1_229) AT=515.025n

.meas tran vdout1_230ck1020 FIND v(dout1_230) AT=515.025n

.meas tran vdout1_231ck1020 FIND v(dout1_231) AT=515.025n

.meas tran vdout1_232ck1020 FIND v(dout1_232) AT=515.025n

.meas tran vdout1_233ck1020 FIND v(dout1_233) AT=515.025n

.meas tran vdout1_234ck1020 FIND v(dout1_234) AT=515.025n

.meas tran vdout1_235ck1020 FIND v(dout1_235) AT=515.025n

.meas tran vdout1_236ck1020 FIND v(dout1_236) AT=515.025n

.meas tran vdout1_237ck1020 FIND v(dout1_237) AT=515.025n

.meas tran vdout1_238ck1020 FIND v(dout1_238) AT=515.025n

.meas tran vdout1_239ck1020 FIND v(dout1_239) AT=515.025n

.meas tran vdout1_240ck1020 FIND v(dout1_240) AT=515.025n

.meas tran vdout1_241ck1020 FIND v(dout1_241) AT=515.025n

.meas tran vdout1_242ck1020 FIND v(dout1_242) AT=515.025n

.meas tran vdout1_243ck1020 FIND v(dout1_243) AT=515.025n

.meas tran vdout1_244ck1020 FIND v(dout1_244) AT=515.025n

.meas tran vdout1_245ck1020 FIND v(dout1_245) AT=515.025n

.meas tran vdout1_246ck1020 FIND v(dout1_246) AT=515.025n

.meas tran vdout1_247ck1020 FIND v(dout1_247) AT=515.025n

.meas tran vdout1_248ck1020 FIND v(dout1_248) AT=515.025n

.meas tran vdout1_249ck1020 FIND v(dout1_249) AT=515.025n

.meas tran vdout1_250ck1020 FIND v(dout1_250) AT=515.025n

.meas tran vdout1_251ck1020 FIND v(dout1_251) AT=515.025n

.meas tran vdout1_252ck1020 FIND v(dout1_252) AT=515.025n

.meas tran vdout1_253ck1020 FIND v(dout1_253) AT=515.025n

.meas tran vdout1_254ck1020 FIND v(dout1_254) AT=515.025n

.meas tran vdout1_255ck1020 FIND v(dout1_255) AT=515.025n

.meas tran vdout1_256ck1020 FIND v(dout1_256) AT=515.025n

.meas tran vdout1_257ck1020 FIND v(dout1_257) AT=515.025n

.meas tran vdout1_258ck1020 FIND v(dout1_258) AT=515.025n

.meas tran vdout1_259ck1020 FIND v(dout1_259) AT=515.025n

.meas tran vdout1_260ck1020 FIND v(dout1_260) AT=515.025n

.meas tran vdout1_261ck1020 FIND v(dout1_261) AT=515.025n

.meas tran vdout1_262ck1020 FIND v(dout1_262) AT=515.025n

.meas tran vdout1_263ck1020 FIND v(dout1_263) AT=515.025n

.meas tran vdout1_264ck1020 FIND v(dout1_264) AT=515.025n

.meas tran vdout1_265ck1020 FIND v(dout1_265) AT=515.025n

.meas tran vdout1_266ck1020 FIND v(dout1_266) AT=515.025n

.meas tran vdout1_267ck1020 FIND v(dout1_267) AT=515.025n

.meas tran vdout1_268ck1020 FIND v(dout1_268) AT=515.025n

.meas tran vdout1_269ck1020 FIND v(dout1_269) AT=515.025n

.meas tran vdout1_270ck1020 FIND v(dout1_270) AT=515.025n

.meas tran vdout1_271ck1020 FIND v(dout1_271) AT=515.025n

.meas tran vdout1_272ck1020 FIND v(dout1_272) AT=515.025n

.meas tran vdout1_273ck1020 FIND v(dout1_273) AT=515.025n

.meas tran vdout1_274ck1020 FIND v(dout1_274) AT=515.025n

.meas tran vdout1_275ck1020 FIND v(dout1_275) AT=515.025n

.meas tran vdout1_276ck1020 FIND v(dout1_276) AT=515.025n

.meas tran vdout1_277ck1020 FIND v(dout1_277) AT=515.025n

.meas tran vdout1_278ck1020 FIND v(dout1_278) AT=515.025n

.meas tran vdout1_279ck1020 FIND v(dout1_279) AT=515.025n

.meas tran vdout1_280ck1020 FIND v(dout1_280) AT=515.025n

.meas tran vdout1_281ck1020 FIND v(dout1_281) AT=515.025n

.meas tran vdout1_282ck1020 FIND v(dout1_282) AT=515.025n

.meas tran vdout1_283ck1020 FIND v(dout1_283) AT=515.025n

.meas tran vdout1_284ck1020 FIND v(dout1_284) AT=515.025n

.meas tran vdout1_285ck1020 FIND v(dout1_285) AT=515.025n

.meas tran vdout1_286ck1020 FIND v(dout1_286) AT=515.025n

.meas tran vdout1_287ck1020 FIND v(dout1_287) AT=515.025n

.meas tran vdout1_288ck1020 FIND v(dout1_288) AT=515.025n

.meas tran vdout1_289ck1020 FIND v(dout1_289) AT=515.025n

.meas tran vdout1_290ck1020 FIND v(dout1_290) AT=515.025n

.meas tran vdout1_291ck1020 FIND v(dout1_291) AT=515.025n

.meas tran vdout1_292ck1020 FIND v(dout1_292) AT=515.025n

.meas tran vdout1_293ck1020 FIND v(dout1_293) AT=515.025n

.meas tran vdout1_294ck1020 FIND v(dout1_294) AT=515.025n

.meas tran vdout1_295ck1020 FIND v(dout1_295) AT=515.025n

.meas tran vdout1_296ck1020 FIND v(dout1_296) AT=515.025n

.meas tran vdout1_297ck1020 FIND v(dout1_297) AT=515.025n

.meas tran vdout1_298ck1020 FIND v(dout1_298) AT=515.025n

.meas tran vdout1_299ck1020 FIND v(dout1_299) AT=515.025n

.meas tran vdout1_300ck1020 FIND v(dout1_300) AT=515.025n

.meas tran vdout1_301ck1020 FIND v(dout1_301) AT=515.025n

.meas tran vdout1_302ck1020 FIND v(dout1_302) AT=515.025n

.meas tran vdout1_303ck1020 FIND v(dout1_303) AT=515.025n

.meas tran vdout1_304ck1020 FIND v(dout1_304) AT=515.025n

.meas tran vdout1_305ck1020 FIND v(dout1_305) AT=515.025n

.meas tran vdout1_306ck1020 FIND v(dout1_306) AT=515.025n

.meas tran vdout1_307ck1020 FIND v(dout1_307) AT=515.025n

.meas tran vdout1_308ck1020 FIND v(dout1_308) AT=515.025n

.meas tran vdout1_309ck1020 FIND v(dout1_309) AT=515.025n

.meas tran vdout1_310ck1020 FIND v(dout1_310) AT=515.025n

.meas tran vdout1_311ck1020 FIND v(dout1_311) AT=515.025n

.meas tran vdout1_312ck1020 FIND v(dout1_312) AT=515.025n

.meas tran vdout1_313ck1020 FIND v(dout1_313) AT=515.025n

.meas tran vdout1_314ck1020 FIND v(dout1_314) AT=515.025n

.meas tran vdout1_315ck1020 FIND v(dout1_315) AT=515.025n

.meas tran vdout1_316ck1020 FIND v(dout1_316) AT=515.025n

.meas tran vdout1_317ck1020 FIND v(dout1_317) AT=515.025n

.meas tran vdout1_318ck1020 FIND v(dout1_318) AT=515.025n

.meas tran vdout1_319ck1020 FIND v(dout1_319) AT=515.025n

.meas tran vdout1_320ck1020 FIND v(dout1_320) AT=515.025n

.meas tran vdout1_321ck1020 FIND v(dout1_321) AT=515.025n

.meas tran vdout1_322ck1020 FIND v(dout1_322) AT=515.025n

.meas tran vdout1_323ck1020 FIND v(dout1_323) AT=515.025n

.meas tran vdout1_324ck1020 FIND v(dout1_324) AT=515.025n

.meas tran vdout1_325ck1020 FIND v(dout1_325) AT=515.025n

.meas tran vdout1_326ck1020 FIND v(dout1_326) AT=515.025n

.meas tran vdout1_327ck1020 FIND v(dout1_327) AT=515.025n

.meas tran vdout1_328ck1020 FIND v(dout1_328) AT=515.025n

.meas tran vdout1_329ck1020 FIND v(dout1_329) AT=515.025n

.meas tran vdout1_330ck1020 FIND v(dout1_330) AT=515.025n

.meas tran vdout1_331ck1020 FIND v(dout1_331) AT=515.025n

.meas tran vdout1_332ck1020 FIND v(dout1_332) AT=515.025n

.meas tran vdout1_333ck1020 FIND v(dout1_333) AT=515.025n

.meas tran vdout1_334ck1020 FIND v(dout1_334) AT=515.025n

.meas tran vdout1_335ck1020 FIND v(dout1_335) AT=515.025n

.meas tran vdout1_336ck1020 FIND v(dout1_336) AT=515.025n

.meas tran vdout1_337ck1020 FIND v(dout1_337) AT=515.025n

.meas tran vdout1_338ck1020 FIND v(dout1_338) AT=515.025n

.meas tran vdout1_339ck1020 FIND v(dout1_339) AT=515.025n

.meas tran vdout1_340ck1020 FIND v(dout1_340) AT=515.025n

.meas tran vdout1_341ck1020 FIND v(dout1_341) AT=515.025n

.meas tran vdout1_342ck1020 FIND v(dout1_342) AT=515.025n

.meas tran vdout1_343ck1020 FIND v(dout1_343) AT=515.025n

.meas tran vdout1_344ck1020 FIND v(dout1_344) AT=515.025n

.meas tran vdout1_345ck1020 FIND v(dout1_345) AT=515.025n

.meas tran vdout1_346ck1020 FIND v(dout1_346) AT=515.025n

.meas tran vdout1_347ck1020 FIND v(dout1_347) AT=515.025n

.meas tran vdout1_348ck1020 FIND v(dout1_348) AT=515.025n

.meas tran vdout1_349ck1020 FIND v(dout1_349) AT=515.025n

.meas tran vdout1_350ck1020 FIND v(dout1_350) AT=515.025n

.meas tran vdout1_351ck1020 FIND v(dout1_351) AT=515.025n

.meas tran vdout1_352ck1020 FIND v(dout1_352) AT=515.025n

.meas tran vdout1_353ck1020 FIND v(dout1_353) AT=515.025n

.meas tran vdout1_354ck1020 FIND v(dout1_354) AT=515.025n

.meas tran vdout1_355ck1020 FIND v(dout1_355) AT=515.025n

.meas tran vdout1_356ck1020 FIND v(dout1_356) AT=515.025n

.meas tran vdout1_357ck1020 FIND v(dout1_357) AT=515.025n

.meas tran vdout1_358ck1020 FIND v(dout1_358) AT=515.025n

.meas tran vdout1_359ck1020 FIND v(dout1_359) AT=515.025n

.meas tran vdout1_360ck1020 FIND v(dout1_360) AT=515.025n

.meas tran vdout1_361ck1020 FIND v(dout1_361) AT=515.025n

.meas tran vdout1_362ck1020 FIND v(dout1_362) AT=515.025n

.meas tran vdout1_363ck1020 FIND v(dout1_363) AT=515.025n

.meas tran vdout1_364ck1020 FIND v(dout1_364) AT=515.025n

.meas tran vdout1_365ck1020 FIND v(dout1_365) AT=515.025n

.meas tran vdout1_366ck1020 FIND v(dout1_366) AT=515.025n

.meas tran vdout1_367ck1020 FIND v(dout1_367) AT=515.025n

.meas tran vdout1_368ck1020 FIND v(dout1_368) AT=515.025n

.meas tran vdout1_369ck1020 FIND v(dout1_369) AT=515.025n

.meas tran vdout1_370ck1020 FIND v(dout1_370) AT=515.025n

.meas tran vdout1_371ck1020 FIND v(dout1_371) AT=515.025n

.meas tran vdout1_372ck1020 FIND v(dout1_372) AT=515.025n

.meas tran vdout1_373ck1020 FIND v(dout1_373) AT=515.025n

.meas tran vdout1_374ck1020 FIND v(dout1_374) AT=515.025n

.meas tran vdout1_375ck1020 FIND v(dout1_375) AT=515.025n

.meas tran vdout1_376ck1020 FIND v(dout1_376) AT=515.025n

.meas tran vdout1_377ck1020 FIND v(dout1_377) AT=515.025n

.meas tran vdout1_378ck1020 FIND v(dout1_378) AT=515.025n

.meas tran vdout1_379ck1020 FIND v(dout1_379) AT=515.025n

.meas tran vdout1_380ck1020 FIND v(dout1_380) AT=515.025n

.meas tran vdout1_381ck1020 FIND v(dout1_381) AT=515.025n

.meas tran vdout1_382ck1020 FIND v(dout1_382) AT=515.025n

.meas tran vdout1_383ck1020 FIND v(dout1_383) AT=515.025n

.meas tran vdout1_384ck1020 FIND v(dout1_384) AT=515.025n

.meas tran vdout1_385ck1020 FIND v(dout1_385) AT=515.025n

.meas tran vdout1_386ck1020 FIND v(dout1_386) AT=515.025n

.meas tran vdout1_387ck1020 FIND v(dout1_387) AT=515.025n

.meas tran vdout1_388ck1020 FIND v(dout1_388) AT=515.025n

.meas tran vdout1_389ck1020 FIND v(dout1_389) AT=515.025n

.meas tran vdout1_390ck1020 FIND v(dout1_390) AT=515.025n

.meas tran vdout1_391ck1020 FIND v(dout1_391) AT=515.025n

.meas tran vdout1_392ck1020 FIND v(dout1_392) AT=515.025n

.meas tran vdout1_393ck1020 FIND v(dout1_393) AT=515.025n

.meas tran vdout1_394ck1020 FIND v(dout1_394) AT=515.025n

.meas tran vdout1_395ck1020 FIND v(dout1_395) AT=515.025n

.meas tran vdout1_396ck1020 FIND v(dout1_396) AT=515.025n

.meas tran vdout1_397ck1020 FIND v(dout1_397) AT=515.025n

.meas tran vdout1_398ck1020 FIND v(dout1_398) AT=515.025n

.meas tran vdout1_399ck1020 FIND v(dout1_399) AT=515.025n

.meas tran vdout1_400ck1020 FIND v(dout1_400) AT=515.025n

.meas tran vdout1_401ck1020 FIND v(dout1_401) AT=515.025n

.meas tran vdout1_402ck1020 FIND v(dout1_402) AT=515.025n

.meas tran vdout1_403ck1020 FIND v(dout1_403) AT=515.025n

.meas tran vdout1_404ck1020 FIND v(dout1_404) AT=515.025n

.meas tran vdout1_405ck1020 FIND v(dout1_405) AT=515.025n

.meas tran vdout1_406ck1020 FIND v(dout1_406) AT=515.025n

.meas tran vdout1_407ck1020 FIND v(dout1_407) AT=515.025n

.meas tran vdout1_408ck1020 FIND v(dout1_408) AT=515.025n

.meas tran vdout1_409ck1020 FIND v(dout1_409) AT=515.025n

.meas tran vdout1_410ck1020 FIND v(dout1_410) AT=515.025n

.meas tran vdout1_411ck1020 FIND v(dout1_411) AT=515.025n

.meas tran vdout1_412ck1020 FIND v(dout1_412) AT=515.025n

.meas tran vdout1_413ck1020 FIND v(dout1_413) AT=515.025n

.meas tran vdout1_414ck1020 FIND v(dout1_414) AT=515.025n

.meas tran vdout1_415ck1020 FIND v(dout1_415) AT=515.025n

.meas tran vdout1_416ck1020 FIND v(dout1_416) AT=515.025n

.meas tran vdout1_417ck1020 FIND v(dout1_417) AT=515.025n

.meas tran vdout1_418ck1020 FIND v(dout1_418) AT=515.025n

.meas tran vdout1_419ck1020 FIND v(dout1_419) AT=515.025n

.meas tran vdout1_420ck1020 FIND v(dout1_420) AT=515.025n

.meas tran vdout1_421ck1020 FIND v(dout1_421) AT=515.025n

.meas tran vdout1_422ck1020 FIND v(dout1_422) AT=515.025n

.meas tran vdout1_423ck1020 FIND v(dout1_423) AT=515.025n

.meas tran vdout1_424ck1020 FIND v(dout1_424) AT=515.025n

.meas tran vdout1_425ck1020 FIND v(dout1_425) AT=515.025n

.meas tran vdout1_426ck1020 FIND v(dout1_426) AT=515.025n

.meas tran vdout1_427ck1020 FIND v(dout1_427) AT=515.025n

.meas tran vdout1_428ck1020 FIND v(dout1_428) AT=515.025n

.meas tran vdout1_429ck1020 FIND v(dout1_429) AT=515.025n

.meas tran vdout1_430ck1020 FIND v(dout1_430) AT=515.025n

.meas tran vdout1_431ck1020 FIND v(dout1_431) AT=515.025n

.meas tran vdout1_432ck1020 FIND v(dout1_432) AT=515.025n

.meas tran vdout1_433ck1020 FIND v(dout1_433) AT=515.025n

.meas tran vdout1_434ck1020 FIND v(dout1_434) AT=515.025n

.meas tran vdout1_435ck1020 FIND v(dout1_435) AT=515.025n

.meas tran vdout1_436ck1020 FIND v(dout1_436) AT=515.025n

.meas tran vdout1_437ck1020 FIND v(dout1_437) AT=515.025n

.meas tran vdout1_438ck1020 FIND v(dout1_438) AT=515.025n

.meas tran vdout1_439ck1020 FIND v(dout1_439) AT=515.025n

.meas tran vdout1_440ck1020 FIND v(dout1_440) AT=515.025n

.meas tran vdout1_441ck1020 FIND v(dout1_441) AT=515.025n

.meas tran vdout1_442ck1020 FIND v(dout1_442) AT=515.025n

.meas tran vdout1_443ck1020 FIND v(dout1_443) AT=515.025n

.meas tran vdout1_444ck1020 FIND v(dout1_444) AT=515.025n

.meas tran vdout1_445ck1020 FIND v(dout1_445) AT=515.025n

.meas tran vdout1_446ck1020 FIND v(dout1_446) AT=515.025n

.meas tran vdout1_447ck1020 FIND v(dout1_447) AT=515.025n

.meas tran vdout1_448ck1020 FIND v(dout1_448) AT=515.025n

.meas tran vdout1_449ck1020 FIND v(dout1_449) AT=515.025n

.meas tran vdout1_450ck1020 FIND v(dout1_450) AT=515.025n

.meas tran vdout1_451ck1020 FIND v(dout1_451) AT=515.025n

.meas tran vdout1_452ck1020 FIND v(dout1_452) AT=515.025n

.meas tran vdout1_453ck1020 FIND v(dout1_453) AT=515.025n

.meas tran vdout1_454ck1020 FIND v(dout1_454) AT=515.025n

.meas tran vdout1_455ck1020 FIND v(dout1_455) AT=515.025n

.meas tran vdout1_456ck1020 FIND v(dout1_456) AT=515.025n

.meas tran vdout1_457ck1020 FIND v(dout1_457) AT=515.025n

.meas tran vdout1_458ck1020 FIND v(dout1_458) AT=515.025n

.meas tran vdout1_459ck1020 FIND v(dout1_459) AT=515.025n

.meas tran vdout1_460ck1020 FIND v(dout1_460) AT=515.025n

.meas tran vdout1_461ck1020 FIND v(dout1_461) AT=515.025n

.meas tran vdout1_462ck1020 FIND v(dout1_462) AT=515.025n

.meas tran vdout1_463ck1020 FIND v(dout1_463) AT=515.025n

.meas tran vdout1_464ck1020 FIND v(dout1_464) AT=515.025n

.meas tran vdout1_465ck1020 FIND v(dout1_465) AT=515.025n

.meas tran vdout1_466ck1020 FIND v(dout1_466) AT=515.025n

.meas tran vdout1_467ck1020 FIND v(dout1_467) AT=515.025n

.meas tran vdout1_468ck1020 FIND v(dout1_468) AT=515.025n

.meas tran vdout1_469ck1020 FIND v(dout1_469) AT=515.025n

.meas tran vdout1_470ck1020 FIND v(dout1_470) AT=515.025n

.meas tran vdout1_471ck1020 FIND v(dout1_471) AT=515.025n

.meas tran vdout1_472ck1020 FIND v(dout1_472) AT=515.025n

.meas tran vdout1_473ck1020 FIND v(dout1_473) AT=515.025n

.meas tran vdout1_474ck1020 FIND v(dout1_474) AT=515.025n

.meas tran vdout1_475ck1020 FIND v(dout1_475) AT=515.025n

.meas tran vdout1_476ck1020 FIND v(dout1_476) AT=515.025n

.meas tran vdout1_477ck1020 FIND v(dout1_477) AT=515.025n

.meas tran vdout1_478ck1020 FIND v(dout1_478) AT=515.025n

.meas tran vdout1_479ck1020 FIND v(dout1_479) AT=515.025n

.meas tran vdout1_480ck1020 FIND v(dout1_480) AT=515.025n

.meas tran vdout1_481ck1020 FIND v(dout1_481) AT=515.025n

.meas tran vdout1_482ck1020 FIND v(dout1_482) AT=515.025n

.meas tran vdout1_483ck1020 FIND v(dout1_483) AT=515.025n

.meas tran vdout1_484ck1020 FIND v(dout1_484) AT=515.025n

.meas tran vdout1_485ck1020 FIND v(dout1_485) AT=515.025n

.meas tran vdout1_486ck1020 FIND v(dout1_486) AT=515.025n

.meas tran vdout1_487ck1020 FIND v(dout1_487) AT=515.025n

.meas tran vdout1_488ck1020 FIND v(dout1_488) AT=515.025n

.meas tran vdout1_489ck1020 FIND v(dout1_489) AT=515.025n

.meas tran vdout1_490ck1020 FIND v(dout1_490) AT=515.025n

.meas tran vdout1_491ck1020 FIND v(dout1_491) AT=515.025n

.meas tran vdout1_492ck1020 FIND v(dout1_492) AT=515.025n

.meas tran vdout1_493ck1020 FIND v(dout1_493) AT=515.025n

.meas tran vdout1_494ck1020 FIND v(dout1_494) AT=515.025n

.meas tran vdout1_495ck1020 FIND v(dout1_495) AT=515.025n

.meas tran vdout1_496ck1020 FIND v(dout1_496) AT=515.025n

.meas tran vdout1_497ck1020 FIND v(dout1_497) AT=515.025n

.meas tran vdout1_498ck1020 FIND v(dout1_498) AT=515.025n

.meas tran vdout1_499ck1020 FIND v(dout1_499) AT=515.025n

.meas tran vdout1_500ck1020 FIND v(dout1_500) AT=515.025n

.meas tran vdout1_501ck1020 FIND v(dout1_501) AT=515.025n

.meas tran vdout1_502ck1020 FIND v(dout1_502) AT=515.025n

.meas tran vdout1_503ck1020 FIND v(dout1_503) AT=515.025n

.meas tran vdout1_504ck1020 FIND v(dout1_504) AT=515.025n

.meas tran vdout1_505ck1020 FIND v(dout1_505) AT=515.025n

.meas tran vdout1_506ck1020 FIND v(dout1_506) AT=515.025n

.meas tran vdout1_507ck1020 FIND v(dout1_507) AT=515.025n

.meas tran vdout1_508ck1020 FIND v(dout1_508) AT=515.025n

.meas tran vdout1_509ck1020 FIND v(dout1_509) AT=515.025n

.meas tran vdout1_510ck1020 FIND v(dout1_510) AT=515.025n

.meas tran vdout1_511ck1020 FIND v(dout1_511) AT=515.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_16ck1030 FIND v(dout1_16) AT=520.025n

.meas tran vdout1_17ck1030 FIND v(dout1_17) AT=520.025n

.meas tran vdout1_18ck1030 FIND v(dout1_18) AT=520.025n

.meas tran vdout1_19ck1030 FIND v(dout1_19) AT=520.025n

.meas tran vdout1_20ck1030 FIND v(dout1_20) AT=520.025n

.meas tran vdout1_21ck1030 FIND v(dout1_21) AT=520.025n

.meas tran vdout1_22ck1030 FIND v(dout1_22) AT=520.025n

.meas tran vdout1_23ck1030 FIND v(dout1_23) AT=520.025n

.meas tran vdout1_24ck1030 FIND v(dout1_24) AT=520.025n

.meas tran vdout1_25ck1030 FIND v(dout1_25) AT=520.025n

.meas tran vdout1_26ck1030 FIND v(dout1_26) AT=520.025n

.meas tran vdout1_27ck1030 FIND v(dout1_27) AT=520.025n

.meas tran vdout1_28ck1030 FIND v(dout1_28) AT=520.025n

.meas tran vdout1_29ck1030 FIND v(dout1_29) AT=520.025n

.meas tran vdout1_30ck1030 FIND v(dout1_30) AT=520.025n

.meas tran vdout1_31ck1030 FIND v(dout1_31) AT=520.025n

.meas tran vdout1_32ck1030 FIND v(dout1_32) AT=520.025n

.meas tran vdout1_33ck1030 FIND v(dout1_33) AT=520.025n

.meas tran vdout1_34ck1030 FIND v(dout1_34) AT=520.025n

.meas tran vdout1_35ck1030 FIND v(dout1_35) AT=520.025n

.meas tran vdout1_36ck1030 FIND v(dout1_36) AT=520.025n

.meas tran vdout1_37ck1030 FIND v(dout1_37) AT=520.025n

.meas tran vdout1_38ck1030 FIND v(dout1_38) AT=520.025n

.meas tran vdout1_39ck1030 FIND v(dout1_39) AT=520.025n

.meas tran vdout1_40ck1030 FIND v(dout1_40) AT=520.025n

.meas tran vdout1_41ck1030 FIND v(dout1_41) AT=520.025n

.meas tran vdout1_42ck1030 FIND v(dout1_42) AT=520.025n

.meas tran vdout1_43ck1030 FIND v(dout1_43) AT=520.025n

.meas tran vdout1_44ck1030 FIND v(dout1_44) AT=520.025n

.meas tran vdout1_45ck1030 FIND v(dout1_45) AT=520.025n

.meas tran vdout1_46ck1030 FIND v(dout1_46) AT=520.025n

.meas tran vdout1_47ck1030 FIND v(dout1_47) AT=520.025n

.meas tran vdout1_48ck1030 FIND v(dout1_48) AT=520.025n

.meas tran vdout1_49ck1030 FIND v(dout1_49) AT=520.025n

.meas tran vdout1_50ck1030 FIND v(dout1_50) AT=520.025n

.meas tran vdout1_51ck1030 FIND v(dout1_51) AT=520.025n

.meas tran vdout1_52ck1030 FIND v(dout1_52) AT=520.025n

.meas tran vdout1_53ck1030 FIND v(dout1_53) AT=520.025n

.meas tran vdout1_54ck1030 FIND v(dout1_54) AT=520.025n

.meas tran vdout1_55ck1030 FIND v(dout1_55) AT=520.025n

.meas tran vdout1_56ck1030 FIND v(dout1_56) AT=520.025n

.meas tran vdout1_57ck1030 FIND v(dout1_57) AT=520.025n

.meas tran vdout1_58ck1030 FIND v(dout1_58) AT=520.025n

.meas tran vdout1_59ck1030 FIND v(dout1_59) AT=520.025n

.meas tran vdout1_60ck1030 FIND v(dout1_60) AT=520.025n

.meas tran vdout1_61ck1030 FIND v(dout1_61) AT=520.025n

.meas tran vdout1_62ck1030 FIND v(dout1_62) AT=520.025n

.meas tran vdout1_63ck1030 FIND v(dout1_63) AT=520.025n

.meas tran vdout1_64ck1030 FIND v(dout1_64) AT=520.025n

.meas tran vdout1_65ck1030 FIND v(dout1_65) AT=520.025n

.meas tran vdout1_66ck1030 FIND v(dout1_66) AT=520.025n

.meas tran vdout1_67ck1030 FIND v(dout1_67) AT=520.025n

.meas tran vdout1_68ck1030 FIND v(dout1_68) AT=520.025n

.meas tran vdout1_69ck1030 FIND v(dout1_69) AT=520.025n

.meas tran vdout1_70ck1030 FIND v(dout1_70) AT=520.025n

.meas tran vdout1_71ck1030 FIND v(dout1_71) AT=520.025n

.meas tran vdout1_72ck1030 FIND v(dout1_72) AT=520.025n

.meas tran vdout1_73ck1030 FIND v(dout1_73) AT=520.025n

.meas tran vdout1_74ck1030 FIND v(dout1_74) AT=520.025n

.meas tran vdout1_75ck1030 FIND v(dout1_75) AT=520.025n

.meas tran vdout1_76ck1030 FIND v(dout1_76) AT=520.025n

.meas tran vdout1_77ck1030 FIND v(dout1_77) AT=520.025n

.meas tran vdout1_78ck1030 FIND v(dout1_78) AT=520.025n

.meas tran vdout1_79ck1030 FIND v(dout1_79) AT=520.025n

.meas tran vdout1_80ck1030 FIND v(dout1_80) AT=520.025n

.meas tran vdout1_81ck1030 FIND v(dout1_81) AT=520.025n

.meas tran vdout1_82ck1030 FIND v(dout1_82) AT=520.025n

.meas tran vdout1_83ck1030 FIND v(dout1_83) AT=520.025n

.meas tran vdout1_84ck1030 FIND v(dout1_84) AT=520.025n

.meas tran vdout1_85ck1030 FIND v(dout1_85) AT=520.025n

.meas tran vdout1_86ck1030 FIND v(dout1_86) AT=520.025n

.meas tran vdout1_87ck1030 FIND v(dout1_87) AT=520.025n

.meas tran vdout1_88ck1030 FIND v(dout1_88) AT=520.025n

.meas tran vdout1_89ck1030 FIND v(dout1_89) AT=520.025n

.meas tran vdout1_90ck1030 FIND v(dout1_90) AT=520.025n

.meas tran vdout1_91ck1030 FIND v(dout1_91) AT=520.025n

.meas tran vdout1_92ck1030 FIND v(dout1_92) AT=520.025n

.meas tran vdout1_93ck1030 FIND v(dout1_93) AT=520.025n

.meas tran vdout1_94ck1030 FIND v(dout1_94) AT=520.025n

.meas tran vdout1_95ck1030 FIND v(dout1_95) AT=520.025n

.meas tran vdout1_96ck1030 FIND v(dout1_96) AT=520.025n

.meas tran vdout1_97ck1030 FIND v(dout1_97) AT=520.025n

.meas tran vdout1_98ck1030 FIND v(dout1_98) AT=520.025n

.meas tran vdout1_99ck1030 FIND v(dout1_99) AT=520.025n

.meas tran vdout1_100ck1030 FIND v(dout1_100) AT=520.025n

.meas tran vdout1_101ck1030 FIND v(dout1_101) AT=520.025n

.meas tran vdout1_102ck1030 FIND v(dout1_102) AT=520.025n

.meas tran vdout1_103ck1030 FIND v(dout1_103) AT=520.025n

.meas tran vdout1_104ck1030 FIND v(dout1_104) AT=520.025n

.meas tran vdout1_105ck1030 FIND v(dout1_105) AT=520.025n

.meas tran vdout1_106ck1030 FIND v(dout1_106) AT=520.025n

.meas tran vdout1_107ck1030 FIND v(dout1_107) AT=520.025n

.meas tran vdout1_108ck1030 FIND v(dout1_108) AT=520.025n

.meas tran vdout1_109ck1030 FIND v(dout1_109) AT=520.025n

.meas tran vdout1_110ck1030 FIND v(dout1_110) AT=520.025n

.meas tran vdout1_111ck1030 FIND v(dout1_111) AT=520.025n

.meas tran vdout1_112ck1030 FIND v(dout1_112) AT=520.025n

.meas tran vdout1_113ck1030 FIND v(dout1_113) AT=520.025n

.meas tran vdout1_114ck1030 FIND v(dout1_114) AT=520.025n

.meas tran vdout1_115ck1030 FIND v(dout1_115) AT=520.025n

.meas tran vdout1_116ck1030 FIND v(dout1_116) AT=520.025n

.meas tran vdout1_117ck1030 FIND v(dout1_117) AT=520.025n

.meas tran vdout1_118ck1030 FIND v(dout1_118) AT=520.025n

.meas tran vdout1_119ck1030 FIND v(dout1_119) AT=520.025n

.meas tran vdout1_120ck1030 FIND v(dout1_120) AT=520.025n

.meas tran vdout1_121ck1030 FIND v(dout1_121) AT=520.025n

.meas tran vdout1_122ck1030 FIND v(dout1_122) AT=520.025n

.meas tran vdout1_123ck1030 FIND v(dout1_123) AT=520.025n

.meas tran vdout1_124ck1030 FIND v(dout1_124) AT=520.025n

.meas tran vdout1_125ck1030 FIND v(dout1_125) AT=520.025n

.meas tran vdout1_126ck1030 FIND v(dout1_126) AT=520.025n

.meas tran vdout1_127ck1030 FIND v(dout1_127) AT=520.025n

.meas tran vdout1_128ck1030 FIND v(dout1_128) AT=520.025n

.meas tran vdout1_129ck1030 FIND v(dout1_129) AT=520.025n

.meas tran vdout1_130ck1030 FIND v(dout1_130) AT=520.025n

.meas tran vdout1_131ck1030 FIND v(dout1_131) AT=520.025n

.meas tran vdout1_132ck1030 FIND v(dout1_132) AT=520.025n

.meas tran vdout1_133ck1030 FIND v(dout1_133) AT=520.025n

.meas tran vdout1_134ck1030 FIND v(dout1_134) AT=520.025n

.meas tran vdout1_135ck1030 FIND v(dout1_135) AT=520.025n

.meas tran vdout1_136ck1030 FIND v(dout1_136) AT=520.025n

.meas tran vdout1_137ck1030 FIND v(dout1_137) AT=520.025n

.meas tran vdout1_138ck1030 FIND v(dout1_138) AT=520.025n

.meas tran vdout1_139ck1030 FIND v(dout1_139) AT=520.025n

.meas tran vdout1_140ck1030 FIND v(dout1_140) AT=520.025n

.meas tran vdout1_141ck1030 FIND v(dout1_141) AT=520.025n

.meas tran vdout1_142ck1030 FIND v(dout1_142) AT=520.025n

.meas tran vdout1_143ck1030 FIND v(dout1_143) AT=520.025n

.meas tran vdout1_144ck1030 FIND v(dout1_144) AT=520.025n

.meas tran vdout1_145ck1030 FIND v(dout1_145) AT=520.025n

.meas tran vdout1_146ck1030 FIND v(dout1_146) AT=520.025n

.meas tran vdout1_147ck1030 FIND v(dout1_147) AT=520.025n

.meas tran vdout1_148ck1030 FIND v(dout1_148) AT=520.025n

.meas tran vdout1_149ck1030 FIND v(dout1_149) AT=520.025n

.meas tran vdout1_150ck1030 FIND v(dout1_150) AT=520.025n

.meas tran vdout1_151ck1030 FIND v(dout1_151) AT=520.025n

.meas tran vdout1_152ck1030 FIND v(dout1_152) AT=520.025n

.meas tran vdout1_153ck1030 FIND v(dout1_153) AT=520.025n

.meas tran vdout1_154ck1030 FIND v(dout1_154) AT=520.025n

.meas tran vdout1_155ck1030 FIND v(dout1_155) AT=520.025n

.meas tran vdout1_156ck1030 FIND v(dout1_156) AT=520.025n

.meas tran vdout1_157ck1030 FIND v(dout1_157) AT=520.025n

.meas tran vdout1_158ck1030 FIND v(dout1_158) AT=520.025n

.meas tran vdout1_159ck1030 FIND v(dout1_159) AT=520.025n

.meas tran vdout1_160ck1030 FIND v(dout1_160) AT=520.025n

.meas tran vdout1_161ck1030 FIND v(dout1_161) AT=520.025n

.meas tran vdout1_162ck1030 FIND v(dout1_162) AT=520.025n

.meas tran vdout1_163ck1030 FIND v(dout1_163) AT=520.025n

.meas tran vdout1_164ck1030 FIND v(dout1_164) AT=520.025n

.meas tran vdout1_165ck1030 FIND v(dout1_165) AT=520.025n

.meas tran vdout1_166ck1030 FIND v(dout1_166) AT=520.025n

.meas tran vdout1_167ck1030 FIND v(dout1_167) AT=520.025n

.meas tran vdout1_168ck1030 FIND v(dout1_168) AT=520.025n

.meas tran vdout1_169ck1030 FIND v(dout1_169) AT=520.025n

.meas tran vdout1_170ck1030 FIND v(dout1_170) AT=520.025n

.meas tran vdout1_171ck1030 FIND v(dout1_171) AT=520.025n

.meas tran vdout1_172ck1030 FIND v(dout1_172) AT=520.025n

.meas tran vdout1_173ck1030 FIND v(dout1_173) AT=520.025n

.meas tran vdout1_174ck1030 FIND v(dout1_174) AT=520.025n

.meas tran vdout1_175ck1030 FIND v(dout1_175) AT=520.025n

.meas tran vdout1_176ck1030 FIND v(dout1_176) AT=520.025n

.meas tran vdout1_177ck1030 FIND v(dout1_177) AT=520.025n

.meas tran vdout1_178ck1030 FIND v(dout1_178) AT=520.025n

.meas tran vdout1_179ck1030 FIND v(dout1_179) AT=520.025n

.meas tran vdout1_180ck1030 FIND v(dout1_180) AT=520.025n

.meas tran vdout1_181ck1030 FIND v(dout1_181) AT=520.025n

.meas tran vdout1_182ck1030 FIND v(dout1_182) AT=520.025n

.meas tran vdout1_183ck1030 FIND v(dout1_183) AT=520.025n

.meas tran vdout1_184ck1030 FIND v(dout1_184) AT=520.025n

.meas tran vdout1_185ck1030 FIND v(dout1_185) AT=520.025n

.meas tran vdout1_186ck1030 FIND v(dout1_186) AT=520.025n

.meas tran vdout1_187ck1030 FIND v(dout1_187) AT=520.025n

.meas tran vdout1_188ck1030 FIND v(dout1_188) AT=520.025n

.meas tran vdout1_189ck1030 FIND v(dout1_189) AT=520.025n

.meas tran vdout1_190ck1030 FIND v(dout1_190) AT=520.025n

.meas tran vdout1_191ck1030 FIND v(dout1_191) AT=520.025n

.meas tran vdout1_192ck1030 FIND v(dout1_192) AT=520.025n

.meas tran vdout1_193ck1030 FIND v(dout1_193) AT=520.025n

.meas tran vdout1_194ck1030 FIND v(dout1_194) AT=520.025n

.meas tran vdout1_195ck1030 FIND v(dout1_195) AT=520.025n

.meas tran vdout1_196ck1030 FIND v(dout1_196) AT=520.025n

.meas tran vdout1_197ck1030 FIND v(dout1_197) AT=520.025n

.meas tran vdout1_198ck1030 FIND v(dout1_198) AT=520.025n

.meas tran vdout1_199ck1030 FIND v(dout1_199) AT=520.025n

.meas tran vdout1_200ck1030 FIND v(dout1_200) AT=520.025n

.meas tran vdout1_201ck1030 FIND v(dout1_201) AT=520.025n

.meas tran vdout1_202ck1030 FIND v(dout1_202) AT=520.025n

.meas tran vdout1_203ck1030 FIND v(dout1_203) AT=520.025n

.meas tran vdout1_204ck1030 FIND v(dout1_204) AT=520.025n

.meas tran vdout1_205ck1030 FIND v(dout1_205) AT=520.025n

.meas tran vdout1_206ck1030 FIND v(dout1_206) AT=520.025n

.meas tran vdout1_207ck1030 FIND v(dout1_207) AT=520.025n

.meas tran vdout1_208ck1030 FIND v(dout1_208) AT=520.025n

.meas tran vdout1_209ck1030 FIND v(dout1_209) AT=520.025n

.meas tran vdout1_210ck1030 FIND v(dout1_210) AT=520.025n

.meas tran vdout1_211ck1030 FIND v(dout1_211) AT=520.025n

.meas tran vdout1_212ck1030 FIND v(dout1_212) AT=520.025n

.meas tran vdout1_213ck1030 FIND v(dout1_213) AT=520.025n

.meas tran vdout1_214ck1030 FIND v(dout1_214) AT=520.025n

.meas tran vdout1_215ck1030 FIND v(dout1_215) AT=520.025n

.meas tran vdout1_216ck1030 FIND v(dout1_216) AT=520.025n

.meas tran vdout1_217ck1030 FIND v(dout1_217) AT=520.025n

.meas tran vdout1_218ck1030 FIND v(dout1_218) AT=520.025n

.meas tran vdout1_219ck1030 FIND v(dout1_219) AT=520.025n

.meas tran vdout1_220ck1030 FIND v(dout1_220) AT=520.025n

.meas tran vdout1_221ck1030 FIND v(dout1_221) AT=520.025n

.meas tran vdout1_222ck1030 FIND v(dout1_222) AT=520.025n

.meas tran vdout1_223ck1030 FIND v(dout1_223) AT=520.025n

.meas tran vdout1_224ck1030 FIND v(dout1_224) AT=520.025n

.meas tran vdout1_225ck1030 FIND v(dout1_225) AT=520.025n

.meas tran vdout1_226ck1030 FIND v(dout1_226) AT=520.025n

.meas tran vdout1_227ck1030 FIND v(dout1_227) AT=520.025n

.meas tran vdout1_228ck1030 FIND v(dout1_228) AT=520.025n

.meas tran vdout1_229ck1030 FIND v(dout1_229) AT=520.025n

.meas tran vdout1_230ck1030 FIND v(dout1_230) AT=520.025n

.meas tran vdout1_231ck1030 FIND v(dout1_231) AT=520.025n

.meas tran vdout1_232ck1030 FIND v(dout1_232) AT=520.025n

.meas tran vdout1_233ck1030 FIND v(dout1_233) AT=520.025n

.meas tran vdout1_234ck1030 FIND v(dout1_234) AT=520.025n

.meas tran vdout1_235ck1030 FIND v(dout1_235) AT=520.025n

.meas tran vdout1_236ck1030 FIND v(dout1_236) AT=520.025n

.meas tran vdout1_237ck1030 FIND v(dout1_237) AT=520.025n

.meas tran vdout1_238ck1030 FIND v(dout1_238) AT=520.025n

.meas tran vdout1_239ck1030 FIND v(dout1_239) AT=520.025n

.meas tran vdout1_240ck1030 FIND v(dout1_240) AT=520.025n

.meas tran vdout1_241ck1030 FIND v(dout1_241) AT=520.025n

.meas tran vdout1_242ck1030 FIND v(dout1_242) AT=520.025n

.meas tran vdout1_243ck1030 FIND v(dout1_243) AT=520.025n

.meas tran vdout1_244ck1030 FIND v(dout1_244) AT=520.025n

.meas tran vdout1_245ck1030 FIND v(dout1_245) AT=520.025n

.meas tran vdout1_246ck1030 FIND v(dout1_246) AT=520.025n

.meas tran vdout1_247ck1030 FIND v(dout1_247) AT=520.025n

.meas tran vdout1_248ck1030 FIND v(dout1_248) AT=520.025n

.meas tran vdout1_249ck1030 FIND v(dout1_249) AT=520.025n

.meas tran vdout1_250ck1030 FIND v(dout1_250) AT=520.025n

.meas tran vdout1_251ck1030 FIND v(dout1_251) AT=520.025n

.meas tran vdout1_252ck1030 FIND v(dout1_252) AT=520.025n

.meas tran vdout1_253ck1030 FIND v(dout1_253) AT=520.025n

.meas tran vdout1_254ck1030 FIND v(dout1_254) AT=520.025n

.meas tran vdout1_255ck1030 FIND v(dout1_255) AT=520.025n

.meas tran vdout1_256ck1030 FIND v(dout1_256) AT=520.025n

.meas tran vdout1_257ck1030 FIND v(dout1_257) AT=520.025n

.meas tran vdout1_258ck1030 FIND v(dout1_258) AT=520.025n

.meas tran vdout1_259ck1030 FIND v(dout1_259) AT=520.025n

.meas tran vdout1_260ck1030 FIND v(dout1_260) AT=520.025n

.meas tran vdout1_261ck1030 FIND v(dout1_261) AT=520.025n

.meas tran vdout1_262ck1030 FIND v(dout1_262) AT=520.025n

.meas tran vdout1_263ck1030 FIND v(dout1_263) AT=520.025n

.meas tran vdout1_264ck1030 FIND v(dout1_264) AT=520.025n

.meas tran vdout1_265ck1030 FIND v(dout1_265) AT=520.025n

.meas tran vdout1_266ck1030 FIND v(dout1_266) AT=520.025n

.meas tran vdout1_267ck1030 FIND v(dout1_267) AT=520.025n

.meas tran vdout1_268ck1030 FIND v(dout1_268) AT=520.025n

.meas tran vdout1_269ck1030 FIND v(dout1_269) AT=520.025n

.meas tran vdout1_270ck1030 FIND v(dout1_270) AT=520.025n

.meas tran vdout1_271ck1030 FIND v(dout1_271) AT=520.025n

.meas tran vdout1_272ck1030 FIND v(dout1_272) AT=520.025n

.meas tran vdout1_273ck1030 FIND v(dout1_273) AT=520.025n

.meas tran vdout1_274ck1030 FIND v(dout1_274) AT=520.025n

.meas tran vdout1_275ck1030 FIND v(dout1_275) AT=520.025n

.meas tran vdout1_276ck1030 FIND v(dout1_276) AT=520.025n

.meas tran vdout1_277ck1030 FIND v(dout1_277) AT=520.025n

.meas tran vdout1_278ck1030 FIND v(dout1_278) AT=520.025n

.meas tran vdout1_279ck1030 FIND v(dout1_279) AT=520.025n

.meas tran vdout1_280ck1030 FIND v(dout1_280) AT=520.025n

.meas tran vdout1_281ck1030 FIND v(dout1_281) AT=520.025n

.meas tran vdout1_282ck1030 FIND v(dout1_282) AT=520.025n

.meas tran vdout1_283ck1030 FIND v(dout1_283) AT=520.025n

.meas tran vdout1_284ck1030 FIND v(dout1_284) AT=520.025n

.meas tran vdout1_285ck1030 FIND v(dout1_285) AT=520.025n

.meas tran vdout1_286ck1030 FIND v(dout1_286) AT=520.025n

.meas tran vdout1_287ck1030 FIND v(dout1_287) AT=520.025n

.meas tran vdout1_288ck1030 FIND v(dout1_288) AT=520.025n

.meas tran vdout1_289ck1030 FIND v(dout1_289) AT=520.025n

.meas tran vdout1_290ck1030 FIND v(dout1_290) AT=520.025n

.meas tran vdout1_291ck1030 FIND v(dout1_291) AT=520.025n

.meas tran vdout1_292ck1030 FIND v(dout1_292) AT=520.025n

.meas tran vdout1_293ck1030 FIND v(dout1_293) AT=520.025n

.meas tran vdout1_294ck1030 FIND v(dout1_294) AT=520.025n

.meas tran vdout1_295ck1030 FIND v(dout1_295) AT=520.025n

.meas tran vdout1_296ck1030 FIND v(dout1_296) AT=520.025n

.meas tran vdout1_297ck1030 FIND v(dout1_297) AT=520.025n

.meas tran vdout1_298ck1030 FIND v(dout1_298) AT=520.025n

.meas tran vdout1_299ck1030 FIND v(dout1_299) AT=520.025n

.meas tran vdout1_300ck1030 FIND v(dout1_300) AT=520.025n

.meas tran vdout1_301ck1030 FIND v(dout1_301) AT=520.025n

.meas tran vdout1_302ck1030 FIND v(dout1_302) AT=520.025n

.meas tran vdout1_303ck1030 FIND v(dout1_303) AT=520.025n

.meas tran vdout1_304ck1030 FIND v(dout1_304) AT=520.025n

.meas tran vdout1_305ck1030 FIND v(dout1_305) AT=520.025n

.meas tran vdout1_306ck1030 FIND v(dout1_306) AT=520.025n

.meas tran vdout1_307ck1030 FIND v(dout1_307) AT=520.025n

.meas tran vdout1_308ck1030 FIND v(dout1_308) AT=520.025n

.meas tran vdout1_309ck1030 FIND v(dout1_309) AT=520.025n

.meas tran vdout1_310ck1030 FIND v(dout1_310) AT=520.025n

.meas tran vdout1_311ck1030 FIND v(dout1_311) AT=520.025n

.meas tran vdout1_312ck1030 FIND v(dout1_312) AT=520.025n

.meas tran vdout1_313ck1030 FIND v(dout1_313) AT=520.025n

.meas tran vdout1_314ck1030 FIND v(dout1_314) AT=520.025n

.meas tran vdout1_315ck1030 FIND v(dout1_315) AT=520.025n

.meas tran vdout1_316ck1030 FIND v(dout1_316) AT=520.025n

.meas tran vdout1_317ck1030 FIND v(dout1_317) AT=520.025n

.meas tran vdout1_318ck1030 FIND v(dout1_318) AT=520.025n

.meas tran vdout1_319ck1030 FIND v(dout1_319) AT=520.025n

.meas tran vdout1_320ck1030 FIND v(dout1_320) AT=520.025n

.meas tran vdout1_321ck1030 FIND v(dout1_321) AT=520.025n

.meas tran vdout1_322ck1030 FIND v(dout1_322) AT=520.025n

.meas tran vdout1_323ck1030 FIND v(dout1_323) AT=520.025n

.meas tran vdout1_324ck1030 FIND v(dout1_324) AT=520.025n

.meas tran vdout1_325ck1030 FIND v(dout1_325) AT=520.025n

.meas tran vdout1_326ck1030 FIND v(dout1_326) AT=520.025n

.meas tran vdout1_327ck1030 FIND v(dout1_327) AT=520.025n

.meas tran vdout1_328ck1030 FIND v(dout1_328) AT=520.025n

.meas tran vdout1_329ck1030 FIND v(dout1_329) AT=520.025n

.meas tran vdout1_330ck1030 FIND v(dout1_330) AT=520.025n

.meas tran vdout1_331ck1030 FIND v(dout1_331) AT=520.025n

.meas tran vdout1_332ck1030 FIND v(dout1_332) AT=520.025n

.meas tran vdout1_333ck1030 FIND v(dout1_333) AT=520.025n

.meas tran vdout1_334ck1030 FIND v(dout1_334) AT=520.025n

.meas tran vdout1_335ck1030 FIND v(dout1_335) AT=520.025n

.meas tran vdout1_336ck1030 FIND v(dout1_336) AT=520.025n

.meas tran vdout1_337ck1030 FIND v(dout1_337) AT=520.025n

.meas tran vdout1_338ck1030 FIND v(dout1_338) AT=520.025n

.meas tran vdout1_339ck1030 FIND v(dout1_339) AT=520.025n

.meas tran vdout1_340ck1030 FIND v(dout1_340) AT=520.025n

.meas tran vdout1_341ck1030 FIND v(dout1_341) AT=520.025n

.meas tran vdout1_342ck1030 FIND v(dout1_342) AT=520.025n

.meas tran vdout1_343ck1030 FIND v(dout1_343) AT=520.025n

.meas tran vdout1_344ck1030 FIND v(dout1_344) AT=520.025n

.meas tran vdout1_345ck1030 FIND v(dout1_345) AT=520.025n

.meas tran vdout1_346ck1030 FIND v(dout1_346) AT=520.025n

.meas tran vdout1_347ck1030 FIND v(dout1_347) AT=520.025n

.meas tran vdout1_348ck1030 FIND v(dout1_348) AT=520.025n

.meas tran vdout1_349ck1030 FIND v(dout1_349) AT=520.025n

.meas tran vdout1_350ck1030 FIND v(dout1_350) AT=520.025n

.meas tran vdout1_351ck1030 FIND v(dout1_351) AT=520.025n

.meas tran vdout1_352ck1030 FIND v(dout1_352) AT=520.025n

.meas tran vdout1_353ck1030 FIND v(dout1_353) AT=520.025n

.meas tran vdout1_354ck1030 FIND v(dout1_354) AT=520.025n

.meas tran vdout1_355ck1030 FIND v(dout1_355) AT=520.025n

.meas tran vdout1_356ck1030 FIND v(dout1_356) AT=520.025n

.meas tran vdout1_357ck1030 FIND v(dout1_357) AT=520.025n

.meas tran vdout1_358ck1030 FIND v(dout1_358) AT=520.025n

.meas tran vdout1_359ck1030 FIND v(dout1_359) AT=520.025n

.meas tran vdout1_360ck1030 FIND v(dout1_360) AT=520.025n

.meas tran vdout1_361ck1030 FIND v(dout1_361) AT=520.025n

.meas tran vdout1_362ck1030 FIND v(dout1_362) AT=520.025n

.meas tran vdout1_363ck1030 FIND v(dout1_363) AT=520.025n

.meas tran vdout1_364ck1030 FIND v(dout1_364) AT=520.025n

.meas tran vdout1_365ck1030 FIND v(dout1_365) AT=520.025n

.meas tran vdout1_366ck1030 FIND v(dout1_366) AT=520.025n

.meas tran vdout1_367ck1030 FIND v(dout1_367) AT=520.025n

.meas tran vdout1_368ck1030 FIND v(dout1_368) AT=520.025n

.meas tran vdout1_369ck1030 FIND v(dout1_369) AT=520.025n

.meas tran vdout1_370ck1030 FIND v(dout1_370) AT=520.025n

.meas tran vdout1_371ck1030 FIND v(dout1_371) AT=520.025n

.meas tran vdout1_372ck1030 FIND v(dout1_372) AT=520.025n

.meas tran vdout1_373ck1030 FIND v(dout1_373) AT=520.025n

.meas tran vdout1_374ck1030 FIND v(dout1_374) AT=520.025n

.meas tran vdout1_375ck1030 FIND v(dout1_375) AT=520.025n

.meas tran vdout1_376ck1030 FIND v(dout1_376) AT=520.025n

.meas tran vdout1_377ck1030 FIND v(dout1_377) AT=520.025n

.meas tran vdout1_378ck1030 FIND v(dout1_378) AT=520.025n

.meas tran vdout1_379ck1030 FIND v(dout1_379) AT=520.025n

.meas tran vdout1_380ck1030 FIND v(dout1_380) AT=520.025n

.meas tran vdout1_381ck1030 FIND v(dout1_381) AT=520.025n

.meas tran vdout1_382ck1030 FIND v(dout1_382) AT=520.025n

.meas tran vdout1_383ck1030 FIND v(dout1_383) AT=520.025n

.meas tran vdout1_384ck1030 FIND v(dout1_384) AT=520.025n

.meas tran vdout1_385ck1030 FIND v(dout1_385) AT=520.025n

.meas tran vdout1_386ck1030 FIND v(dout1_386) AT=520.025n

.meas tran vdout1_387ck1030 FIND v(dout1_387) AT=520.025n

.meas tran vdout1_388ck1030 FIND v(dout1_388) AT=520.025n

.meas tran vdout1_389ck1030 FIND v(dout1_389) AT=520.025n

.meas tran vdout1_390ck1030 FIND v(dout1_390) AT=520.025n

.meas tran vdout1_391ck1030 FIND v(dout1_391) AT=520.025n

.meas tran vdout1_392ck1030 FIND v(dout1_392) AT=520.025n

.meas tran vdout1_393ck1030 FIND v(dout1_393) AT=520.025n

.meas tran vdout1_394ck1030 FIND v(dout1_394) AT=520.025n

.meas tran vdout1_395ck1030 FIND v(dout1_395) AT=520.025n

.meas tran vdout1_396ck1030 FIND v(dout1_396) AT=520.025n

.meas tran vdout1_397ck1030 FIND v(dout1_397) AT=520.025n

.meas tran vdout1_398ck1030 FIND v(dout1_398) AT=520.025n

.meas tran vdout1_399ck1030 FIND v(dout1_399) AT=520.025n

.meas tran vdout1_400ck1030 FIND v(dout1_400) AT=520.025n

.meas tran vdout1_401ck1030 FIND v(dout1_401) AT=520.025n

.meas tran vdout1_402ck1030 FIND v(dout1_402) AT=520.025n

.meas tran vdout1_403ck1030 FIND v(dout1_403) AT=520.025n

.meas tran vdout1_404ck1030 FIND v(dout1_404) AT=520.025n

.meas tran vdout1_405ck1030 FIND v(dout1_405) AT=520.025n

.meas tran vdout1_406ck1030 FIND v(dout1_406) AT=520.025n

.meas tran vdout1_407ck1030 FIND v(dout1_407) AT=520.025n

.meas tran vdout1_408ck1030 FIND v(dout1_408) AT=520.025n

.meas tran vdout1_409ck1030 FIND v(dout1_409) AT=520.025n

.meas tran vdout1_410ck1030 FIND v(dout1_410) AT=520.025n

.meas tran vdout1_411ck1030 FIND v(dout1_411) AT=520.025n

.meas tran vdout1_412ck1030 FIND v(dout1_412) AT=520.025n

.meas tran vdout1_413ck1030 FIND v(dout1_413) AT=520.025n

.meas tran vdout1_414ck1030 FIND v(dout1_414) AT=520.025n

.meas tran vdout1_415ck1030 FIND v(dout1_415) AT=520.025n

.meas tran vdout1_416ck1030 FIND v(dout1_416) AT=520.025n

.meas tran vdout1_417ck1030 FIND v(dout1_417) AT=520.025n

.meas tran vdout1_418ck1030 FIND v(dout1_418) AT=520.025n

.meas tran vdout1_419ck1030 FIND v(dout1_419) AT=520.025n

.meas tran vdout1_420ck1030 FIND v(dout1_420) AT=520.025n

.meas tran vdout1_421ck1030 FIND v(dout1_421) AT=520.025n

.meas tran vdout1_422ck1030 FIND v(dout1_422) AT=520.025n

.meas tran vdout1_423ck1030 FIND v(dout1_423) AT=520.025n

.meas tran vdout1_424ck1030 FIND v(dout1_424) AT=520.025n

.meas tran vdout1_425ck1030 FIND v(dout1_425) AT=520.025n

.meas tran vdout1_426ck1030 FIND v(dout1_426) AT=520.025n

.meas tran vdout1_427ck1030 FIND v(dout1_427) AT=520.025n

.meas tran vdout1_428ck1030 FIND v(dout1_428) AT=520.025n

.meas tran vdout1_429ck1030 FIND v(dout1_429) AT=520.025n

.meas tran vdout1_430ck1030 FIND v(dout1_430) AT=520.025n

.meas tran vdout1_431ck1030 FIND v(dout1_431) AT=520.025n

.meas tran vdout1_432ck1030 FIND v(dout1_432) AT=520.025n

.meas tran vdout1_433ck1030 FIND v(dout1_433) AT=520.025n

.meas tran vdout1_434ck1030 FIND v(dout1_434) AT=520.025n

.meas tran vdout1_435ck1030 FIND v(dout1_435) AT=520.025n

.meas tran vdout1_436ck1030 FIND v(dout1_436) AT=520.025n

.meas tran vdout1_437ck1030 FIND v(dout1_437) AT=520.025n

.meas tran vdout1_438ck1030 FIND v(dout1_438) AT=520.025n

.meas tran vdout1_439ck1030 FIND v(dout1_439) AT=520.025n

.meas tran vdout1_440ck1030 FIND v(dout1_440) AT=520.025n

.meas tran vdout1_441ck1030 FIND v(dout1_441) AT=520.025n

.meas tran vdout1_442ck1030 FIND v(dout1_442) AT=520.025n

.meas tran vdout1_443ck1030 FIND v(dout1_443) AT=520.025n

.meas tran vdout1_444ck1030 FIND v(dout1_444) AT=520.025n

.meas tran vdout1_445ck1030 FIND v(dout1_445) AT=520.025n

.meas tran vdout1_446ck1030 FIND v(dout1_446) AT=520.025n

.meas tran vdout1_447ck1030 FIND v(dout1_447) AT=520.025n

.meas tran vdout1_448ck1030 FIND v(dout1_448) AT=520.025n

.meas tran vdout1_449ck1030 FIND v(dout1_449) AT=520.025n

.meas tran vdout1_450ck1030 FIND v(dout1_450) AT=520.025n

.meas tran vdout1_451ck1030 FIND v(dout1_451) AT=520.025n

.meas tran vdout1_452ck1030 FIND v(dout1_452) AT=520.025n

.meas tran vdout1_453ck1030 FIND v(dout1_453) AT=520.025n

.meas tran vdout1_454ck1030 FIND v(dout1_454) AT=520.025n

.meas tran vdout1_455ck1030 FIND v(dout1_455) AT=520.025n

.meas tran vdout1_456ck1030 FIND v(dout1_456) AT=520.025n

.meas tran vdout1_457ck1030 FIND v(dout1_457) AT=520.025n

.meas tran vdout1_458ck1030 FIND v(dout1_458) AT=520.025n

.meas tran vdout1_459ck1030 FIND v(dout1_459) AT=520.025n

.meas tran vdout1_460ck1030 FIND v(dout1_460) AT=520.025n

.meas tran vdout1_461ck1030 FIND v(dout1_461) AT=520.025n

.meas tran vdout1_462ck1030 FIND v(dout1_462) AT=520.025n

.meas tran vdout1_463ck1030 FIND v(dout1_463) AT=520.025n

.meas tran vdout1_464ck1030 FIND v(dout1_464) AT=520.025n

.meas tran vdout1_465ck1030 FIND v(dout1_465) AT=520.025n

.meas tran vdout1_466ck1030 FIND v(dout1_466) AT=520.025n

.meas tran vdout1_467ck1030 FIND v(dout1_467) AT=520.025n

.meas tran vdout1_468ck1030 FIND v(dout1_468) AT=520.025n

.meas tran vdout1_469ck1030 FIND v(dout1_469) AT=520.025n

.meas tran vdout1_470ck1030 FIND v(dout1_470) AT=520.025n

.meas tran vdout1_471ck1030 FIND v(dout1_471) AT=520.025n

.meas tran vdout1_472ck1030 FIND v(dout1_472) AT=520.025n

.meas tran vdout1_473ck1030 FIND v(dout1_473) AT=520.025n

.meas tran vdout1_474ck1030 FIND v(dout1_474) AT=520.025n

.meas tran vdout1_475ck1030 FIND v(dout1_475) AT=520.025n

.meas tran vdout1_476ck1030 FIND v(dout1_476) AT=520.025n

.meas tran vdout1_477ck1030 FIND v(dout1_477) AT=520.025n

.meas tran vdout1_478ck1030 FIND v(dout1_478) AT=520.025n

.meas tran vdout1_479ck1030 FIND v(dout1_479) AT=520.025n

.meas tran vdout1_480ck1030 FIND v(dout1_480) AT=520.025n

.meas tran vdout1_481ck1030 FIND v(dout1_481) AT=520.025n

.meas tran vdout1_482ck1030 FIND v(dout1_482) AT=520.025n

.meas tran vdout1_483ck1030 FIND v(dout1_483) AT=520.025n

.meas tran vdout1_484ck1030 FIND v(dout1_484) AT=520.025n

.meas tran vdout1_485ck1030 FIND v(dout1_485) AT=520.025n

.meas tran vdout1_486ck1030 FIND v(dout1_486) AT=520.025n

.meas tran vdout1_487ck1030 FIND v(dout1_487) AT=520.025n

.meas tran vdout1_488ck1030 FIND v(dout1_488) AT=520.025n

.meas tran vdout1_489ck1030 FIND v(dout1_489) AT=520.025n

.meas tran vdout1_490ck1030 FIND v(dout1_490) AT=520.025n

.meas tran vdout1_491ck1030 FIND v(dout1_491) AT=520.025n

.meas tran vdout1_492ck1030 FIND v(dout1_492) AT=520.025n

.meas tran vdout1_493ck1030 FIND v(dout1_493) AT=520.025n

.meas tran vdout1_494ck1030 FIND v(dout1_494) AT=520.025n

.meas tran vdout1_495ck1030 FIND v(dout1_495) AT=520.025n

.meas tran vdout1_496ck1030 FIND v(dout1_496) AT=520.025n

.meas tran vdout1_497ck1030 FIND v(dout1_497) AT=520.025n

.meas tran vdout1_498ck1030 FIND v(dout1_498) AT=520.025n

.meas tran vdout1_499ck1030 FIND v(dout1_499) AT=520.025n

.meas tran vdout1_500ck1030 FIND v(dout1_500) AT=520.025n

.meas tran vdout1_501ck1030 FIND v(dout1_501) AT=520.025n

.meas tran vdout1_502ck1030 FIND v(dout1_502) AT=520.025n

.meas tran vdout1_503ck1030 FIND v(dout1_503) AT=520.025n

.meas tran vdout1_504ck1030 FIND v(dout1_504) AT=520.025n

.meas tran vdout1_505ck1030 FIND v(dout1_505) AT=520.025n

.meas tran vdout1_506ck1030 FIND v(dout1_506) AT=520.025n

.meas tran vdout1_507ck1030 FIND v(dout1_507) AT=520.025n

.meas tran vdout1_508ck1030 FIND v(dout1_508) AT=520.025n

.meas tran vdout1_509ck1030 FIND v(dout1_509) AT=520.025n

.meas tran vdout1_510ck1030 FIND v(dout1_510) AT=520.025n

.meas tran vdout1_511ck1030 FIND v(dout1_511) AT=520.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_32ck1050 FIND v(dout1_32) AT=530.025n

.meas tran vdout1_33ck1050 FIND v(dout1_33) AT=530.025n

.meas tran vdout1_34ck1050 FIND v(dout1_34) AT=530.025n

.meas tran vdout1_35ck1050 FIND v(dout1_35) AT=530.025n

.meas tran vdout1_36ck1050 FIND v(dout1_36) AT=530.025n

.meas tran vdout1_37ck1050 FIND v(dout1_37) AT=530.025n

.meas tran vdout1_38ck1050 FIND v(dout1_38) AT=530.025n

.meas tran vdout1_39ck1050 FIND v(dout1_39) AT=530.025n

.meas tran vdout1_40ck1050 FIND v(dout1_40) AT=530.025n

.meas tran vdout1_41ck1050 FIND v(dout1_41) AT=530.025n

.meas tran vdout1_42ck1050 FIND v(dout1_42) AT=530.025n

.meas tran vdout1_43ck1050 FIND v(dout1_43) AT=530.025n

.meas tran vdout1_44ck1050 FIND v(dout1_44) AT=530.025n

.meas tran vdout1_45ck1050 FIND v(dout1_45) AT=530.025n

.meas tran vdout1_46ck1050 FIND v(dout1_46) AT=530.025n

.meas tran vdout1_47ck1050 FIND v(dout1_47) AT=530.025n

.meas tran vdout1_48ck1050 FIND v(dout1_48) AT=530.025n

.meas tran vdout1_49ck1050 FIND v(dout1_49) AT=530.025n

.meas tran vdout1_50ck1050 FIND v(dout1_50) AT=530.025n

.meas tran vdout1_51ck1050 FIND v(dout1_51) AT=530.025n

.meas tran vdout1_52ck1050 FIND v(dout1_52) AT=530.025n

.meas tran vdout1_53ck1050 FIND v(dout1_53) AT=530.025n

.meas tran vdout1_54ck1050 FIND v(dout1_54) AT=530.025n

.meas tran vdout1_55ck1050 FIND v(dout1_55) AT=530.025n

.meas tran vdout1_56ck1050 FIND v(dout1_56) AT=530.025n

.meas tran vdout1_57ck1050 FIND v(dout1_57) AT=530.025n

.meas tran vdout1_58ck1050 FIND v(dout1_58) AT=530.025n

.meas tran vdout1_59ck1050 FIND v(dout1_59) AT=530.025n

.meas tran vdout1_60ck1050 FIND v(dout1_60) AT=530.025n

.meas tran vdout1_61ck1050 FIND v(dout1_61) AT=530.025n

.meas tran vdout1_62ck1050 FIND v(dout1_62) AT=530.025n

.meas tran vdout1_63ck1050 FIND v(dout1_63) AT=530.025n

.meas tran vdout1_64ck1050 FIND v(dout1_64) AT=530.025n

.meas tran vdout1_65ck1050 FIND v(dout1_65) AT=530.025n

.meas tran vdout1_66ck1050 FIND v(dout1_66) AT=530.025n

.meas tran vdout1_67ck1050 FIND v(dout1_67) AT=530.025n

.meas tran vdout1_68ck1050 FIND v(dout1_68) AT=530.025n

.meas tran vdout1_69ck1050 FIND v(dout1_69) AT=530.025n

.meas tran vdout1_70ck1050 FIND v(dout1_70) AT=530.025n

.meas tran vdout1_71ck1050 FIND v(dout1_71) AT=530.025n

.meas tran vdout1_72ck1050 FIND v(dout1_72) AT=530.025n

.meas tran vdout1_73ck1050 FIND v(dout1_73) AT=530.025n

.meas tran vdout1_74ck1050 FIND v(dout1_74) AT=530.025n

.meas tran vdout1_75ck1050 FIND v(dout1_75) AT=530.025n

.meas tran vdout1_76ck1050 FIND v(dout1_76) AT=530.025n

.meas tran vdout1_77ck1050 FIND v(dout1_77) AT=530.025n

.meas tran vdout1_78ck1050 FIND v(dout1_78) AT=530.025n

.meas tran vdout1_79ck1050 FIND v(dout1_79) AT=530.025n

.meas tran vdout1_80ck1050 FIND v(dout1_80) AT=530.025n

.meas tran vdout1_81ck1050 FIND v(dout1_81) AT=530.025n

.meas tran vdout1_82ck1050 FIND v(dout1_82) AT=530.025n

.meas tran vdout1_83ck1050 FIND v(dout1_83) AT=530.025n

.meas tran vdout1_84ck1050 FIND v(dout1_84) AT=530.025n

.meas tran vdout1_85ck1050 FIND v(dout1_85) AT=530.025n

.meas tran vdout1_86ck1050 FIND v(dout1_86) AT=530.025n

.meas tran vdout1_87ck1050 FIND v(dout1_87) AT=530.025n

.meas tran vdout1_88ck1050 FIND v(dout1_88) AT=530.025n

.meas tran vdout1_89ck1050 FIND v(dout1_89) AT=530.025n

.meas tran vdout1_90ck1050 FIND v(dout1_90) AT=530.025n

.meas tran vdout1_91ck1050 FIND v(dout1_91) AT=530.025n

.meas tran vdout1_92ck1050 FIND v(dout1_92) AT=530.025n

.meas tran vdout1_93ck1050 FIND v(dout1_93) AT=530.025n

.meas tran vdout1_94ck1050 FIND v(dout1_94) AT=530.025n

.meas tran vdout1_95ck1050 FIND v(dout1_95) AT=530.025n

.meas tran vdout1_96ck1050 FIND v(dout1_96) AT=530.025n

.meas tran vdout1_97ck1050 FIND v(dout1_97) AT=530.025n

.meas tran vdout1_98ck1050 FIND v(dout1_98) AT=530.025n

.meas tran vdout1_99ck1050 FIND v(dout1_99) AT=530.025n

.meas tran vdout1_100ck1050 FIND v(dout1_100) AT=530.025n

.meas tran vdout1_101ck1050 FIND v(dout1_101) AT=530.025n

.meas tran vdout1_102ck1050 FIND v(dout1_102) AT=530.025n

.meas tran vdout1_103ck1050 FIND v(dout1_103) AT=530.025n

.meas tran vdout1_104ck1050 FIND v(dout1_104) AT=530.025n

.meas tran vdout1_105ck1050 FIND v(dout1_105) AT=530.025n

.meas tran vdout1_106ck1050 FIND v(dout1_106) AT=530.025n

.meas tran vdout1_107ck1050 FIND v(dout1_107) AT=530.025n

.meas tran vdout1_108ck1050 FIND v(dout1_108) AT=530.025n

.meas tran vdout1_109ck1050 FIND v(dout1_109) AT=530.025n

.meas tran vdout1_110ck1050 FIND v(dout1_110) AT=530.025n

.meas tran vdout1_111ck1050 FIND v(dout1_111) AT=530.025n

.meas tran vdout1_112ck1050 FIND v(dout1_112) AT=530.025n

.meas tran vdout1_113ck1050 FIND v(dout1_113) AT=530.025n

.meas tran vdout1_114ck1050 FIND v(dout1_114) AT=530.025n

.meas tran vdout1_115ck1050 FIND v(dout1_115) AT=530.025n

.meas tran vdout1_116ck1050 FIND v(dout1_116) AT=530.025n

.meas tran vdout1_117ck1050 FIND v(dout1_117) AT=530.025n

.meas tran vdout1_118ck1050 FIND v(dout1_118) AT=530.025n

.meas tran vdout1_119ck1050 FIND v(dout1_119) AT=530.025n

.meas tran vdout1_120ck1050 FIND v(dout1_120) AT=530.025n

.meas tran vdout1_121ck1050 FIND v(dout1_121) AT=530.025n

.meas tran vdout1_122ck1050 FIND v(dout1_122) AT=530.025n

.meas tran vdout1_123ck1050 FIND v(dout1_123) AT=530.025n

.meas tran vdout1_124ck1050 FIND v(dout1_124) AT=530.025n

.meas tran vdout1_125ck1050 FIND v(dout1_125) AT=530.025n

.meas tran vdout1_126ck1050 FIND v(dout1_126) AT=530.025n

.meas tran vdout1_127ck1050 FIND v(dout1_127) AT=530.025n

.meas tran vdout1_128ck1050 FIND v(dout1_128) AT=530.025n

.meas tran vdout1_129ck1050 FIND v(dout1_129) AT=530.025n

.meas tran vdout1_130ck1050 FIND v(dout1_130) AT=530.025n

.meas tran vdout1_131ck1050 FIND v(dout1_131) AT=530.025n

.meas tran vdout1_132ck1050 FIND v(dout1_132) AT=530.025n

.meas tran vdout1_133ck1050 FIND v(dout1_133) AT=530.025n

.meas tran vdout1_134ck1050 FIND v(dout1_134) AT=530.025n

.meas tran vdout1_135ck1050 FIND v(dout1_135) AT=530.025n

.meas tran vdout1_136ck1050 FIND v(dout1_136) AT=530.025n

.meas tran vdout1_137ck1050 FIND v(dout1_137) AT=530.025n

.meas tran vdout1_138ck1050 FIND v(dout1_138) AT=530.025n

.meas tran vdout1_139ck1050 FIND v(dout1_139) AT=530.025n

.meas tran vdout1_140ck1050 FIND v(dout1_140) AT=530.025n

.meas tran vdout1_141ck1050 FIND v(dout1_141) AT=530.025n

.meas tran vdout1_142ck1050 FIND v(dout1_142) AT=530.025n

.meas tran vdout1_143ck1050 FIND v(dout1_143) AT=530.025n

.meas tran vdout1_144ck1050 FIND v(dout1_144) AT=530.025n

.meas tran vdout1_145ck1050 FIND v(dout1_145) AT=530.025n

.meas tran vdout1_146ck1050 FIND v(dout1_146) AT=530.025n

.meas tran vdout1_147ck1050 FIND v(dout1_147) AT=530.025n

.meas tran vdout1_148ck1050 FIND v(dout1_148) AT=530.025n

.meas tran vdout1_149ck1050 FIND v(dout1_149) AT=530.025n

.meas tran vdout1_150ck1050 FIND v(dout1_150) AT=530.025n

.meas tran vdout1_151ck1050 FIND v(dout1_151) AT=530.025n

.meas tran vdout1_152ck1050 FIND v(dout1_152) AT=530.025n

.meas tran vdout1_153ck1050 FIND v(dout1_153) AT=530.025n

.meas tran vdout1_154ck1050 FIND v(dout1_154) AT=530.025n

.meas tran vdout1_155ck1050 FIND v(dout1_155) AT=530.025n

.meas tran vdout1_156ck1050 FIND v(dout1_156) AT=530.025n

.meas tran vdout1_157ck1050 FIND v(dout1_157) AT=530.025n

.meas tran vdout1_158ck1050 FIND v(dout1_158) AT=530.025n

.meas tran vdout1_159ck1050 FIND v(dout1_159) AT=530.025n

.meas tran vdout1_160ck1050 FIND v(dout1_160) AT=530.025n

.meas tran vdout1_161ck1050 FIND v(dout1_161) AT=530.025n

.meas tran vdout1_162ck1050 FIND v(dout1_162) AT=530.025n

.meas tran vdout1_163ck1050 FIND v(dout1_163) AT=530.025n

.meas tran vdout1_164ck1050 FIND v(dout1_164) AT=530.025n

.meas tran vdout1_165ck1050 FIND v(dout1_165) AT=530.025n

.meas tran vdout1_166ck1050 FIND v(dout1_166) AT=530.025n

.meas tran vdout1_167ck1050 FIND v(dout1_167) AT=530.025n

.meas tran vdout1_168ck1050 FIND v(dout1_168) AT=530.025n

.meas tran vdout1_169ck1050 FIND v(dout1_169) AT=530.025n

.meas tran vdout1_170ck1050 FIND v(dout1_170) AT=530.025n

.meas tran vdout1_171ck1050 FIND v(dout1_171) AT=530.025n

.meas tran vdout1_172ck1050 FIND v(dout1_172) AT=530.025n

.meas tran vdout1_173ck1050 FIND v(dout1_173) AT=530.025n

.meas tran vdout1_174ck1050 FIND v(dout1_174) AT=530.025n

.meas tran vdout1_175ck1050 FIND v(dout1_175) AT=530.025n

.meas tran vdout1_176ck1050 FIND v(dout1_176) AT=530.025n

.meas tran vdout1_177ck1050 FIND v(dout1_177) AT=530.025n

.meas tran vdout1_178ck1050 FIND v(dout1_178) AT=530.025n

.meas tran vdout1_179ck1050 FIND v(dout1_179) AT=530.025n

.meas tran vdout1_180ck1050 FIND v(dout1_180) AT=530.025n

.meas tran vdout1_181ck1050 FIND v(dout1_181) AT=530.025n

.meas tran vdout1_182ck1050 FIND v(dout1_182) AT=530.025n

.meas tran vdout1_183ck1050 FIND v(dout1_183) AT=530.025n

.meas tran vdout1_184ck1050 FIND v(dout1_184) AT=530.025n

.meas tran vdout1_185ck1050 FIND v(dout1_185) AT=530.025n

.meas tran vdout1_186ck1050 FIND v(dout1_186) AT=530.025n

.meas tran vdout1_187ck1050 FIND v(dout1_187) AT=530.025n

.meas tran vdout1_188ck1050 FIND v(dout1_188) AT=530.025n

.meas tran vdout1_189ck1050 FIND v(dout1_189) AT=530.025n

.meas tran vdout1_190ck1050 FIND v(dout1_190) AT=530.025n

.meas tran vdout1_191ck1050 FIND v(dout1_191) AT=530.025n

.meas tran vdout1_192ck1050 FIND v(dout1_192) AT=530.025n

.meas tran vdout1_193ck1050 FIND v(dout1_193) AT=530.025n

.meas tran vdout1_194ck1050 FIND v(dout1_194) AT=530.025n

.meas tran vdout1_195ck1050 FIND v(dout1_195) AT=530.025n

.meas tran vdout1_196ck1050 FIND v(dout1_196) AT=530.025n

.meas tran vdout1_197ck1050 FIND v(dout1_197) AT=530.025n

.meas tran vdout1_198ck1050 FIND v(dout1_198) AT=530.025n

.meas tran vdout1_199ck1050 FIND v(dout1_199) AT=530.025n

.meas tran vdout1_200ck1050 FIND v(dout1_200) AT=530.025n

.meas tran vdout1_201ck1050 FIND v(dout1_201) AT=530.025n

.meas tran vdout1_202ck1050 FIND v(dout1_202) AT=530.025n

.meas tran vdout1_203ck1050 FIND v(dout1_203) AT=530.025n

.meas tran vdout1_204ck1050 FIND v(dout1_204) AT=530.025n

.meas tran vdout1_205ck1050 FIND v(dout1_205) AT=530.025n

.meas tran vdout1_206ck1050 FIND v(dout1_206) AT=530.025n

.meas tran vdout1_207ck1050 FIND v(dout1_207) AT=530.025n

.meas tran vdout1_208ck1050 FIND v(dout1_208) AT=530.025n

.meas tran vdout1_209ck1050 FIND v(dout1_209) AT=530.025n

.meas tran vdout1_210ck1050 FIND v(dout1_210) AT=530.025n

.meas tran vdout1_211ck1050 FIND v(dout1_211) AT=530.025n

.meas tran vdout1_212ck1050 FIND v(dout1_212) AT=530.025n

.meas tran vdout1_213ck1050 FIND v(dout1_213) AT=530.025n

.meas tran vdout1_214ck1050 FIND v(dout1_214) AT=530.025n

.meas tran vdout1_215ck1050 FIND v(dout1_215) AT=530.025n

.meas tran vdout1_216ck1050 FIND v(dout1_216) AT=530.025n

.meas tran vdout1_217ck1050 FIND v(dout1_217) AT=530.025n

.meas tran vdout1_218ck1050 FIND v(dout1_218) AT=530.025n

.meas tran vdout1_219ck1050 FIND v(dout1_219) AT=530.025n

.meas tran vdout1_220ck1050 FIND v(dout1_220) AT=530.025n

.meas tran vdout1_221ck1050 FIND v(dout1_221) AT=530.025n

.meas tran vdout1_222ck1050 FIND v(dout1_222) AT=530.025n

.meas tran vdout1_223ck1050 FIND v(dout1_223) AT=530.025n

.meas tran vdout1_224ck1050 FIND v(dout1_224) AT=530.025n

.meas tran vdout1_225ck1050 FIND v(dout1_225) AT=530.025n

.meas tran vdout1_226ck1050 FIND v(dout1_226) AT=530.025n

.meas tran vdout1_227ck1050 FIND v(dout1_227) AT=530.025n

.meas tran vdout1_228ck1050 FIND v(dout1_228) AT=530.025n

.meas tran vdout1_229ck1050 FIND v(dout1_229) AT=530.025n

.meas tran vdout1_230ck1050 FIND v(dout1_230) AT=530.025n

.meas tran vdout1_231ck1050 FIND v(dout1_231) AT=530.025n

.meas tran vdout1_232ck1050 FIND v(dout1_232) AT=530.025n

.meas tran vdout1_233ck1050 FIND v(dout1_233) AT=530.025n

.meas tran vdout1_234ck1050 FIND v(dout1_234) AT=530.025n

.meas tran vdout1_235ck1050 FIND v(dout1_235) AT=530.025n

.meas tran vdout1_236ck1050 FIND v(dout1_236) AT=530.025n

.meas tran vdout1_237ck1050 FIND v(dout1_237) AT=530.025n

.meas tran vdout1_238ck1050 FIND v(dout1_238) AT=530.025n

.meas tran vdout1_239ck1050 FIND v(dout1_239) AT=530.025n

.meas tran vdout1_240ck1050 FIND v(dout1_240) AT=530.025n

.meas tran vdout1_241ck1050 FIND v(dout1_241) AT=530.025n

.meas tran vdout1_242ck1050 FIND v(dout1_242) AT=530.025n

.meas tran vdout1_243ck1050 FIND v(dout1_243) AT=530.025n

.meas tran vdout1_244ck1050 FIND v(dout1_244) AT=530.025n

.meas tran vdout1_245ck1050 FIND v(dout1_245) AT=530.025n

.meas tran vdout1_246ck1050 FIND v(dout1_246) AT=530.025n

.meas tran vdout1_247ck1050 FIND v(dout1_247) AT=530.025n

.meas tran vdout1_248ck1050 FIND v(dout1_248) AT=530.025n

.meas tran vdout1_249ck1050 FIND v(dout1_249) AT=530.025n

.meas tran vdout1_250ck1050 FIND v(dout1_250) AT=530.025n

.meas tran vdout1_251ck1050 FIND v(dout1_251) AT=530.025n

.meas tran vdout1_252ck1050 FIND v(dout1_252) AT=530.025n

.meas tran vdout1_253ck1050 FIND v(dout1_253) AT=530.025n

.meas tran vdout1_254ck1050 FIND v(dout1_254) AT=530.025n

.meas tran vdout1_255ck1050 FIND v(dout1_255) AT=530.025n

.meas tran vdout1_256ck1050 FIND v(dout1_256) AT=530.025n

.meas tran vdout1_257ck1050 FIND v(dout1_257) AT=530.025n

.meas tran vdout1_258ck1050 FIND v(dout1_258) AT=530.025n

.meas tran vdout1_259ck1050 FIND v(dout1_259) AT=530.025n

.meas tran vdout1_260ck1050 FIND v(dout1_260) AT=530.025n

.meas tran vdout1_261ck1050 FIND v(dout1_261) AT=530.025n

.meas tran vdout1_262ck1050 FIND v(dout1_262) AT=530.025n

.meas tran vdout1_263ck1050 FIND v(dout1_263) AT=530.025n

.meas tran vdout1_264ck1050 FIND v(dout1_264) AT=530.025n

.meas tran vdout1_265ck1050 FIND v(dout1_265) AT=530.025n

.meas tran vdout1_266ck1050 FIND v(dout1_266) AT=530.025n

.meas tran vdout1_267ck1050 FIND v(dout1_267) AT=530.025n

.meas tran vdout1_268ck1050 FIND v(dout1_268) AT=530.025n

.meas tran vdout1_269ck1050 FIND v(dout1_269) AT=530.025n

.meas tran vdout1_270ck1050 FIND v(dout1_270) AT=530.025n

.meas tran vdout1_271ck1050 FIND v(dout1_271) AT=530.025n

.meas tran vdout1_272ck1050 FIND v(dout1_272) AT=530.025n

.meas tran vdout1_273ck1050 FIND v(dout1_273) AT=530.025n

.meas tran vdout1_274ck1050 FIND v(dout1_274) AT=530.025n

.meas tran vdout1_275ck1050 FIND v(dout1_275) AT=530.025n

.meas tran vdout1_276ck1050 FIND v(dout1_276) AT=530.025n

.meas tran vdout1_277ck1050 FIND v(dout1_277) AT=530.025n

.meas tran vdout1_278ck1050 FIND v(dout1_278) AT=530.025n

.meas tran vdout1_279ck1050 FIND v(dout1_279) AT=530.025n

.meas tran vdout1_280ck1050 FIND v(dout1_280) AT=530.025n

.meas tran vdout1_281ck1050 FIND v(dout1_281) AT=530.025n

.meas tran vdout1_282ck1050 FIND v(dout1_282) AT=530.025n

.meas tran vdout1_283ck1050 FIND v(dout1_283) AT=530.025n

.meas tran vdout1_284ck1050 FIND v(dout1_284) AT=530.025n

.meas tran vdout1_285ck1050 FIND v(dout1_285) AT=530.025n

.meas tran vdout1_286ck1050 FIND v(dout1_286) AT=530.025n

.meas tran vdout1_287ck1050 FIND v(dout1_287) AT=530.025n

.meas tran vdout1_288ck1050 FIND v(dout1_288) AT=530.025n

.meas tran vdout1_289ck1050 FIND v(dout1_289) AT=530.025n

.meas tran vdout1_290ck1050 FIND v(dout1_290) AT=530.025n

.meas tran vdout1_291ck1050 FIND v(dout1_291) AT=530.025n

.meas tran vdout1_292ck1050 FIND v(dout1_292) AT=530.025n

.meas tran vdout1_293ck1050 FIND v(dout1_293) AT=530.025n

.meas tran vdout1_294ck1050 FIND v(dout1_294) AT=530.025n

.meas tran vdout1_295ck1050 FIND v(dout1_295) AT=530.025n

.meas tran vdout1_296ck1050 FIND v(dout1_296) AT=530.025n

.meas tran vdout1_297ck1050 FIND v(dout1_297) AT=530.025n

.meas tran vdout1_298ck1050 FIND v(dout1_298) AT=530.025n

.meas tran vdout1_299ck1050 FIND v(dout1_299) AT=530.025n

.meas tran vdout1_300ck1050 FIND v(dout1_300) AT=530.025n

.meas tran vdout1_301ck1050 FIND v(dout1_301) AT=530.025n

.meas tran vdout1_302ck1050 FIND v(dout1_302) AT=530.025n

.meas tran vdout1_303ck1050 FIND v(dout1_303) AT=530.025n

.meas tran vdout1_304ck1050 FIND v(dout1_304) AT=530.025n

.meas tran vdout1_305ck1050 FIND v(dout1_305) AT=530.025n

.meas tran vdout1_306ck1050 FIND v(dout1_306) AT=530.025n

.meas tran vdout1_307ck1050 FIND v(dout1_307) AT=530.025n

.meas tran vdout1_308ck1050 FIND v(dout1_308) AT=530.025n

.meas tran vdout1_309ck1050 FIND v(dout1_309) AT=530.025n

.meas tran vdout1_310ck1050 FIND v(dout1_310) AT=530.025n

.meas tran vdout1_311ck1050 FIND v(dout1_311) AT=530.025n

.meas tran vdout1_312ck1050 FIND v(dout1_312) AT=530.025n

.meas tran vdout1_313ck1050 FIND v(dout1_313) AT=530.025n

.meas tran vdout1_314ck1050 FIND v(dout1_314) AT=530.025n

.meas tran vdout1_315ck1050 FIND v(dout1_315) AT=530.025n

.meas tran vdout1_316ck1050 FIND v(dout1_316) AT=530.025n

.meas tran vdout1_317ck1050 FIND v(dout1_317) AT=530.025n

.meas tran vdout1_318ck1050 FIND v(dout1_318) AT=530.025n

.meas tran vdout1_319ck1050 FIND v(dout1_319) AT=530.025n

.meas tran vdout1_320ck1050 FIND v(dout1_320) AT=530.025n

.meas tran vdout1_321ck1050 FIND v(dout1_321) AT=530.025n

.meas tran vdout1_322ck1050 FIND v(dout1_322) AT=530.025n

.meas tran vdout1_323ck1050 FIND v(dout1_323) AT=530.025n

.meas tran vdout1_324ck1050 FIND v(dout1_324) AT=530.025n

.meas tran vdout1_325ck1050 FIND v(dout1_325) AT=530.025n

.meas tran vdout1_326ck1050 FIND v(dout1_326) AT=530.025n

.meas tran vdout1_327ck1050 FIND v(dout1_327) AT=530.025n

.meas tran vdout1_328ck1050 FIND v(dout1_328) AT=530.025n

.meas tran vdout1_329ck1050 FIND v(dout1_329) AT=530.025n

.meas tran vdout1_330ck1050 FIND v(dout1_330) AT=530.025n

.meas tran vdout1_331ck1050 FIND v(dout1_331) AT=530.025n

.meas tran vdout1_332ck1050 FIND v(dout1_332) AT=530.025n

.meas tran vdout1_333ck1050 FIND v(dout1_333) AT=530.025n

.meas tran vdout1_334ck1050 FIND v(dout1_334) AT=530.025n

.meas tran vdout1_335ck1050 FIND v(dout1_335) AT=530.025n

.meas tran vdout1_336ck1050 FIND v(dout1_336) AT=530.025n

.meas tran vdout1_337ck1050 FIND v(dout1_337) AT=530.025n

.meas tran vdout1_338ck1050 FIND v(dout1_338) AT=530.025n

.meas tran vdout1_339ck1050 FIND v(dout1_339) AT=530.025n

.meas tran vdout1_340ck1050 FIND v(dout1_340) AT=530.025n

.meas tran vdout1_341ck1050 FIND v(dout1_341) AT=530.025n

.meas tran vdout1_342ck1050 FIND v(dout1_342) AT=530.025n

.meas tran vdout1_343ck1050 FIND v(dout1_343) AT=530.025n

.meas tran vdout1_344ck1050 FIND v(dout1_344) AT=530.025n

.meas tran vdout1_345ck1050 FIND v(dout1_345) AT=530.025n

.meas tran vdout1_346ck1050 FIND v(dout1_346) AT=530.025n

.meas tran vdout1_347ck1050 FIND v(dout1_347) AT=530.025n

.meas tran vdout1_348ck1050 FIND v(dout1_348) AT=530.025n

.meas tran vdout1_349ck1050 FIND v(dout1_349) AT=530.025n

.meas tran vdout1_350ck1050 FIND v(dout1_350) AT=530.025n

.meas tran vdout1_351ck1050 FIND v(dout1_351) AT=530.025n

.meas tran vdout1_352ck1050 FIND v(dout1_352) AT=530.025n

.meas tran vdout1_353ck1050 FIND v(dout1_353) AT=530.025n

.meas tran vdout1_354ck1050 FIND v(dout1_354) AT=530.025n

.meas tran vdout1_355ck1050 FIND v(dout1_355) AT=530.025n

.meas tran vdout1_356ck1050 FIND v(dout1_356) AT=530.025n

.meas tran vdout1_357ck1050 FIND v(dout1_357) AT=530.025n

.meas tran vdout1_358ck1050 FIND v(dout1_358) AT=530.025n

.meas tran vdout1_359ck1050 FIND v(dout1_359) AT=530.025n

.meas tran vdout1_360ck1050 FIND v(dout1_360) AT=530.025n

.meas tran vdout1_361ck1050 FIND v(dout1_361) AT=530.025n

.meas tran vdout1_362ck1050 FIND v(dout1_362) AT=530.025n

.meas tran vdout1_363ck1050 FIND v(dout1_363) AT=530.025n

.meas tran vdout1_364ck1050 FIND v(dout1_364) AT=530.025n

.meas tran vdout1_365ck1050 FIND v(dout1_365) AT=530.025n

.meas tran vdout1_366ck1050 FIND v(dout1_366) AT=530.025n

.meas tran vdout1_367ck1050 FIND v(dout1_367) AT=530.025n

.meas tran vdout1_368ck1050 FIND v(dout1_368) AT=530.025n

.meas tran vdout1_369ck1050 FIND v(dout1_369) AT=530.025n

.meas tran vdout1_370ck1050 FIND v(dout1_370) AT=530.025n

.meas tran vdout1_371ck1050 FIND v(dout1_371) AT=530.025n

.meas tran vdout1_372ck1050 FIND v(dout1_372) AT=530.025n

.meas tran vdout1_373ck1050 FIND v(dout1_373) AT=530.025n

.meas tran vdout1_374ck1050 FIND v(dout1_374) AT=530.025n

.meas tran vdout1_375ck1050 FIND v(dout1_375) AT=530.025n

.meas tran vdout1_376ck1050 FIND v(dout1_376) AT=530.025n

.meas tran vdout1_377ck1050 FIND v(dout1_377) AT=530.025n

.meas tran vdout1_378ck1050 FIND v(dout1_378) AT=530.025n

.meas tran vdout1_379ck1050 FIND v(dout1_379) AT=530.025n

.meas tran vdout1_380ck1050 FIND v(dout1_380) AT=530.025n

.meas tran vdout1_381ck1050 FIND v(dout1_381) AT=530.025n

.meas tran vdout1_382ck1050 FIND v(dout1_382) AT=530.025n

.meas tran vdout1_383ck1050 FIND v(dout1_383) AT=530.025n

.meas tran vdout1_384ck1050 FIND v(dout1_384) AT=530.025n

.meas tran vdout1_385ck1050 FIND v(dout1_385) AT=530.025n

.meas tran vdout1_386ck1050 FIND v(dout1_386) AT=530.025n

.meas tran vdout1_387ck1050 FIND v(dout1_387) AT=530.025n

.meas tran vdout1_388ck1050 FIND v(dout1_388) AT=530.025n

.meas tran vdout1_389ck1050 FIND v(dout1_389) AT=530.025n

.meas tran vdout1_390ck1050 FIND v(dout1_390) AT=530.025n

.meas tran vdout1_391ck1050 FIND v(dout1_391) AT=530.025n

.meas tran vdout1_392ck1050 FIND v(dout1_392) AT=530.025n

.meas tran vdout1_393ck1050 FIND v(dout1_393) AT=530.025n

.meas tran vdout1_394ck1050 FIND v(dout1_394) AT=530.025n

.meas tran vdout1_395ck1050 FIND v(dout1_395) AT=530.025n

.meas tran vdout1_396ck1050 FIND v(dout1_396) AT=530.025n

.meas tran vdout1_397ck1050 FIND v(dout1_397) AT=530.025n

.meas tran vdout1_398ck1050 FIND v(dout1_398) AT=530.025n

.meas tran vdout1_399ck1050 FIND v(dout1_399) AT=530.025n

.meas tran vdout1_400ck1050 FIND v(dout1_400) AT=530.025n

.meas tran vdout1_401ck1050 FIND v(dout1_401) AT=530.025n

.meas tran vdout1_402ck1050 FIND v(dout1_402) AT=530.025n

.meas tran vdout1_403ck1050 FIND v(dout1_403) AT=530.025n

.meas tran vdout1_404ck1050 FIND v(dout1_404) AT=530.025n

.meas tran vdout1_405ck1050 FIND v(dout1_405) AT=530.025n

.meas tran vdout1_406ck1050 FIND v(dout1_406) AT=530.025n

.meas tran vdout1_407ck1050 FIND v(dout1_407) AT=530.025n

.meas tran vdout1_408ck1050 FIND v(dout1_408) AT=530.025n

.meas tran vdout1_409ck1050 FIND v(dout1_409) AT=530.025n

.meas tran vdout1_410ck1050 FIND v(dout1_410) AT=530.025n

.meas tran vdout1_411ck1050 FIND v(dout1_411) AT=530.025n

.meas tran vdout1_412ck1050 FIND v(dout1_412) AT=530.025n

.meas tran vdout1_413ck1050 FIND v(dout1_413) AT=530.025n

.meas tran vdout1_414ck1050 FIND v(dout1_414) AT=530.025n

.meas tran vdout1_415ck1050 FIND v(dout1_415) AT=530.025n

.meas tran vdout1_416ck1050 FIND v(dout1_416) AT=530.025n

.meas tran vdout1_417ck1050 FIND v(dout1_417) AT=530.025n

.meas tran vdout1_418ck1050 FIND v(dout1_418) AT=530.025n

.meas tran vdout1_419ck1050 FIND v(dout1_419) AT=530.025n

.meas tran vdout1_420ck1050 FIND v(dout1_420) AT=530.025n

.meas tran vdout1_421ck1050 FIND v(dout1_421) AT=530.025n

.meas tran vdout1_422ck1050 FIND v(dout1_422) AT=530.025n

.meas tran vdout1_423ck1050 FIND v(dout1_423) AT=530.025n

.meas tran vdout1_424ck1050 FIND v(dout1_424) AT=530.025n

.meas tran vdout1_425ck1050 FIND v(dout1_425) AT=530.025n

.meas tran vdout1_426ck1050 FIND v(dout1_426) AT=530.025n

.meas tran vdout1_427ck1050 FIND v(dout1_427) AT=530.025n

.meas tran vdout1_428ck1050 FIND v(dout1_428) AT=530.025n

.meas tran vdout1_429ck1050 FIND v(dout1_429) AT=530.025n

.meas tran vdout1_430ck1050 FIND v(dout1_430) AT=530.025n

.meas tran vdout1_431ck1050 FIND v(dout1_431) AT=530.025n

.meas tran vdout1_432ck1050 FIND v(dout1_432) AT=530.025n

.meas tran vdout1_433ck1050 FIND v(dout1_433) AT=530.025n

.meas tran vdout1_434ck1050 FIND v(dout1_434) AT=530.025n

.meas tran vdout1_435ck1050 FIND v(dout1_435) AT=530.025n

.meas tran vdout1_436ck1050 FIND v(dout1_436) AT=530.025n

.meas tran vdout1_437ck1050 FIND v(dout1_437) AT=530.025n

.meas tran vdout1_438ck1050 FIND v(dout1_438) AT=530.025n

.meas tran vdout1_439ck1050 FIND v(dout1_439) AT=530.025n

.meas tran vdout1_440ck1050 FIND v(dout1_440) AT=530.025n

.meas tran vdout1_441ck1050 FIND v(dout1_441) AT=530.025n

.meas tran vdout1_442ck1050 FIND v(dout1_442) AT=530.025n

.meas tran vdout1_443ck1050 FIND v(dout1_443) AT=530.025n

.meas tran vdout1_444ck1050 FIND v(dout1_444) AT=530.025n

.meas tran vdout1_445ck1050 FIND v(dout1_445) AT=530.025n

.meas tran vdout1_446ck1050 FIND v(dout1_446) AT=530.025n

.meas tran vdout1_447ck1050 FIND v(dout1_447) AT=530.025n

.meas tran vdout1_448ck1050 FIND v(dout1_448) AT=530.025n

.meas tran vdout1_449ck1050 FIND v(dout1_449) AT=530.025n

.meas tran vdout1_450ck1050 FIND v(dout1_450) AT=530.025n

.meas tran vdout1_451ck1050 FIND v(dout1_451) AT=530.025n

.meas tran vdout1_452ck1050 FIND v(dout1_452) AT=530.025n

.meas tran vdout1_453ck1050 FIND v(dout1_453) AT=530.025n

.meas tran vdout1_454ck1050 FIND v(dout1_454) AT=530.025n

.meas tran vdout1_455ck1050 FIND v(dout1_455) AT=530.025n

.meas tran vdout1_456ck1050 FIND v(dout1_456) AT=530.025n

.meas tran vdout1_457ck1050 FIND v(dout1_457) AT=530.025n

.meas tran vdout1_458ck1050 FIND v(dout1_458) AT=530.025n

.meas tran vdout1_459ck1050 FIND v(dout1_459) AT=530.025n

.meas tran vdout1_460ck1050 FIND v(dout1_460) AT=530.025n

.meas tran vdout1_461ck1050 FIND v(dout1_461) AT=530.025n

.meas tran vdout1_462ck1050 FIND v(dout1_462) AT=530.025n

.meas tran vdout1_463ck1050 FIND v(dout1_463) AT=530.025n

.meas tran vdout1_464ck1050 FIND v(dout1_464) AT=530.025n

.meas tran vdout1_465ck1050 FIND v(dout1_465) AT=530.025n

.meas tran vdout1_466ck1050 FIND v(dout1_466) AT=530.025n

.meas tran vdout1_467ck1050 FIND v(dout1_467) AT=530.025n

.meas tran vdout1_468ck1050 FIND v(dout1_468) AT=530.025n

.meas tran vdout1_469ck1050 FIND v(dout1_469) AT=530.025n

.meas tran vdout1_470ck1050 FIND v(dout1_470) AT=530.025n

.meas tran vdout1_471ck1050 FIND v(dout1_471) AT=530.025n

.meas tran vdout1_472ck1050 FIND v(dout1_472) AT=530.025n

.meas tran vdout1_473ck1050 FIND v(dout1_473) AT=530.025n

.meas tran vdout1_474ck1050 FIND v(dout1_474) AT=530.025n

.meas tran vdout1_475ck1050 FIND v(dout1_475) AT=530.025n

.meas tran vdout1_476ck1050 FIND v(dout1_476) AT=530.025n

.meas tran vdout1_477ck1050 FIND v(dout1_477) AT=530.025n

.meas tran vdout1_478ck1050 FIND v(dout1_478) AT=530.025n

.meas tran vdout1_479ck1050 FIND v(dout1_479) AT=530.025n

.meas tran vdout1_480ck1050 FIND v(dout1_480) AT=530.025n

.meas tran vdout1_481ck1050 FIND v(dout1_481) AT=530.025n

.meas tran vdout1_482ck1050 FIND v(dout1_482) AT=530.025n

.meas tran vdout1_483ck1050 FIND v(dout1_483) AT=530.025n

.meas tran vdout1_484ck1050 FIND v(dout1_484) AT=530.025n

.meas tran vdout1_485ck1050 FIND v(dout1_485) AT=530.025n

.meas tran vdout1_486ck1050 FIND v(dout1_486) AT=530.025n

.meas tran vdout1_487ck1050 FIND v(dout1_487) AT=530.025n

.meas tran vdout1_488ck1050 FIND v(dout1_488) AT=530.025n

.meas tran vdout1_489ck1050 FIND v(dout1_489) AT=530.025n

.meas tran vdout1_490ck1050 FIND v(dout1_490) AT=530.025n

.meas tran vdout1_491ck1050 FIND v(dout1_491) AT=530.025n

.meas tran vdout1_492ck1050 FIND v(dout1_492) AT=530.025n

.meas tran vdout1_493ck1050 FIND v(dout1_493) AT=530.025n

.meas tran vdout1_494ck1050 FIND v(dout1_494) AT=530.025n

.meas tran vdout1_495ck1050 FIND v(dout1_495) AT=530.025n

.meas tran vdout1_496ck1050 FIND v(dout1_496) AT=530.025n

.meas tran vdout1_497ck1050 FIND v(dout1_497) AT=530.025n

.meas tran vdout1_498ck1050 FIND v(dout1_498) AT=530.025n

.meas tran vdout1_499ck1050 FIND v(dout1_499) AT=530.025n

.meas tran vdout1_500ck1050 FIND v(dout1_500) AT=530.025n

.meas tran vdout1_501ck1050 FIND v(dout1_501) AT=530.025n

.meas tran vdout1_502ck1050 FIND v(dout1_502) AT=530.025n

.meas tran vdout1_503ck1050 FIND v(dout1_503) AT=530.025n

.meas tran vdout1_504ck1050 FIND v(dout1_504) AT=530.025n

.meas tran vdout1_505ck1050 FIND v(dout1_505) AT=530.025n

.meas tran vdout1_506ck1050 FIND v(dout1_506) AT=530.025n

.meas tran vdout1_507ck1050 FIND v(dout1_507) AT=530.025n

.meas tran vdout1_508ck1050 FIND v(dout1_508) AT=530.025n

.meas tran vdout1_509ck1050 FIND v(dout1_509) AT=530.025n

.meas tran vdout1_510ck1050 FIND v(dout1_510) AT=530.025n

.meas tran vdout1_511ck1050 FIND v(dout1_511) AT=530.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_23ck1070 FIND v(dout1_23) AT=540.025n

.meas tran vdout1_24ck1070 FIND v(dout1_24) AT=540.025n

.meas tran vdout1_25ck1070 FIND v(dout1_25) AT=540.025n

.meas tran vdout1_26ck1070 FIND v(dout1_26) AT=540.025n

.meas tran vdout1_27ck1070 FIND v(dout1_27) AT=540.025n

.meas tran vdout1_28ck1070 FIND v(dout1_28) AT=540.025n

.meas tran vdout1_29ck1070 FIND v(dout1_29) AT=540.025n

.meas tran vdout1_30ck1070 FIND v(dout1_30) AT=540.025n

.meas tran vdout1_31ck1070 FIND v(dout1_31) AT=540.025n

.meas tran vdout1_32ck1070 FIND v(dout1_32) AT=540.025n

.meas tran vdout1_33ck1070 FIND v(dout1_33) AT=540.025n

.meas tran vdout1_34ck1070 FIND v(dout1_34) AT=540.025n

.meas tran vdout1_35ck1070 FIND v(dout1_35) AT=540.025n

.meas tran vdout1_36ck1070 FIND v(dout1_36) AT=540.025n

.meas tran vdout1_37ck1070 FIND v(dout1_37) AT=540.025n

.meas tran vdout1_38ck1070 FIND v(dout1_38) AT=540.025n

.meas tran vdout1_39ck1070 FIND v(dout1_39) AT=540.025n

.meas tran vdout1_40ck1070 FIND v(dout1_40) AT=540.025n

.meas tran vdout1_41ck1070 FIND v(dout1_41) AT=540.025n

.meas tran vdout1_42ck1070 FIND v(dout1_42) AT=540.025n

.meas tran vdout1_43ck1070 FIND v(dout1_43) AT=540.025n

.meas tran vdout1_44ck1070 FIND v(dout1_44) AT=540.025n

.meas tran vdout1_45ck1070 FIND v(dout1_45) AT=540.025n

.meas tran vdout1_46ck1070 FIND v(dout1_46) AT=540.025n

.meas tran vdout1_47ck1070 FIND v(dout1_47) AT=540.025n

.meas tran vdout1_48ck1070 FIND v(dout1_48) AT=540.025n

.meas tran vdout1_49ck1070 FIND v(dout1_49) AT=540.025n

.meas tran vdout1_50ck1070 FIND v(dout1_50) AT=540.025n

.meas tran vdout1_51ck1070 FIND v(dout1_51) AT=540.025n

.meas tran vdout1_52ck1070 FIND v(dout1_52) AT=540.025n

.meas tran vdout1_53ck1070 FIND v(dout1_53) AT=540.025n

.meas tran vdout1_54ck1070 FIND v(dout1_54) AT=540.025n

.meas tran vdout1_55ck1070 FIND v(dout1_55) AT=540.025n

.meas tran vdout1_56ck1070 FIND v(dout1_56) AT=540.025n

.meas tran vdout1_57ck1070 FIND v(dout1_57) AT=540.025n

.meas tran vdout1_58ck1070 FIND v(dout1_58) AT=540.025n

.meas tran vdout1_59ck1070 FIND v(dout1_59) AT=540.025n

.meas tran vdout1_60ck1070 FIND v(dout1_60) AT=540.025n

.meas tran vdout1_61ck1070 FIND v(dout1_61) AT=540.025n

.meas tran vdout1_62ck1070 FIND v(dout1_62) AT=540.025n

.meas tran vdout1_63ck1070 FIND v(dout1_63) AT=540.025n

.meas tran vdout1_64ck1070 FIND v(dout1_64) AT=540.025n

.meas tran vdout1_65ck1070 FIND v(dout1_65) AT=540.025n

.meas tran vdout1_66ck1070 FIND v(dout1_66) AT=540.025n

.meas tran vdout1_67ck1070 FIND v(dout1_67) AT=540.025n

.meas tran vdout1_68ck1070 FIND v(dout1_68) AT=540.025n

.meas tran vdout1_69ck1070 FIND v(dout1_69) AT=540.025n

.meas tran vdout1_70ck1070 FIND v(dout1_70) AT=540.025n

.meas tran vdout1_71ck1070 FIND v(dout1_71) AT=540.025n

.meas tran vdout1_72ck1070 FIND v(dout1_72) AT=540.025n

.meas tran vdout1_73ck1070 FIND v(dout1_73) AT=540.025n

.meas tran vdout1_74ck1070 FIND v(dout1_74) AT=540.025n

.meas tran vdout1_75ck1070 FIND v(dout1_75) AT=540.025n

.meas tran vdout1_76ck1070 FIND v(dout1_76) AT=540.025n

.meas tran vdout1_77ck1070 FIND v(dout1_77) AT=540.025n

.meas tran vdout1_78ck1070 FIND v(dout1_78) AT=540.025n

.meas tran vdout1_79ck1070 FIND v(dout1_79) AT=540.025n

.meas tran vdout1_80ck1070 FIND v(dout1_80) AT=540.025n

.meas tran vdout1_81ck1070 FIND v(dout1_81) AT=540.025n

.meas tran vdout1_82ck1070 FIND v(dout1_82) AT=540.025n

.meas tran vdout1_83ck1070 FIND v(dout1_83) AT=540.025n

.meas tran vdout1_84ck1070 FIND v(dout1_84) AT=540.025n

.meas tran vdout1_85ck1070 FIND v(dout1_85) AT=540.025n

.meas tran vdout1_86ck1070 FIND v(dout1_86) AT=540.025n

.meas tran vdout1_87ck1070 FIND v(dout1_87) AT=540.025n

.meas tran vdout1_88ck1070 FIND v(dout1_88) AT=540.025n

.meas tran vdout1_89ck1070 FIND v(dout1_89) AT=540.025n

.meas tran vdout1_90ck1070 FIND v(dout1_90) AT=540.025n

.meas tran vdout1_91ck1070 FIND v(dout1_91) AT=540.025n

.meas tran vdout1_92ck1070 FIND v(dout1_92) AT=540.025n

.meas tran vdout1_93ck1070 FIND v(dout1_93) AT=540.025n

.meas tran vdout1_94ck1070 FIND v(dout1_94) AT=540.025n

.meas tran vdout1_95ck1070 FIND v(dout1_95) AT=540.025n

.meas tran vdout1_96ck1070 FIND v(dout1_96) AT=540.025n

.meas tran vdout1_97ck1070 FIND v(dout1_97) AT=540.025n

.meas tran vdout1_98ck1070 FIND v(dout1_98) AT=540.025n

.meas tran vdout1_99ck1070 FIND v(dout1_99) AT=540.025n

.meas tran vdout1_100ck1070 FIND v(dout1_100) AT=540.025n

.meas tran vdout1_101ck1070 FIND v(dout1_101) AT=540.025n

.meas tran vdout1_102ck1070 FIND v(dout1_102) AT=540.025n

.meas tran vdout1_103ck1070 FIND v(dout1_103) AT=540.025n

.meas tran vdout1_104ck1070 FIND v(dout1_104) AT=540.025n

.meas tran vdout1_105ck1070 FIND v(dout1_105) AT=540.025n

.meas tran vdout1_106ck1070 FIND v(dout1_106) AT=540.025n

.meas tran vdout1_107ck1070 FIND v(dout1_107) AT=540.025n

.meas tran vdout1_108ck1070 FIND v(dout1_108) AT=540.025n

.meas tran vdout1_109ck1070 FIND v(dout1_109) AT=540.025n

.meas tran vdout1_110ck1070 FIND v(dout1_110) AT=540.025n

.meas tran vdout1_111ck1070 FIND v(dout1_111) AT=540.025n

.meas tran vdout1_112ck1070 FIND v(dout1_112) AT=540.025n

.meas tran vdout1_113ck1070 FIND v(dout1_113) AT=540.025n

.meas tran vdout1_114ck1070 FIND v(dout1_114) AT=540.025n

.meas tran vdout1_115ck1070 FIND v(dout1_115) AT=540.025n

.meas tran vdout1_116ck1070 FIND v(dout1_116) AT=540.025n

.meas tran vdout1_117ck1070 FIND v(dout1_117) AT=540.025n

.meas tran vdout1_118ck1070 FIND v(dout1_118) AT=540.025n

.meas tran vdout1_119ck1070 FIND v(dout1_119) AT=540.025n

.meas tran vdout1_120ck1070 FIND v(dout1_120) AT=540.025n

.meas tran vdout1_121ck1070 FIND v(dout1_121) AT=540.025n

.meas tran vdout1_122ck1070 FIND v(dout1_122) AT=540.025n

.meas tran vdout1_123ck1070 FIND v(dout1_123) AT=540.025n

.meas tran vdout1_124ck1070 FIND v(dout1_124) AT=540.025n

.meas tran vdout1_125ck1070 FIND v(dout1_125) AT=540.025n

.meas tran vdout1_126ck1070 FIND v(dout1_126) AT=540.025n

.meas tran vdout1_127ck1070 FIND v(dout1_127) AT=540.025n

.meas tran vdout1_128ck1070 FIND v(dout1_128) AT=540.025n

.meas tran vdout1_129ck1070 FIND v(dout1_129) AT=540.025n

.meas tran vdout1_130ck1070 FIND v(dout1_130) AT=540.025n

.meas tran vdout1_131ck1070 FIND v(dout1_131) AT=540.025n

.meas tran vdout1_132ck1070 FIND v(dout1_132) AT=540.025n

.meas tran vdout1_133ck1070 FIND v(dout1_133) AT=540.025n

.meas tran vdout1_134ck1070 FIND v(dout1_134) AT=540.025n

.meas tran vdout1_135ck1070 FIND v(dout1_135) AT=540.025n

.meas tran vdout1_136ck1070 FIND v(dout1_136) AT=540.025n

.meas tran vdout1_137ck1070 FIND v(dout1_137) AT=540.025n

.meas tran vdout1_138ck1070 FIND v(dout1_138) AT=540.025n

.meas tran vdout1_139ck1070 FIND v(dout1_139) AT=540.025n

.meas tran vdout1_140ck1070 FIND v(dout1_140) AT=540.025n

.meas tran vdout1_141ck1070 FIND v(dout1_141) AT=540.025n

.meas tran vdout1_142ck1070 FIND v(dout1_142) AT=540.025n

.meas tran vdout1_143ck1070 FIND v(dout1_143) AT=540.025n

.meas tran vdout1_144ck1070 FIND v(dout1_144) AT=540.025n

.meas tran vdout1_145ck1070 FIND v(dout1_145) AT=540.025n

.meas tran vdout1_146ck1070 FIND v(dout1_146) AT=540.025n

.meas tran vdout1_147ck1070 FIND v(dout1_147) AT=540.025n

.meas tran vdout1_148ck1070 FIND v(dout1_148) AT=540.025n

.meas tran vdout1_149ck1070 FIND v(dout1_149) AT=540.025n

.meas tran vdout1_150ck1070 FIND v(dout1_150) AT=540.025n

.meas tran vdout1_151ck1070 FIND v(dout1_151) AT=540.025n

.meas tran vdout1_152ck1070 FIND v(dout1_152) AT=540.025n

.meas tran vdout1_153ck1070 FIND v(dout1_153) AT=540.025n

.meas tran vdout1_154ck1070 FIND v(dout1_154) AT=540.025n

.meas tran vdout1_155ck1070 FIND v(dout1_155) AT=540.025n

.meas tran vdout1_156ck1070 FIND v(dout1_156) AT=540.025n

.meas tran vdout1_157ck1070 FIND v(dout1_157) AT=540.025n

.meas tran vdout1_158ck1070 FIND v(dout1_158) AT=540.025n

.meas tran vdout1_159ck1070 FIND v(dout1_159) AT=540.025n

.meas tran vdout1_160ck1070 FIND v(dout1_160) AT=540.025n

.meas tran vdout1_161ck1070 FIND v(dout1_161) AT=540.025n

.meas tran vdout1_162ck1070 FIND v(dout1_162) AT=540.025n

.meas tran vdout1_163ck1070 FIND v(dout1_163) AT=540.025n

.meas tran vdout1_164ck1070 FIND v(dout1_164) AT=540.025n

.meas tran vdout1_165ck1070 FIND v(dout1_165) AT=540.025n

.meas tran vdout1_166ck1070 FIND v(dout1_166) AT=540.025n

.meas tran vdout1_167ck1070 FIND v(dout1_167) AT=540.025n

.meas tran vdout1_168ck1070 FIND v(dout1_168) AT=540.025n

.meas tran vdout1_169ck1070 FIND v(dout1_169) AT=540.025n

.meas tran vdout1_170ck1070 FIND v(dout1_170) AT=540.025n

.meas tran vdout1_171ck1070 FIND v(dout1_171) AT=540.025n

.meas tran vdout1_172ck1070 FIND v(dout1_172) AT=540.025n

.meas tran vdout1_173ck1070 FIND v(dout1_173) AT=540.025n

.meas tran vdout1_174ck1070 FIND v(dout1_174) AT=540.025n

.meas tran vdout1_175ck1070 FIND v(dout1_175) AT=540.025n

.meas tran vdout1_176ck1070 FIND v(dout1_176) AT=540.025n

.meas tran vdout1_177ck1070 FIND v(dout1_177) AT=540.025n

.meas tran vdout1_178ck1070 FIND v(dout1_178) AT=540.025n

.meas tran vdout1_179ck1070 FIND v(dout1_179) AT=540.025n

.meas tran vdout1_180ck1070 FIND v(dout1_180) AT=540.025n

.meas tran vdout1_181ck1070 FIND v(dout1_181) AT=540.025n

.meas tran vdout1_182ck1070 FIND v(dout1_182) AT=540.025n

.meas tran vdout1_183ck1070 FIND v(dout1_183) AT=540.025n

.meas tran vdout1_184ck1070 FIND v(dout1_184) AT=540.025n

.meas tran vdout1_185ck1070 FIND v(dout1_185) AT=540.025n

.meas tran vdout1_186ck1070 FIND v(dout1_186) AT=540.025n

.meas tran vdout1_187ck1070 FIND v(dout1_187) AT=540.025n

.meas tran vdout1_188ck1070 FIND v(dout1_188) AT=540.025n

.meas tran vdout1_189ck1070 FIND v(dout1_189) AT=540.025n

.meas tran vdout1_190ck1070 FIND v(dout1_190) AT=540.025n

.meas tran vdout1_191ck1070 FIND v(dout1_191) AT=540.025n

.meas tran vdout1_192ck1070 FIND v(dout1_192) AT=540.025n

.meas tran vdout1_193ck1070 FIND v(dout1_193) AT=540.025n

.meas tran vdout1_194ck1070 FIND v(dout1_194) AT=540.025n

.meas tran vdout1_195ck1070 FIND v(dout1_195) AT=540.025n

.meas tran vdout1_196ck1070 FIND v(dout1_196) AT=540.025n

.meas tran vdout1_197ck1070 FIND v(dout1_197) AT=540.025n

.meas tran vdout1_198ck1070 FIND v(dout1_198) AT=540.025n

.meas tran vdout1_199ck1070 FIND v(dout1_199) AT=540.025n

.meas tran vdout1_200ck1070 FIND v(dout1_200) AT=540.025n

.meas tran vdout1_201ck1070 FIND v(dout1_201) AT=540.025n

.meas tran vdout1_202ck1070 FIND v(dout1_202) AT=540.025n

.meas tran vdout1_203ck1070 FIND v(dout1_203) AT=540.025n

.meas tran vdout1_204ck1070 FIND v(dout1_204) AT=540.025n

.meas tran vdout1_205ck1070 FIND v(dout1_205) AT=540.025n

.meas tran vdout1_206ck1070 FIND v(dout1_206) AT=540.025n

.meas tran vdout1_207ck1070 FIND v(dout1_207) AT=540.025n

.meas tran vdout1_208ck1070 FIND v(dout1_208) AT=540.025n

.meas tran vdout1_209ck1070 FIND v(dout1_209) AT=540.025n

.meas tran vdout1_210ck1070 FIND v(dout1_210) AT=540.025n

.meas tran vdout1_211ck1070 FIND v(dout1_211) AT=540.025n

.meas tran vdout1_212ck1070 FIND v(dout1_212) AT=540.025n

.meas tran vdout1_213ck1070 FIND v(dout1_213) AT=540.025n

.meas tran vdout1_214ck1070 FIND v(dout1_214) AT=540.025n

.meas tran vdout1_215ck1070 FIND v(dout1_215) AT=540.025n

.meas tran vdout1_216ck1070 FIND v(dout1_216) AT=540.025n

.meas tran vdout1_217ck1070 FIND v(dout1_217) AT=540.025n

.meas tran vdout1_218ck1070 FIND v(dout1_218) AT=540.025n

.meas tran vdout1_219ck1070 FIND v(dout1_219) AT=540.025n

.meas tran vdout1_220ck1070 FIND v(dout1_220) AT=540.025n

.meas tran vdout1_221ck1070 FIND v(dout1_221) AT=540.025n

.meas tran vdout1_222ck1070 FIND v(dout1_222) AT=540.025n

.meas tran vdout1_223ck1070 FIND v(dout1_223) AT=540.025n

.meas tran vdout1_224ck1070 FIND v(dout1_224) AT=540.025n

.meas tran vdout1_225ck1070 FIND v(dout1_225) AT=540.025n

.meas tran vdout1_226ck1070 FIND v(dout1_226) AT=540.025n

.meas tran vdout1_227ck1070 FIND v(dout1_227) AT=540.025n

.meas tran vdout1_228ck1070 FIND v(dout1_228) AT=540.025n

.meas tran vdout1_229ck1070 FIND v(dout1_229) AT=540.025n

.meas tran vdout1_230ck1070 FIND v(dout1_230) AT=540.025n

.meas tran vdout1_231ck1070 FIND v(dout1_231) AT=540.025n

.meas tran vdout1_232ck1070 FIND v(dout1_232) AT=540.025n

.meas tran vdout1_233ck1070 FIND v(dout1_233) AT=540.025n

.meas tran vdout1_234ck1070 FIND v(dout1_234) AT=540.025n

.meas tran vdout1_235ck1070 FIND v(dout1_235) AT=540.025n

.meas tran vdout1_236ck1070 FIND v(dout1_236) AT=540.025n

.meas tran vdout1_237ck1070 FIND v(dout1_237) AT=540.025n

.meas tran vdout1_238ck1070 FIND v(dout1_238) AT=540.025n

.meas tran vdout1_239ck1070 FIND v(dout1_239) AT=540.025n

.meas tran vdout1_240ck1070 FIND v(dout1_240) AT=540.025n

.meas tran vdout1_241ck1070 FIND v(dout1_241) AT=540.025n

.meas tran vdout1_242ck1070 FIND v(dout1_242) AT=540.025n

.meas tran vdout1_243ck1070 FIND v(dout1_243) AT=540.025n

.meas tran vdout1_244ck1070 FIND v(dout1_244) AT=540.025n

.meas tran vdout1_245ck1070 FIND v(dout1_245) AT=540.025n

.meas tran vdout1_246ck1070 FIND v(dout1_246) AT=540.025n

.meas tran vdout1_247ck1070 FIND v(dout1_247) AT=540.025n

.meas tran vdout1_248ck1070 FIND v(dout1_248) AT=540.025n

.meas tran vdout1_249ck1070 FIND v(dout1_249) AT=540.025n

.meas tran vdout1_250ck1070 FIND v(dout1_250) AT=540.025n

.meas tran vdout1_251ck1070 FIND v(dout1_251) AT=540.025n

.meas tran vdout1_252ck1070 FIND v(dout1_252) AT=540.025n

.meas tran vdout1_253ck1070 FIND v(dout1_253) AT=540.025n

.meas tran vdout1_254ck1070 FIND v(dout1_254) AT=540.025n

.meas tran vdout1_255ck1070 FIND v(dout1_255) AT=540.025n

.meas tran vdout1_256ck1070 FIND v(dout1_256) AT=540.025n

.meas tran vdout1_257ck1070 FIND v(dout1_257) AT=540.025n

.meas tran vdout1_258ck1070 FIND v(dout1_258) AT=540.025n

.meas tran vdout1_259ck1070 FIND v(dout1_259) AT=540.025n

.meas tran vdout1_260ck1070 FIND v(dout1_260) AT=540.025n

.meas tran vdout1_261ck1070 FIND v(dout1_261) AT=540.025n

.meas tran vdout1_262ck1070 FIND v(dout1_262) AT=540.025n

.meas tran vdout1_263ck1070 FIND v(dout1_263) AT=540.025n

.meas tran vdout1_264ck1070 FIND v(dout1_264) AT=540.025n

.meas tran vdout1_265ck1070 FIND v(dout1_265) AT=540.025n

.meas tran vdout1_266ck1070 FIND v(dout1_266) AT=540.025n

.meas tran vdout1_267ck1070 FIND v(dout1_267) AT=540.025n

.meas tran vdout1_268ck1070 FIND v(dout1_268) AT=540.025n

.meas tran vdout1_269ck1070 FIND v(dout1_269) AT=540.025n

.meas tran vdout1_270ck1070 FIND v(dout1_270) AT=540.025n

.meas tran vdout1_271ck1070 FIND v(dout1_271) AT=540.025n

.meas tran vdout1_272ck1070 FIND v(dout1_272) AT=540.025n

.meas tran vdout1_273ck1070 FIND v(dout1_273) AT=540.025n

.meas tran vdout1_274ck1070 FIND v(dout1_274) AT=540.025n

.meas tran vdout1_275ck1070 FIND v(dout1_275) AT=540.025n

.meas tran vdout1_276ck1070 FIND v(dout1_276) AT=540.025n

.meas tran vdout1_277ck1070 FIND v(dout1_277) AT=540.025n

.meas tran vdout1_278ck1070 FIND v(dout1_278) AT=540.025n

.meas tran vdout1_279ck1070 FIND v(dout1_279) AT=540.025n

.meas tran vdout1_280ck1070 FIND v(dout1_280) AT=540.025n

.meas tran vdout1_281ck1070 FIND v(dout1_281) AT=540.025n

.meas tran vdout1_282ck1070 FIND v(dout1_282) AT=540.025n

.meas tran vdout1_283ck1070 FIND v(dout1_283) AT=540.025n

.meas tran vdout1_284ck1070 FIND v(dout1_284) AT=540.025n

.meas tran vdout1_285ck1070 FIND v(dout1_285) AT=540.025n

.meas tran vdout1_286ck1070 FIND v(dout1_286) AT=540.025n

.meas tran vdout1_287ck1070 FIND v(dout1_287) AT=540.025n

.meas tran vdout1_288ck1070 FIND v(dout1_288) AT=540.025n

.meas tran vdout1_289ck1070 FIND v(dout1_289) AT=540.025n

.meas tran vdout1_290ck1070 FIND v(dout1_290) AT=540.025n

.meas tran vdout1_291ck1070 FIND v(dout1_291) AT=540.025n

.meas tran vdout1_292ck1070 FIND v(dout1_292) AT=540.025n

.meas tran vdout1_293ck1070 FIND v(dout1_293) AT=540.025n

.meas tran vdout1_294ck1070 FIND v(dout1_294) AT=540.025n

.meas tran vdout1_295ck1070 FIND v(dout1_295) AT=540.025n

.meas tran vdout1_296ck1070 FIND v(dout1_296) AT=540.025n

.meas tran vdout1_297ck1070 FIND v(dout1_297) AT=540.025n

.meas tran vdout1_298ck1070 FIND v(dout1_298) AT=540.025n

.meas tran vdout1_299ck1070 FIND v(dout1_299) AT=540.025n

.meas tran vdout1_300ck1070 FIND v(dout1_300) AT=540.025n

.meas tran vdout1_301ck1070 FIND v(dout1_301) AT=540.025n

.meas tran vdout1_302ck1070 FIND v(dout1_302) AT=540.025n

.meas tran vdout1_303ck1070 FIND v(dout1_303) AT=540.025n

.meas tran vdout1_304ck1070 FIND v(dout1_304) AT=540.025n

.meas tran vdout1_305ck1070 FIND v(dout1_305) AT=540.025n

.meas tran vdout1_306ck1070 FIND v(dout1_306) AT=540.025n

.meas tran vdout1_307ck1070 FIND v(dout1_307) AT=540.025n

.meas tran vdout1_308ck1070 FIND v(dout1_308) AT=540.025n

.meas tran vdout1_309ck1070 FIND v(dout1_309) AT=540.025n

.meas tran vdout1_310ck1070 FIND v(dout1_310) AT=540.025n

.meas tran vdout1_311ck1070 FIND v(dout1_311) AT=540.025n

.meas tran vdout1_312ck1070 FIND v(dout1_312) AT=540.025n

.meas tran vdout1_313ck1070 FIND v(dout1_313) AT=540.025n

.meas tran vdout1_314ck1070 FIND v(dout1_314) AT=540.025n

.meas tran vdout1_315ck1070 FIND v(dout1_315) AT=540.025n

.meas tran vdout1_316ck1070 FIND v(dout1_316) AT=540.025n

.meas tran vdout1_317ck1070 FIND v(dout1_317) AT=540.025n

.meas tran vdout1_318ck1070 FIND v(dout1_318) AT=540.025n

.meas tran vdout1_319ck1070 FIND v(dout1_319) AT=540.025n

.meas tran vdout1_320ck1070 FIND v(dout1_320) AT=540.025n

.meas tran vdout1_321ck1070 FIND v(dout1_321) AT=540.025n

.meas tran vdout1_322ck1070 FIND v(dout1_322) AT=540.025n

.meas tran vdout1_323ck1070 FIND v(dout1_323) AT=540.025n

.meas tran vdout1_324ck1070 FIND v(dout1_324) AT=540.025n

.meas tran vdout1_325ck1070 FIND v(dout1_325) AT=540.025n

.meas tran vdout1_326ck1070 FIND v(dout1_326) AT=540.025n

.meas tran vdout1_327ck1070 FIND v(dout1_327) AT=540.025n

.meas tran vdout1_328ck1070 FIND v(dout1_328) AT=540.025n

.meas tran vdout1_329ck1070 FIND v(dout1_329) AT=540.025n

.meas tran vdout1_330ck1070 FIND v(dout1_330) AT=540.025n

.meas tran vdout1_331ck1070 FIND v(dout1_331) AT=540.025n

.meas tran vdout1_332ck1070 FIND v(dout1_332) AT=540.025n

.meas tran vdout1_333ck1070 FIND v(dout1_333) AT=540.025n

.meas tran vdout1_334ck1070 FIND v(dout1_334) AT=540.025n

.meas tran vdout1_335ck1070 FIND v(dout1_335) AT=540.025n

.meas tran vdout1_336ck1070 FIND v(dout1_336) AT=540.025n

.meas tran vdout1_337ck1070 FIND v(dout1_337) AT=540.025n

.meas tran vdout1_338ck1070 FIND v(dout1_338) AT=540.025n

.meas tran vdout1_339ck1070 FIND v(dout1_339) AT=540.025n

.meas tran vdout1_340ck1070 FIND v(dout1_340) AT=540.025n

.meas tran vdout1_341ck1070 FIND v(dout1_341) AT=540.025n

.meas tran vdout1_342ck1070 FIND v(dout1_342) AT=540.025n

.meas tran vdout1_343ck1070 FIND v(dout1_343) AT=540.025n

.meas tran vdout1_344ck1070 FIND v(dout1_344) AT=540.025n

.meas tran vdout1_345ck1070 FIND v(dout1_345) AT=540.025n

.meas tran vdout1_346ck1070 FIND v(dout1_346) AT=540.025n

.meas tran vdout1_347ck1070 FIND v(dout1_347) AT=540.025n

.meas tran vdout1_348ck1070 FIND v(dout1_348) AT=540.025n

.meas tran vdout1_349ck1070 FIND v(dout1_349) AT=540.025n

.meas tran vdout1_350ck1070 FIND v(dout1_350) AT=540.025n

.meas tran vdout1_351ck1070 FIND v(dout1_351) AT=540.025n

.meas tran vdout1_352ck1070 FIND v(dout1_352) AT=540.025n

.meas tran vdout1_353ck1070 FIND v(dout1_353) AT=540.025n

.meas tran vdout1_354ck1070 FIND v(dout1_354) AT=540.025n

.meas tran vdout1_355ck1070 FIND v(dout1_355) AT=540.025n

.meas tran vdout1_356ck1070 FIND v(dout1_356) AT=540.025n

.meas tran vdout1_357ck1070 FIND v(dout1_357) AT=540.025n

.meas tran vdout1_358ck1070 FIND v(dout1_358) AT=540.025n

.meas tran vdout1_359ck1070 FIND v(dout1_359) AT=540.025n

.meas tran vdout1_360ck1070 FIND v(dout1_360) AT=540.025n

.meas tran vdout1_361ck1070 FIND v(dout1_361) AT=540.025n

.meas tran vdout1_362ck1070 FIND v(dout1_362) AT=540.025n

.meas tran vdout1_363ck1070 FIND v(dout1_363) AT=540.025n

.meas tran vdout1_364ck1070 FIND v(dout1_364) AT=540.025n

.meas tran vdout1_365ck1070 FIND v(dout1_365) AT=540.025n

.meas tran vdout1_366ck1070 FIND v(dout1_366) AT=540.025n

.meas tran vdout1_367ck1070 FIND v(dout1_367) AT=540.025n

.meas tran vdout1_368ck1070 FIND v(dout1_368) AT=540.025n

.meas tran vdout1_369ck1070 FIND v(dout1_369) AT=540.025n

.meas tran vdout1_370ck1070 FIND v(dout1_370) AT=540.025n

.meas tran vdout1_371ck1070 FIND v(dout1_371) AT=540.025n

.meas tran vdout1_372ck1070 FIND v(dout1_372) AT=540.025n

.meas tran vdout1_373ck1070 FIND v(dout1_373) AT=540.025n

.meas tran vdout1_374ck1070 FIND v(dout1_374) AT=540.025n

.meas tran vdout1_375ck1070 FIND v(dout1_375) AT=540.025n

.meas tran vdout1_376ck1070 FIND v(dout1_376) AT=540.025n

.meas tran vdout1_377ck1070 FIND v(dout1_377) AT=540.025n

.meas tran vdout1_378ck1070 FIND v(dout1_378) AT=540.025n

.meas tran vdout1_379ck1070 FIND v(dout1_379) AT=540.025n

.meas tran vdout1_380ck1070 FIND v(dout1_380) AT=540.025n

.meas tran vdout1_381ck1070 FIND v(dout1_381) AT=540.025n

.meas tran vdout1_382ck1070 FIND v(dout1_382) AT=540.025n

.meas tran vdout1_383ck1070 FIND v(dout1_383) AT=540.025n

.meas tran vdout1_384ck1070 FIND v(dout1_384) AT=540.025n

.meas tran vdout1_385ck1070 FIND v(dout1_385) AT=540.025n

.meas tran vdout1_386ck1070 FIND v(dout1_386) AT=540.025n

.meas tran vdout1_387ck1070 FIND v(dout1_387) AT=540.025n

.meas tran vdout1_388ck1070 FIND v(dout1_388) AT=540.025n

.meas tran vdout1_389ck1070 FIND v(dout1_389) AT=540.025n

.meas tran vdout1_390ck1070 FIND v(dout1_390) AT=540.025n

.meas tran vdout1_391ck1070 FIND v(dout1_391) AT=540.025n

.meas tran vdout1_392ck1070 FIND v(dout1_392) AT=540.025n

.meas tran vdout1_393ck1070 FIND v(dout1_393) AT=540.025n

.meas tran vdout1_394ck1070 FIND v(dout1_394) AT=540.025n

.meas tran vdout1_395ck1070 FIND v(dout1_395) AT=540.025n

.meas tran vdout1_396ck1070 FIND v(dout1_396) AT=540.025n

.meas tran vdout1_397ck1070 FIND v(dout1_397) AT=540.025n

.meas tran vdout1_398ck1070 FIND v(dout1_398) AT=540.025n

.meas tran vdout1_399ck1070 FIND v(dout1_399) AT=540.025n

.meas tran vdout1_400ck1070 FIND v(dout1_400) AT=540.025n

.meas tran vdout1_401ck1070 FIND v(dout1_401) AT=540.025n

.meas tran vdout1_402ck1070 FIND v(dout1_402) AT=540.025n

.meas tran vdout1_403ck1070 FIND v(dout1_403) AT=540.025n

.meas tran vdout1_404ck1070 FIND v(dout1_404) AT=540.025n

.meas tran vdout1_405ck1070 FIND v(dout1_405) AT=540.025n

.meas tran vdout1_406ck1070 FIND v(dout1_406) AT=540.025n

.meas tran vdout1_407ck1070 FIND v(dout1_407) AT=540.025n

.meas tran vdout1_408ck1070 FIND v(dout1_408) AT=540.025n

.meas tran vdout1_409ck1070 FIND v(dout1_409) AT=540.025n

.meas tran vdout1_410ck1070 FIND v(dout1_410) AT=540.025n

.meas tran vdout1_411ck1070 FIND v(dout1_411) AT=540.025n

.meas tran vdout1_412ck1070 FIND v(dout1_412) AT=540.025n

.meas tran vdout1_413ck1070 FIND v(dout1_413) AT=540.025n

.meas tran vdout1_414ck1070 FIND v(dout1_414) AT=540.025n

.meas tran vdout1_415ck1070 FIND v(dout1_415) AT=540.025n

.meas tran vdout1_416ck1070 FIND v(dout1_416) AT=540.025n

.meas tran vdout1_417ck1070 FIND v(dout1_417) AT=540.025n

.meas tran vdout1_418ck1070 FIND v(dout1_418) AT=540.025n

.meas tran vdout1_419ck1070 FIND v(dout1_419) AT=540.025n

.meas tran vdout1_420ck1070 FIND v(dout1_420) AT=540.025n

.meas tran vdout1_421ck1070 FIND v(dout1_421) AT=540.025n

.meas tran vdout1_422ck1070 FIND v(dout1_422) AT=540.025n

.meas tran vdout1_423ck1070 FIND v(dout1_423) AT=540.025n

.meas tran vdout1_424ck1070 FIND v(dout1_424) AT=540.025n

.meas tran vdout1_425ck1070 FIND v(dout1_425) AT=540.025n

.meas tran vdout1_426ck1070 FIND v(dout1_426) AT=540.025n

.meas tran vdout1_427ck1070 FIND v(dout1_427) AT=540.025n

.meas tran vdout1_428ck1070 FIND v(dout1_428) AT=540.025n

.meas tran vdout1_429ck1070 FIND v(dout1_429) AT=540.025n

.meas tran vdout1_430ck1070 FIND v(dout1_430) AT=540.025n

.meas tran vdout1_431ck1070 FIND v(dout1_431) AT=540.025n

.meas tran vdout1_432ck1070 FIND v(dout1_432) AT=540.025n

.meas tran vdout1_433ck1070 FIND v(dout1_433) AT=540.025n

.meas tran vdout1_434ck1070 FIND v(dout1_434) AT=540.025n

.meas tran vdout1_435ck1070 FIND v(dout1_435) AT=540.025n

.meas tran vdout1_436ck1070 FIND v(dout1_436) AT=540.025n

.meas tran vdout1_437ck1070 FIND v(dout1_437) AT=540.025n

.meas tran vdout1_438ck1070 FIND v(dout1_438) AT=540.025n

.meas tran vdout1_439ck1070 FIND v(dout1_439) AT=540.025n

.meas tran vdout1_440ck1070 FIND v(dout1_440) AT=540.025n

.meas tran vdout1_441ck1070 FIND v(dout1_441) AT=540.025n

.meas tran vdout1_442ck1070 FIND v(dout1_442) AT=540.025n

.meas tran vdout1_443ck1070 FIND v(dout1_443) AT=540.025n

.meas tran vdout1_444ck1070 FIND v(dout1_444) AT=540.025n

.meas tran vdout1_445ck1070 FIND v(dout1_445) AT=540.025n

.meas tran vdout1_446ck1070 FIND v(dout1_446) AT=540.025n

.meas tran vdout1_447ck1070 FIND v(dout1_447) AT=540.025n

.meas tran vdout1_448ck1070 FIND v(dout1_448) AT=540.025n

.meas tran vdout1_449ck1070 FIND v(dout1_449) AT=540.025n

.meas tran vdout1_450ck1070 FIND v(dout1_450) AT=540.025n

.meas tran vdout1_451ck1070 FIND v(dout1_451) AT=540.025n

.meas tran vdout1_452ck1070 FIND v(dout1_452) AT=540.025n

.meas tran vdout1_453ck1070 FIND v(dout1_453) AT=540.025n

.meas tran vdout1_454ck1070 FIND v(dout1_454) AT=540.025n

.meas tran vdout1_455ck1070 FIND v(dout1_455) AT=540.025n

.meas tran vdout1_456ck1070 FIND v(dout1_456) AT=540.025n

.meas tran vdout1_457ck1070 FIND v(dout1_457) AT=540.025n

.meas tran vdout1_458ck1070 FIND v(dout1_458) AT=540.025n

.meas tran vdout1_459ck1070 FIND v(dout1_459) AT=540.025n

.meas tran vdout1_460ck1070 FIND v(dout1_460) AT=540.025n

.meas tran vdout1_461ck1070 FIND v(dout1_461) AT=540.025n

.meas tran vdout1_462ck1070 FIND v(dout1_462) AT=540.025n

.meas tran vdout1_463ck1070 FIND v(dout1_463) AT=540.025n

.meas tran vdout1_464ck1070 FIND v(dout1_464) AT=540.025n

.meas tran vdout1_465ck1070 FIND v(dout1_465) AT=540.025n

.meas tran vdout1_466ck1070 FIND v(dout1_466) AT=540.025n

.meas tran vdout1_467ck1070 FIND v(dout1_467) AT=540.025n

.meas tran vdout1_468ck1070 FIND v(dout1_468) AT=540.025n

.meas tran vdout1_469ck1070 FIND v(dout1_469) AT=540.025n

.meas tran vdout1_470ck1070 FIND v(dout1_470) AT=540.025n

.meas tran vdout1_471ck1070 FIND v(dout1_471) AT=540.025n

.meas tran vdout1_472ck1070 FIND v(dout1_472) AT=540.025n

.meas tran vdout1_473ck1070 FIND v(dout1_473) AT=540.025n

.meas tran vdout1_474ck1070 FIND v(dout1_474) AT=540.025n

.meas tran vdout1_475ck1070 FIND v(dout1_475) AT=540.025n

.meas tran vdout1_476ck1070 FIND v(dout1_476) AT=540.025n

.meas tran vdout1_477ck1070 FIND v(dout1_477) AT=540.025n

.meas tran vdout1_478ck1070 FIND v(dout1_478) AT=540.025n

.meas tran vdout1_479ck1070 FIND v(dout1_479) AT=540.025n

.meas tran vdout1_480ck1070 FIND v(dout1_480) AT=540.025n

.meas tran vdout1_481ck1070 FIND v(dout1_481) AT=540.025n

.meas tran vdout1_482ck1070 FIND v(dout1_482) AT=540.025n

.meas tran vdout1_483ck1070 FIND v(dout1_483) AT=540.025n

.meas tran vdout1_484ck1070 FIND v(dout1_484) AT=540.025n

.meas tran vdout1_485ck1070 FIND v(dout1_485) AT=540.025n

.meas tran vdout1_486ck1070 FIND v(dout1_486) AT=540.025n

.meas tran vdout1_487ck1070 FIND v(dout1_487) AT=540.025n

.meas tran vdout1_488ck1070 FIND v(dout1_488) AT=540.025n

.meas tran vdout1_489ck1070 FIND v(dout1_489) AT=540.025n

.meas tran vdout1_490ck1070 FIND v(dout1_490) AT=540.025n

.meas tran vdout1_491ck1070 FIND v(dout1_491) AT=540.025n

.meas tran vdout1_492ck1070 FIND v(dout1_492) AT=540.025n

.meas tran vdout1_493ck1070 FIND v(dout1_493) AT=540.025n

.meas tran vdout1_494ck1070 FIND v(dout1_494) AT=540.025n

.meas tran vdout1_495ck1070 FIND v(dout1_495) AT=540.025n

.meas tran vdout1_496ck1070 FIND v(dout1_496) AT=540.025n

.meas tran vdout1_497ck1070 FIND v(dout1_497) AT=540.025n

.meas tran vdout1_498ck1070 FIND v(dout1_498) AT=540.025n

.meas tran vdout1_499ck1070 FIND v(dout1_499) AT=540.025n

.meas tran vdout1_500ck1070 FIND v(dout1_500) AT=540.025n

.meas tran vdout1_501ck1070 FIND v(dout1_501) AT=540.025n

.meas tran vdout1_502ck1070 FIND v(dout1_502) AT=540.025n

.meas tran vdout1_503ck1070 FIND v(dout1_503) AT=540.025n

.meas tran vdout1_504ck1070 FIND v(dout1_504) AT=540.025n

.meas tran vdout1_505ck1070 FIND v(dout1_505) AT=540.025n

.meas tran vdout1_506ck1070 FIND v(dout1_506) AT=540.025n

.meas tran vdout1_507ck1070 FIND v(dout1_507) AT=540.025n

.meas tran vdout1_508ck1070 FIND v(dout1_508) AT=540.025n

.meas tran vdout1_509ck1070 FIND v(dout1_509) AT=540.025n

.meas tran vdout1_510ck1070 FIND v(dout1_510) AT=540.025n

.meas tran vdout1_511ck1070 FIND v(dout1_511) AT=540.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_23ck1200 FIND v(dout1_23) AT=605.025n

.meas tran vdout1_24ck1200 FIND v(dout1_24) AT=605.025n

.meas tran vdout1_25ck1200 FIND v(dout1_25) AT=605.025n

.meas tran vdout1_26ck1200 FIND v(dout1_26) AT=605.025n

.meas tran vdout1_27ck1200 FIND v(dout1_27) AT=605.025n

.meas tran vdout1_28ck1200 FIND v(dout1_28) AT=605.025n

.meas tran vdout1_29ck1200 FIND v(dout1_29) AT=605.025n

.meas tran vdout1_30ck1200 FIND v(dout1_30) AT=605.025n

.meas tran vdout1_31ck1200 FIND v(dout1_31) AT=605.025n

.meas tran vdout1_32ck1200 FIND v(dout1_32) AT=605.025n

.meas tran vdout1_33ck1200 FIND v(dout1_33) AT=605.025n

.meas tran vdout1_34ck1200 FIND v(dout1_34) AT=605.025n

.meas tran vdout1_35ck1200 FIND v(dout1_35) AT=605.025n

.meas tran vdout1_36ck1200 FIND v(dout1_36) AT=605.025n

.meas tran vdout1_37ck1200 FIND v(dout1_37) AT=605.025n

.meas tran vdout1_38ck1200 FIND v(dout1_38) AT=605.025n

.meas tran vdout1_39ck1200 FIND v(dout1_39) AT=605.025n

.meas tran vdout1_40ck1200 FIND v(dout1_40) AT=605.025n

.meas tran vdout1_41ck1200 FIND v(dout1_41) AT=605.025n

.meas tran vdout1_42ck1200 FIND v(dout1_42) AT=605.025n

.meas tran vdout1_43ck1200 FIND v(dout1_43) AT=605.025n

.meas tran vdout1_44ck1200 FIND v(dout1_44) AT=605.025n

.meas tran vdout1_45ck1200 FIND v(dout1_45) AT=605.025n

.meas tran vdout1_46ck1200 FIND v(dout1_46) AT=605.025n

.meas tran vdout1_47ck1200 FIND v(dout1_47) AT=605.025n

.meas tran vdout1_48ck1200 FIND v(dout1_48) AT=605.025n

.meas tran vdout1_49ck1200 FIND v(dout1_49) AT=605.025n

.meas tran vdout1_50ck1200 FIND v(dout1_50) AT=605.025n

.meas tran vdout1_51ck1200 FIND v(dout1_51) AT=605.025n

.meas tran vdout1_52ck1200 FIND v(dout1_52) AT=605.025n

.meas tran vdout1_53ck1200 FIND v(dout1_53) AT=605.025n

.meas tran vdout1_54ck1200 FIND v(dout1_54) AT=605.025n

.meas tran vdout1_55ck1200 FIND v(dout1_55) AT=605.025n

.meas tran vdout1_56ck1200 FIND v(dout1_56) AT=605.025n

.meas tran vdout1_57ck1200 FIND v(dout1_57) AT=605.025n

.meas tran vdout1_58ck1200 FIND v(dout1_58) AT=605.025n

.meas tran vdout1_59ck1200 FIND v(dout1_59) AT=605.025n

.meas tran vdout1_60ck1200 FIND v(dout1_60) AT=605.025n

.meas tran vdout1_61ck1200 FIND v(dout1_61) AT=605.025n

.meas tran vdout1_62ck1200 FIND v(dout1_62) AT=605.025n

.meas tran vdout1_63ck1200 FIND v(dout1_63) AT=605.025n

.meas tran vdout1_64ck1200 FIND v(dout1_64) AT=605.025n

.meas tran vdout1_65ck1200 FIND v(dout1_65) AT=605.025n

.meas tran vdout1_66ck1200 FIND v(dout1_66) AT=605.025n

.meas tran vdout1_67ck1200 FIND v(dout1_67) AT=605.025n

.meas tran vdout1_68ck1200 FIND v(dout1_68) AT=605.025n

.meas tran vdout1_69ck1200 FIND v(dout1_69) AT=605.025n

.meas tran vdout1_70ck1200 FIND v(dout1_70) AT=605.025n

.meas tran vdout1_71ck1200 FIND v(dout1_71) AT=605.025n

.meas tran vdout1_72ck1200 FIND v(dout1_72) AT=605.025n

.meas tran vdout1_73ck1200 FIND v(dout1_73) AT=605.025n

.meas tran vdout1_74ck1200 FIND v(dout1_74) AT=605.025n

.meas tran vdout1_75ck1200 FIND v(dout1_75) AT=605.025n

.meas tran vdout1_76ck1200 FIND v(dout1_76) AT=605.025n

.meas tran vdout1_77ck1200 FIND v(dout1_77) AT=605.025n

.meas tran vdout1_78ck1200 FIND v(dout1_78) AT=605.025n

.meas tran vdout1_79ck1200 FIND v(dout1_79) AT=605.025n

.meas tran vdout1_80ck1200 FIND v(dout1_80) AT=605.025n

.meas tran vdout1_81ck1200 FIND v(dout1_81) AT=605.025n

.meas tran vdout1_82ck1200 FIND v(dout1_82) AT=605.025n

.meas tran vdout1_83ck1200 FIND v(dout1_83) AT=605.025n

.meas tran vdout1_84ck1200 FIND v(dout1_84) AT=605.025n

.meas tran vdout1_85ck1200 FIND v(dout1_85) AT=605.025n

.meas tran vdout1_86ck1200 FIND v(dout1_86) AT=605.025n

.meas tran vdout1_87ck1200 FIND v(dout1_87) AT=605.025n

.meas tran vdout1_88ck1200 FIND v(dout1_88) AT=605.025n

.meas tran vdout1_89ck1200 FIND v(dout1_89) AT=605.025n

.meas tran vdout1_90ck1200 FIND v(dout1_90) AT=605.025n

.meas tran vdout1_91ck1200 FIND v(dout1_91) AT=605.025n

.meas tran vdout1_92ck1200 FIND v(dout1_92) AT=605.025n

.meas tran vdout1_93ck1200 FIND v(dout1_93) AT=605.025n

.meas tran vdout1_94ck1200 FIND v(dout1_94) AT=605.025n

.meas tran vdout1_95ck1200 FIND v(dout1_95) AT=605.025n

.meas tran vdout1_96ck1200 FIND v(dout1_96) AT=605.025n

.meas tran vdout1_97ck1200 FIND v(dout1_97) AT=605.025n

.meas tran vdout1_98ck1200 FIND v(dout1_98) AT=605.025n

.meas tran vdout1_99ck1200 FIND v(dout1_99) AT=605.025n

.meas tran vdout1_100ck1200 FIND v(dout1_100) AT=605.025n

.meas tran vdout1_101ck1200 FIND v(dout1_101) AT=605.025n

.meas tran vdout1_102ck1200 FIND v(dout1_102) AT=605.025n

.meas tran vdout1_103ck1200 FIND v(dout1_103) AT=605.025n

.meas tran vdout1_104ck1200 FIND v(dout1_104) AT=605.025n

.meas tran vdout1_105ck1200 FIND v(dout1_105) AT=605.025n

.meas tran vdout1_106ck1200 FIND v(dout1_106) AT=605.025n

.meas tran vdout1_107ck1200 FIND v(dout1_107) AT=605.025n

.meas tran vdout1_108ck1200 FIND v(dout1_108) AT=605.025n

.meas tran vdout1_109ck1200 FIND v(dout1_109) AT=605.025n

.meas tran vdout1_110ck1200 FIND v(dout1_110) AT=605.025n

.meas tran vdout1_111ck1200 FIND v(dout1_111) AT=605.025n

.meas tran vdout1_112ck1200 FIND v(dout1_112) AT=605.025n

.meas tran vdout1_113ck1200 FIND v(dout1_113) AT=605.025n

.meas tran vdout1_114ck1200 FIND v(dout1_114) AT=605.025n

.meas tran vdout1_115ck1200 FIND v(dout1_115) AT=605.025n

.meas tran vdout1_116ck1200 FIND v(dout1_116) AT=605.025n

.meas tran vdout1_117ck1200 FIND v(dout1_117) AT=605.025n

.meas tran vdout1_118ck1200 FIND v(dout1_118) AT=605.025n

.meas tran vdout1_119ck1200 FIND v(dout1_119) AT=605.025n

.meas tran vdout1_120ck1200 FIND v(dout1_120) AT=605.025n

.meas tran vdout1_121ck1200 FIND v(dout1_121) AT=605.025n

.meas tran vdout1_122ck1200 FIND v(dout1_122) AT=605.025n

.meas tran vdout1_123ck1200 FIND v(dout1_123) AT=605.025n

.meas tran vdout1_124ck1200 FIND v(dout1_124) AT=605.025n

.meas tran vdout1_125ck1200 FIND v(dout1_125) AT=605.025n

.meas tran vdout1_126ck1200 FIND v(dout1_126) AT=605.025n

.meas tran vdout1_127ck1200 FIND v(dout1_127) AT=605.025n

.meas tran vdout1_128ck1200 FIND v(dout1_128) AT=605.025n

.meas tran vdout1_129ck1200 FIND v(dout1_129) AT=605.025n

.meas tran vdout1_130ck1200 FIND v(dout1_130) AT=605.025n

.meas tran vdout1_131ck1200 FIND v(dout1_131) AT=605.025n

.meas tran vdout1_132ck1200 FIND v(dout1_132) AT=605.025n

.meas tran vdout1_133ck1200 FIND v(dout1_133) AT=605.025n

.meas tran vdout1_134ck1200 FIND v(dout1_134) AT=605.025n

.meas tran vdout1_135ck1200 FIND v(dout1_135) AT=605.025n

.meas tran vdout1_136ck1200 FIND v(dout1_136) AT=605.025n

.meas tran vdout1_137ck1200 FIND v(dout1_137) AT=605.025n

.meas tran vdout1_138ck1200 FIND v(dout1_138) AT=605.025n

.meas tran vdout1_139ck1200 FIND v(dout1_139) AT=605.025n

.meas tran vdout1_140ck1200 FIND v(dout1_140) AT=605.025n

.meas tran vdout1_141ck1200 FIND v(dout1_141) AT=605.025n

.meas tran vdout1_142ck1200 FIND v(dout1_142) AT=605.025n

.meas tran vdout1_143ck1200 FIND v(dout1_143) AT=605.025n

.meas tran vdout1_144ck1200 FIND v(dout1_144) AT=605.025n

.meas tran vdout1_145ck1200 FIND v(dout1_145) AT=605.025n

.meas tran vdout1_146ck1200 FIND v(dout1_146) AT=605.025n

.meas tran vdout1_147ck1200 FIND v(dout1_147) AT=605.025n

.meas tran vdout1_148ck1200 FIND v(dout1_148) AT=605.025n

.meas tran vdout1_149ck1200 FIND v(dout1_149) AT=605.025n

.meas tran vdout1_150ck1200 FIND v(dout1_150) AT=605.025n

.meas tran vdout1_151ck1200 FIND v(dout1_151) AT=605.025n

.meas tran vdout1_152ck1200 FIND v(dout1_152) AT=605.025n

.meas tran vdout1_153ck1200 FIND v(dout1_153) AT=605.025n

.meas tran vdout1_154ck1200 FIND v(dout1_154) AT=605.025n

.meas tran vdout1_155ck1200 FIND v(dout1_155) AT=605.025n

.meas tran vdout1_156ck1200 FIND v(dout1_156) AT=605.025n

.meas tran vdout1_157ck1200 FIND v(dout1_157) AT=605.025n

.meas tran vdout1_158ck1200 FIND v(dout1_158) AT=605.025n

.meas tran vdout1_159ck1200 FIND v(dout1_159) AT=605.025n

.meas tran vdout1_160ck1200 FIND v(dout1_160) AT=605.025n

.meas tran vdout1_161ck1200 FIND v(dout1_161) AT=605.025n

.meas tran vdout1_162ck1200 FIND v(dout1_162) AT=605.025n

.meas tran vdout1_163ck1200 FIND v(dout1_163) AT=605.025n

.meas tran vdout1_164ck1200 FIND v(dout1_164) AT=605.025n

.meas tran vdout1_165ck1200 FIND v(dout1_165) AT=605.025n

.meas tran vdout1_166ck1200 FIND v(dout1_166) AT=605.025n

.meas tran vdout1_167ck1200 FIND v(dout1_167) AT=605.025n

.meas tran vdout1_168ck1200 FIND v(dout1_168) AT=605.025n

.meas tran vdout1_169ck1200 FIND v(dout1_169) AT=605.025n

.meas tran vdout1_170ck1200 FIND v(dout1_170) AT=605.025n

.meas tran vdout1_171ck1200 FIND v(dout1_171) AT=605.025n

.meas tran vdout1_172ck1200 FIND v(dout1_172) AT=605.025n

.meas tran vdout1_173ck1200 FIND v(dout1_173) AT=605.025n

.meas tran vdout1_174ck1200 FIND v(dout1_174) AT=605.025n

.meas tran vdout1_175ck1200 FIND v(dout1_175) AT=605.025n

.meas tran vdout1_176ck1200 FIND v(dout1_176) AT=605.025n

.meas tran vdout1_177ck1200 FIND v(dout1_177) AT=605.025n

.meas tran vdout1_178ck1200 FIND v(dout1_178) AT=605.025n

.meas tran vdout1_179ck1200 FIND v(dout1_179) AT=605.025n

.meas tran vdout1_180ck1200 FIND v(dout1_180) AT=605.025n

.meas tran vdout1_181ck1200 FIND v(dout1_181) AT=605.025n

.meas tran vdout1_182ck1200 FIND v(dout1_182) AT=605.025n

.meas tran vdout1_183ck1200 FIND v(dout1_183) AT=605.025n

.meas tran vdout1_184ck1200 FIND v(dout1_184) AT=605.025n

.meas tran vdout1_185ck1200 FIND v(dout1_185) AT=605.025n

.meas tran vdout1_186ck1200 FIND v(dout1_186) AT=605.025n

.meas tran vdout1_187ck1200 FIND v(dout1_187) AT=605.025n

.meas tran vdout1_188ck1200 FIND v(dout1_188) AT=605.025n

.meas tran vdout1_189ck1200 FIND v(dout1_189) AT=605.025n

.meas tran vdout1_190ck1200 FIND v(dout1_190) AT=605.025n

.meas tran vdout1_191ck1200 FIND v(dout1_191) AT=605.025n

.meas tran vdout1_192ck1200 FIND v(dout1_192) AT=605.025n

.meas tran vdout1_193ck1200 FIND v(dout1_193) AT=605.025n

.meas tran vdout1_194ck1200 FIND v(dout1_194) AT=605.025n

.meas tran vdout1_195ck1200 FIND v(dout1_195) AT=605.025n

.meas tran vdout1_196ck1200 FIND v(dout1_196) AT=605.025n

.meas tran vdout1_197ck1200 FIND v(dout1_197) AT=605.025n

.meas tran vdout1_198ck1200 FIND v(dout1_198) AT=605.025n

.meas tran vdout1_199ck1200 FIND v(dout1_199) AT=605.025n

.meas tran vdout1_200ck1200 FIND v(dout1_200) AT=605.025n

.meas tran vdout1_201ck1200 FIND v(dout1_201) AT=605.025n

.meas tran vdout1_202ck1200 FIND v(dout1_202) AT=605.025n

.meas tran vdout1_203ck1200 FIND v(dout1_203) AT=605.025n

.meas tran vdout1_204ck1200 FIND v(dout1_204) AT=605.025n

.meas tran vdout1_205ck1200 FIND v(dout1_205) AT=605.025n

.meas tran vdout1_206ck1200 FIND v(dout1_206) AT=605.025n

.meas tran vdout1_207ck1200 FIND v(dout1_207) AT=605.025n

.meas tran vdout1_208ck1200 FIND v(dout1_208) AT=605.025n

.meas tran vdout1_209ck1200 FIND v(dout1_209) AT=605.025n

.meas tran vdout1_210ck1200 FIND v(dout1_210) AT=605.025n

.meas tran vdout1_211ck1200 FIND v(dout1_211) AT=605.025n

.meas tran vdout1_212ck1200 FIND v(dout1_212) AT=605.025n

.meas tran vdout1_213ck1200 FIND v(dout1_213) AT=605.025n

.meas tran vdout1_214ck1200 FIND v(dout1_214) AT=605.025n

.meas tran vdout1_215ck1200 FIND v(dout1_215) AT=605.025n

.meas tran vdout1_216ck1200 FIND v(dout1_216) AT=605.025n

.meas tran vdout1_217ck1200 FIND v(dout1_217) AT=605.025n

.meas tran vdout1_218ck1200 FIND v(dout1_218) AT=605.025n

.meas tran vdout1_219ck1200 FIND v(dout1_219) AT=605.025n

.meas tran vdout1_220ck1200 FIND v(dout1_220) AT=605.025n

.meas tran vdout1_221ck1200 FIND v(dout1_221) AT=605.025n

.meas tran vdout1_222ck1200 FIND v(dout1_222) AT=605.025n

.meas tran vdout1_223ck1200 FIND v(dout1_223) AT=605.025n

.meas tran vdout1_224ck1200 FIND v(dout1_224) AT=605.025n

.meas tran vdout1_225ck1200 FIND v(dout1_225) AT=605.025n

.meas tran vdout1_226ck1200 FIND v(dout1_226) AT=605.025n

.meas tran vdout1_227ck1200 FIND v(dout1_227) AT=605.025n

.meas tran vdout1_228ck1200 FIND v(dout1_228) AT=605.025n

.meas tran vdout1_229ck1200 FIND v(dout1_229) AT=605.025n

.meas tran vdout1_230ck1200 FIND v(dout1_230) AT=605.025n

.meas tran vdout1_231ck1200 FIND v(dout1_231) AT=605.025n

.meas tran vdout1_232ck1200 FIND v(dout1_232) AT=605.025n

.meas tran vdout1_233ck1200 FIND v(dout1_233) AT=605.025n

.meas tran vdout1_234ck1200 FIND v(dout1_234) AT=605.025n

.meas tran vdout1_235ck1200 FIND v(dout1_235) AT=605.025n

.meas tran vdout1_236ck1200 FIND v(dout1_236) AT=605.025n

.meas tran vdout1_237ck1200 FIND v(dout1_237) AT=605.025n

.meas tran vdout1_238ck1200 FIND v(dout1_238) AT=605.025n

.meas tran vdout1_239ck1200 FIND v(dout1_239) AT=605.025n

.meas tran vdout1_240ck1200 FIND v(dout1_240) AT=605.025n

.meas tran vdout1_241ck1200 FIND v(dout1_241) AT=605.025n

.meas tran vdout1_242ck1200 FIND v(dout1_242) AT=605.025n

.meas tran vdout1_243ck1200 FIND v(dout1_243) AT=605.025n

.meas tran vdout1_244ck1200 FIND v(dout1_244) AT=605.025n

.meas tran vdout1_245ck1200 FIND v(dout1_245) AT=605.025n

.meas tran vdout1_246ck1200 FIND v(dout1_246) AT=605.025n

.meas tran vdout1_247ck1200 FIND v(dout1_247) AT=605.025n

.meas tran vdout1_248ck1200 FIND v(dout1_248) AT=605.025n

.meas tran vdout1_249ck1200 FIND v(dout1_249) AT=605.025n

.meas tran vdout1_250ck1200 FIND v(dout1_250) AT=605.025n

.meas tran vdout1_251ck1200 FIND v(dout1_251) AT=605.025n

.meas tran vdout1_252ck1200 FIND v(dout1_252) AT=605.025n

.meas tran vdout1_253ck1200 FIND v(dout1_253) AT=605.025n

.meas tran vdout1_254ck1200 FIND v(dout1_254) AT=605.025n

.meas tran vdout1_255ck1200 FIND v(dout1_255) AT=605.025n

.meas tran vdout1_256ck1200 FIND v(dout1_256) AT=605.025n

.meas tran vdout1_257ck1200 FIND v(dout1_257) AT=605.025n

.meas tran vdout1_258ck1200 FIND v(dout1_258) AT=605.025n

.meas tran vdout1_259ck1200 FIND v(dout1_259) AT=605.025n

.meas tran vdout1_260ck1200 FIND v(dout1_260) AT=605.025n

.meas tran vdout1_261ck1200 FIND v(dout1_261) AT=605.025n

.meas tran vdout1_262ck1200 FIND v(dout1_262) AT=605.025n

.meas tran vdout1_263ck1200 FIND v(dout1_263) AT=605.025n

.meas tran vdout1_264ck1200 FIND v(dout1_264) AT=605.025n

.meas tran vdout1_265ck1200 FIND v(dout1_265) AT=605.025n

.meas tran vdout1_266ck1200 FIND v(dout1_266) AT=605.025n

.meas tran vdout1_267ck1200 FIND v(dout1_267) AT=605.025n

.meas tran vdout1_268ck1200 FIND v(dout1_268) AT=605.025n

.meas tran vdout1_269ck1200 FIND v(dout1_269) AT=605.025n

.meas tran vdout1_270ck1200 FIND v(dout1_270) AT=605.025n

.meas tran vdout1_271ck1200 FIND v(dout1_271) AT=605.025n

.meas tran vdout1_272ck1200 FIND v(dout1_272) AT=605.025n

.meas tran vdout1_273ck1200 FIND v(dout1_273) AT=605.025n

.meas tran vdout1_274ck1200 FIND v(dout1_274) AT=605.025n

.meas tran vdout1_275ck1200 FIND v(dout1_275) AT=605.025n

.meas tran vdout1_276ck1200 FIND v(dout1_276) AT=605.025n

.meas tran vdout1_277ck1200 FIND v(dout1_277) AT=605.025n

.meas tran vdout1_278ck1200 FIND v(dout1_278) AT=605.025n

.meas tran vdout1_279ck1200 FIND v(dout1_279) AT=605.025n

.meas tran vdout1_280ck1200 FIND v(dout1_280) AT=605.025n

.meas tran vdout1_281ck1200 FIND v(dout1_281) AT=605.025n

.meas tran vdout1_282ck1200 FIND v(dout1_282) AT=605.025n

.meas tran vdout1_283ck1200 FIND v(dout1_283) AT=605.025n

.meas tran vdout1_284ck1200 FIND v(dout1_284) AT=605.025n

.meas tran vdout1_285ck1200 FIND v(dout1_285) AT=605.025n

.meas tran vdout1_286ck1200 FIND v(dout1_286) AT=605.025n

.meas tran vdout1_287ck1200 FIND v(dout1_287) AT=605.025n

.meas tran vdout1_288ck1200 FIND v(dout1_288) AT=605.025n

.meas tran vdout1_289ck1200 FIND v(dout1_289) AT=605.025n

.meas tran vdout1_290ck1200 FIND v(dout1_290) AT=605.025n

.meas tran vdout1_291ck1200 FIND v(dout1_291) AT=605.025n

.meas tran vdout1_292ck1200 FIND v(dout1_292) AT=605.025n

.meas tran vdout1_293ck1200 FIND v(dout1_293) AT=605.025n

.meas tran vdout1_294ck1200 FIND v(dout1_294) AT=605.025n

.meas tran vdout1_295ck1200 FIND v(dout1_295) AT=605.025n

.meas tran vdout1_296ck1200 FIND v(dout1_296) AT=605.025n

.meas tran vdout1_297ck1200 FIND v(dout1_297) AT=605.025n

.meas tran vdout1_298ck1200 FIND v(dout1_298) AT=605.025n

.meas tran vdout1_299ck1200 FIND v(dout1_299) AT=605.025n

.meas tran vdout1_300ck1200 FIND v(dout1_300) AT=605.025n

.meas tran vdout1_301ck1200 FIND v(dout1_301) AT=605.025n

.meas tran vdout1_302ck1200 FIND v(dout1_302) AT=605.025n

.meas tran vdout1_303ck1200 FIND v(dout1_303) AT=605.025n

.meas tran vdout1_304ck1200 FIND v(dout1_304) AT=605.025n

.meas tran vdout1_305ck1200 FIND v(dout1_305) AT=605.025n

.meas tran vdout1_306ck1200 FIND v(dout1_306) AT=605.025n

.meas tran vdout1_307ck1200 FIND v(dout1_307) AT=605.025n

.meas tran vdout1_308ck1200 FIND v(dout1_308) AT=605.025n

.meas tran vdout1_309ck1200 FIND v(dout1_309) AT=605.025n

.meas tran vdout1_310ck1200 FIND v(dout1_310) AT=605.025n

.meas tran vdout1_311ck1200 FIND v(dout1_311) AT=605.025n

.meas tran vdout1_312ck1200 FIND v(dout1_312) AT=605.025n

.meas tran vdout1_313ck1200 FIND v(dout1_313) AT=605.025n

.meas tran vdout1_314ck1200 FIND v(dout1_314) AT=605.025n

.meas tran vdout1_315ck1200 FIND v(dout1_315) AT=605.025n

.meas tran vdout1_316ck1200 FIND v(dout1_316) AT=605.025n

.meas tran vdout1_317ck1200 FIND v(dout1_317) AT=605.025n

.meas tran vdout1_318ck1200 FIND v(dout1_318) AT=605.025n

.meas tran vdout1_319ck1200 FIND v(dout1_319) AT=605.025n

.meas tran vdout1_320ck1200 FIND v(dout1_320) AT=605.025n

.meas tran vdout1_321ck1200 FIND v(dout1_321) AT=605.025n

.meas tran vdout1_322ck1200 FIND v(dout1_322) AT=605.025n

.meas tran vdout1_323ck1200 FIND v(dout1_323) AT=605.025n

.meas tran vdout1_324ck1200 FIND v(dout1_324) AT=605.025n

.meas tran vdout1_325ck1200 FIND v(dout1_325) AT=605.025n

.meas tran vdout1_326ck1200 FIND v(dout1_326) AT=605.025n

.meas tran vdout1_327ck1200 FIND v(dout1_327) AT=605.025n

.meas tran vdout1_328ck1200 FIND v(dout1_328) AT=605.025n

.meas tran vdout1_329ck1200 FIND v(dout1_329) AT=605.025n

.meas tran vdout1_330ck1200 FIND v(dout1_330) AT=605.025n

.meas tran vdout1_331ck1200 FIND v(dout1_331) AT=605.025n

.meas tran vdout1_332ck1200 FIND v(dout1_332) AT=605.025n

.meas tran vdout1_333ck1200 FIND v(dout1_333) AT=605.025n

.meas tran vdout1_334ck1200 FIND v(dout1_334) AT=605.025n

.meas tran vdout1_335ck1200 FIND v(dout1_335) AT=605.025n

.meas tran vdout1_336ck1200 FIND v(dout1_336) AT=605.025n

.meas tran vdout1_337ck1200 FIND v(dout1_337) AT=605.025n

.meas tran vdout1_338ck1200 FIND v(dout1_338) AT=605.025n

.meas tran vdout1_339ck1200 FIND v(dout1_339) AT=605.025n

.meas tran vdout1_340ck1200 FIND v(dout1_340) AT=605.025n

.meas tran vdout1_341ck1200 FIND v(dout1_341) AT=605.025n

.meas tran vdout1_342ck1200 FIND v(dout1_342) AT=605.025n

.meas tran vdout1_343ck1200 FIND v(dout1_343) AT=605.025n

.meas tran vdout1_344ck1200 FIND v(dout1_344) AT=605.025n

.meas tran vdout1_345ck1200 FIND v(dout1_345) AT=605.025n

.meas tran vdout1_346ck1200 FIND v(dout1_346) AT=605.025n

.meas tran vdout1_347ck1200 FIND v(dout1_347) AT=605.025n

.meas tran vdout1_348ck1200 FIND v(dout1_348) AT=605.025n

.meas tran vdout1_349ck1200 FIND v(dout1_349) AT=605.025n

.meas tran vdout1_350ck1200 FIND v(dout1_350) AT=605.025n

.meas tran vdout1_351ck1200 FIND v(dout1_351) AT=605.025n

.meas tran vdout1_352ck1200 FIND v(dout1_352) AT=605.025n

.meas tran vdout1_353ck1200 FIND v(dout1_353) AT=605.025n

.meas tran vdout1_354ck1200 FIND v(dout1_354) AT=605.025n

.meas tran vdout1_355ck1200 FIND v(dout1_355) AT=605.025n

.meas tran vdout1_356ck1200 FIND v(dout1_356) AT=605.025n

.meas tran vdout1_357ck1200 FIND v(dout1_357) AT=605.025n

.meas tran vdout1_358ck1200 FIND v(dout1_358) AT=605.025n

.meas tran vdout1_359ck1200 FIND v(dout1_359) AT=605.025n

.meas tran vdout1_360ck1200 FIND v(dout1_360) AT=605.025n

.meas tran vdout1_361ck1200 FIND v(dout1_361) AT=605.025n

.meas tran vdout1_362ck1200 FIND v(dout1_362) AT=605.025n

.meas tran vdout1_363ck1200 FIND v(dout1_363) AT=605.025n

.meas tran vdout1_364ck1200 FIND v(dout1_364) AT=605.025n

.meas tran vdout1_365ck1200 FIND v(dout1_365) AT=605.025n

.meas tran vdout1_366ck1200 FIND v(dout1_366) AT=605.025n

.meas tran vdout1_367ck1200 FIND v(dout1_367) AT=605.025n

.meas tran vdout1_368ck1200 FIND v(dout1_368) AT=605.025n

.meas tran vdout1_369ck1200 FIND v(dout1_369) AT=605.025n

.meas tran vdout1_370ck1200 FIND v(dout1_370) AT=605.025n

.meas tran vdout1_371ck1200 FIND v(dout1_371) AT=605.025n

.meas tran vdout1_372ck1200 FIND v(dout1_372) AT=605.025n

.meas tran vdout1_373ck1200 FIND v(dout1_373) AT=605.025n

.meas tran vdout1_374ck1200 FIND v(dout1_374) AT=605.025n

.meas tran vdout1_375ck1200 FIND v(dout1_375) AT=605.025n

.meas tran vdout1_376ck1200 FIND v(dout1_376) AT=605.025n

.meas tran vdout1_377ck1200 FIND v(dout1_377) AT=605.025n

.meas tran vdout1_378ck1200 FIND v(dout1_378) AT=605.025n

.meas tran vdout1_379ck1200 FIND v(dout1_379) AT=605.025n

.meas tran vdout1_380ck1200 FIND v(dout1_380) AT=605.025n

.meas tran vdout1_381ck1200 FIND v(dout1_381) AT=605.025n

.meas tran vdout1_382ck1200 FIND v(dout1_382) AT=605.025n

.meas tran vdout1_383ck1200 FIND v(dout1_383) AT=605.025n

.meas tran vdout1_384ck1200 FIND v(dout1_384) AT=605.025n

.meas tran vdout1_385ck1200 FIND v(dout1_385) AT=605.025n

.meas tran vdout1_386ck1200 FIND v(dout1_386) AT=605.025n

.meas tran vdout1_387ck1200 FIND v(dout1_387) AT=605.025n

.meas tran vdout1_388ck1200 FIND v(dout1_388) AT=605.025n

.meas tran vdout1_389ck1200 FIND v(dout1_389) AT=605.025n

.meas tran vdout1_390ck1200 FIND v(dout1_390) AT=605.025n

.meas tran vdout1_391ck1200 FIND v(dout1_391) AT=605.025n

.meas tran vdout1_392ck1200 FIND v(dout1_392) AT=605.025n

.meas tran vdout1_393ck1200 FIND v(dout1_393) AT=605.025n

.meas tran vdout1_394ck1200 FIND v(dout1_394) AT=605.025n

.meas tran vdout1_395ck1200 FIND v(dout1_395) AT=605.025n

.meas tran vdout1_396ck1200 FIND v(dout1_396) AT=605.025n

.meas tran vdout1_397ck1200 FIND v(dout1_397) AT=605.025n

.meas tran vdout1_398ck1200 FIND v(dout1_398) AT=605.025n

.meas tran vdout1_399ck1200 FIND v(dout1_399) AT=605.025n

.meas tran vdout1_400ck1200 FIND v(dout1_400) AT=605.025n

.meas tran vdout1_401ck1200 FIND v(dout1_401) AT=605.025n

.meas tran vdout1_402ck1200 FIND v(dout1_402) AT=605.025n

.meas tran vdout1_403ck1200 FIND v(dout1_403) AT=605.025n

.meas tran vdout1_404ck1200 FIND v(dout1_404) AT=605.025n

.meas tran vdout1_405ck1200 FIND v(dout1_405) AT=605.025n

.meas tran vdout1_406ck1200 FIND v(dout1_406) AT=605.025n

.meas tran vdout1_407ck1200 FIND v(dout1_407) AT=605.025n

.meas tran vdout1_408ck1200 FIND v(dout1_408) AT=605.025n

.meas tran vdout1_409ck1200 FIND v(dout1_409) AT=605.025n

.meas tran vdout1_410ck1200 FIND v(dout1_410) AT=605.025n

.meas tran vdout1_411ck1200 FIND v(dout1_411) AT=605.025n

.meas tran vdout1_412ck1200 FIND v(dout1_412) AT=605.025n

.meas tran vdout1_413ck1200 FIND v(dout1_413) AT=605.025n

.meas tran vdout1_414ck1200 FIND v(dout1_414) AT=605.025n

.meas tran vdout1_415ck1200 FIND v(dout1_415) AT=605.025n

.meas tran vdout1_416ck1200 FIND v(dout1_416) AT=605.025n

.meas tran vdout1_417ck1200 FIND v(dout1_417) AT=605.025n

.meas tran vdout1_418ck1200 FIND v(dout1_418) AT=605.025n

.meas tran vdout1_419ck1200 FIND v(dout1_419) AT=605.025n

.meas tran vdout1_420ck1200 FIND v(dout1_420) AT=605.025n

.meas tran vdout1_421ck1200 FIND v(dout1_421) AT=605.025n

.meas tran vdout1_422ck1200 FIND v(dout1_422) AT=605.025n

.meas tran vdout1_423ck1200 FIND v(dout1_423) AT=605.025n

.meas tran vdout1_424ck1200 FIND v(dout1_424) AT=605.025n

.meas tran vdout1_425ck1200 FIND v(dout1_425) AT=605.025n

.meas tran vdout1_426ck1200 FIND v(dout1_426) AT=605.025n

.meas tran vdout1_427ck1200 FIND v(dout1_427) AT=605.025n

.meas tran vdout1_428ck1200 FIND v(dout1_428) AT=605.025n

.meas tran vdout1_429ck1200 FIND v(dout1_429) AT=605.025n

.meas tran vdout1_430ck1200 FIND v(dout1_430) AT=605.025n

.meas tran vdout1_431ck1200 FIND v(dout1_431) AT=605.025n

.meas tran vdout1_432ck1200 FIND v(dout1_432) AT=605.025n

.meas tran vdout1_433ck1200 FIND v(dout1_433) AT=605.025n

.meas tran vdout1_434ck1200 FIND v(dout1_434) AT=605.025n

.meas tran vdout1_435ck1200 FIND v(dout1_435) AT=605.025n

.meas tran vdout1_436ck1200 FIND v(dout1_436) AT=605.025n

.meas tran vdout1_437ck1200 FIND v(dout1_437) AT=605.025n

.meas tran vdout1_438ck1200 FIND v(dout1_438) AT=605.025n

.meas tran vdout1_439ck1200 FIND v(dout1_439) AT=605.025n

.meas tran vdout1_440ck1200 FIND v(dout1_440) AT=605.025n

.meas tran vdout1_441ck1200 FIND v(dout1_441) AT=605.025n

.meas tran vdout1_442ck1200 FIND v(dout1_442) AT=605.025n

.meas tran vdout1_443ck1200 FIND v(dout1_443) AT=605.025n

.meas tran vdout1_444ck1200 FIND v(dout1_444) AT=605.025n

.meas tran vdout1_445ck1200 FIND v(dout1_445) AT=605.025n

.meas tran vdout1_446ck1200 FIND v(dout1_446) AT=605.025n

.meas tran vdout1_447ck1200 FIND v(dout1_447) AT=605.025n

.meas tran vdout1_448ck1200 FIND v(dout1_448) AT=605.025n

.meas tran vdout1_449ck1200 FIND v(dout1_449) AT=605.025n

.meas tran vdout1_450ck1200 FIND v(dout1_450) AT=605.025n

.meas tran vdout1_451ck1200 FIND v(dout1_451) AT=605.025n

.meas tran vdout1_452ck1200 FIND v(dout1_452) AT=605.025n

.meas tran vdout1_453ck1200 FIND v(dout1_453) AT=605.025n

.meas tran vdout1_454ck1200 FIND v(dout1_454) AT=605.025n

.meas tran vdout1_455ck1200 FIND v(dout1_455) AT=605.025n

.meas tran vdout1_456ck1200 FIND v(dout1_456) AT=605.025n

.meas tran vdout1_457ck1200 FIND v(dout1_457) AT=605.025n

.meas tran vdout1_458ck1200 FIND v(dout1_458) AT=605.025n

.meas tran vdout1_459ck1200 FIND v(dout1_459) AT=605.025n

.meas tran vdout1_460ck1200 FIND v(dout1_460) AT=605.025n

.meas tran vdout1_461ck1200 FIND v(dout1_461) AT=605.025n

.meas tran vdout1_462ck1200 FIND v(dout1_462) AT=605.025n

.meas tran vdout1_463ck1200 FIND v(dout1_463) AT=605.025n

.meas tran vdout1_464ck1200 FIND v(dout1_464) AT=605.025n

.meas tran vdout1_465ck1200 FIND v(dout1_465) AT=605.025n

.meas tran vdout1_466ck1200 FIND v(dout1_466) AT=605.025n

.meas tran vdout1_467ck1200 FIND v(dout1_467) AT=605.025n

.meas tran vdout1_468ck1200 FIND v(dout1_468) AT=605.025n

.meas tran vdout1_469ck1200 FIND v(dout1_469) AT=605.025n

.meas tran vdout1_470ck1200 FIND v(dout1_470) AT=605.025n

.meas tran vdout1_471ck1200 FIND v(dout1_471) AT=605.025n

.meas tran vdout1_472ck1200 FIND v(dout1_472) AT=605.025n

.meas tran vdout1_473ck1200 FIND v(dout1_473) AT=605.025n

.meas tran vdout1_474ck1200 FIND v(dout1_474) AT=605.025n

.meas tran vdout1_475ck1200 FIND v(dout1_475) AT=605.025n

.meas tran vdout1_476ck1200 FIND v(dout1_476) AT=605.025n

.meas tran vdout1_477ck1200 FIND v(dout1_477) AT=605.025n

.meas tran vdout1_478ck1200 FIND v(dout1_478) AT=605.025n

.meas tran vdout1_479ck1200 FIND v(dout1_479) AT=605.025n

.meas tran vdout1_480ck1200 FIND v(dout1_480) AT=605.025n

.meas tran vdout1_481ck1200 FIND v(dout1_481) AT=605.025n

.meas tran vdout1_482ck1200 FIND v(dout1_482) AT=605.025n

.meas tran vdout1_483ck1200 FIND v(dout1_483) AT=605.025n

.meas tran vdout1_484ck1200 FIND v(dout1_484) AT=605.025n

.meas tran vdout1_485ck1200 FIND v(dout1_485) AT=605.025n

.meas tran vdout1_486ck1200 FIND v(dout1_486) AT=605.025n

.meas tran vdout1_487ck1200 FIND v(dout1_487) AT=605.025n

.meas tran vdout1_488ck1200 FIND v(dout1_488) AT=605.025n

.meas tran vdout1_489ck1200 FIND v(dout1_489) AT=605.025n

.meas tran vdout1_490ck1200 FIND v(dout1_490) AT=605.025n

.meas tran vdout1_491ck1200 FIND v(dout1_491) AT=605.025n

.meas tran vdout1_492ck1200 FIND v(dout1_492) AT=605.025n

.meas tran vdout1_493ck1200 FIND v(dout1_493) AT=605.025n

.meas tran vdout1_494ck1200 FIND v(dout1_494) AT=605.025n

.meas tran vdout1_495ck1200 FIND v(dout1_495) AT=605.025n

.meas tran vdout1_496ck1200 FIND v(dout1_496) AT=605.025n

.meas tran vdout1_497ck1200 FIND v(dout1_497) AT=605.025n

.meas tran vdout1_498ck1200 FIND v(dout1_498) AT=605.025n

.meas tran vdout1_499ck1200 FIND v(dout1_499) AT=605.025n

.meas tran vdout1_500ck1200 FIND v(dout1_500) AT=605.025n

.meas tran vdout1_501ck1200 FIND v(dout1_501) AT=605.025n

.meas tran vdout1_502ck1200 FIND v(dout1_502) AT=605.025n

.meas tran vdout1_503ck1200 FIND v(dout1_503) AT=605.025n

.meas tran vdout1_504ck1200 FIND v(dout1_504) AT=605.025n

.meas tran vdout1_505ck1200 FIND v(dout1_505) AT=605.025n

.meas tran vdout1_506ck1200 FIND v(dout1_506) AT=605.025n

.meas tran vdout1_507ck1200 FIND v(dout1_507) AT=605.025n

.meas tran vdout1_508ck1200 FIND v(dout1_508) AT=605.025n

.meas tran vdout1_509ck1200 FIND v(dout1_509) AT=605.025n

.meas tran vdout1_510ck1200 FIND v(dout1_510) AT=605.025n

.meas tran vdout1_511ck1200 FIND v(dout1_511) AT=605.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_22ck1280 FIND v(dout1_22) AT=645.025n

.meas tran vdout1_23ck1280 FIND v(dout1_23) AT=645.025n

.meas tran vdout1_24ck1280 FIND v(dout1_24) AT=645.025n

.meas tran vdout1_25ck1280 FIND v(dout1_25) AT=645.025n

.meas tran vdout1_26ck1280 FIND v(dout1_26) AT=645.025n

.meas tran vdout1_27ck1280 FIND v(dout1_27) AT=645.025n

.meas tran vdout1_28ck1280 FIND v(dout1_28) AT=645.025n

.meas tran vdout1_29ck1280 FIND v(dout1_29) AT=645.025n

.meas tran vdout1_30ck1280 FIND v(dout1_30) AT=645.025n

.meas tran vdout1_31ck1280 FIND v(dout1_31) AT=645.025n

.meas tran vdout1_32ck1280 FIND v(dout1_32) AT=645.025n

.meas tran vdout1_33ck1280 FIND v(dout1_33) AT=645.025n

.meas tran vdout1_34ck1280 FIND v(dout1_34) AT=645.025n

.meas tran vdout1_35ck1280 FIND v(dout1_35) AT=645.025n

.meas tran vdout1_36ck1280 FIND v(dout1_36) AT=645.025n

.meas tran vdout1_37ck1280 FIND v(dout1_37) AT=645.025n

.meas tran vdout1_38ck1280 FIND v(dout1_38) AT=645.025n

.meas tran vdout1_39ck1280 FIND v(dout1_39) AT=645.025n

.meas tran vdout1_40ck1280 FIND v(dout1_40) AT=645.025n

.meas tran vdout1_41ck1280 FIND v(dout1_41) AT=645.025n

.meas tran vdout1_42ck1280 FIND v(dout1_42) AT=645.025n

.meas tran vdout1_43ck1280 FIND v(dout1_43) AT=645.025n

.meas tran vdout1_44ck1280 FIND v(dout1_44) AT=645.025n

.meas tran vdout1_45ck1280 FIND v(dout1_45) AT=645.025n

.meas tran vdout1_46ck1280 FIND v(dout1_46) AT=645.025n

.meas tran vdout1_47ck1280 FIND v(dout1_47) AT=645.025n

.meas tran vdout1_48ck1280 FIND v(dout1_48) AT=645.025n

.meas tran vdout1_49ck1280 FIND v(dout1_49) AT=645.025n

.meas tran vdout1_50ck1280 FIND v(dout1_50) AT=645.025n

.meas tran vdout1_51ck1280 FIND v(dout1_51) AT=645.025n

.meas tran vdout1_52ck1280 FIND v(dout1_52) AT=645.025n

.meas tran vdout1_53ck1280 FIND v(dout1_53) AT=645.025n

.meas tran vdout1_54ck1280 FIND v(dout1_54) AT=645.025n

.meas tran vdout1_55ck1280 FIND v(dout1_55) AT=645.025n

.meas tran vdout1_56ck1280 FIND v(dout1_56) AT=645.025n

.meas tran vdout1_57ck1280 FIND v(dout1_57) AT=645.025n

.meas tran vdout1_58ck1280 FIND v(dout1_58) AT=645.025n

.meas tran vdout1_59ck1280 FIND v(dout1_59) AT=645.025n

.meas tran vdout1_60ck1280 FIND v(dout1_60) AT=645.025n

.meas tran vdout1_61ck1280 FIND v(dout1_61) AT=645.025n

.meas tran vdout1_62ck1280 FIND v(dout1_62) AT=645.025n

.meas tran vdout1_63ck1280 FIND v(dout1_63) AT=645.025n

.meas tran vdout1_64ck1280 FIND v(dout1_64) AT=645.025n

.meas tran vdout1_65ck1280 FIND v(dout1_65) AT=645.025n

.meas tran vdout1_66ck1280 FIND v(dout1_66) AT=645.025n

.meas tran vdout1_67ck1280 FIND v(dout1_67) AT=645.025n

.meas tran vdout1_68ck1280 FIND v(dout1_68) AT=645.025n

.meas tran vdout1_69ck1280 FIND v(dout1_69) AT=645.025n

.meas tran vdout1_70ck1280 FIND v(dout1_70) AT=645.025n

.meas tran vdout1_71ck1280 FIND v(dout1_71) AT=645.025n

.meas tran vdout1_72ck1280 FIND v(dout1_72) AT=645.025n

.meas tran vdout1_73ck1280 FIND v(dout1_73) AT=645.025n

.meas tran vdout1_74ck1280 FIND v(dout1_74) AT=645.025n

.meas tran vdout1_75ck1280 FIND v(dout1_75) AT=645.025n

.meas tran vdout1_76ck1280 FIND v(dout1_76) AT=645.025n

.meas tran vdout1_77ck1280 FIND v(dout1_77) AT=645.025n

.meas tran vdout1_78ck1280 FIND v(dout1_78) AT=645.025n

.meas tran vdout1_79ck1280 FIND v(dout1_79) AT=645.025n

.meas tran vdout1_80ck1280 FIND v(dout1_80) AT=645.025n

.meas tran vdout1_81ck1280 FIND v(dout1_81) AT=645.025n

.meas tran vdout1_82ck1280 FIND v(dout1_82) AT=645.025n

.meas tran vdout1_83ck1280 FIND v(dout1_83) AT=645.025n

.meas tran vdout1_84ck1280 FIND v(dout1_84) AT=645.025n

.meas tran vdout1_85ck1280 FIND v(dout1_85) AT=645.025n

.meas tran vdout1_86ck1280 FIND v(dout1_86) AT=645.025n

.meas tran vdout1_87ck1280 FIND v(dout1_87) AT=645.025n

.meas tran vdout1_88ck1280 FIND v(dout1_88) AT=645.025n

.meas tran vdout1_89ck1280 FIND v(dout1_89) AT=645.025n

.meas tran vdout1_90ck1280 FIND v(dout1_90) AT=645.025n

.meas tran vdout1_91ck1280 FIND v(dout1_91) AT=645.025n

.meas tran vdout1_92ck1280 FIND v(dout1_92) AT=645.025n

.meas tran vdout1_93ck1280 FIND v(dout1_93) AT=645.025n

.meas tran vdout1_94ck1280 FIND v(dout1_94) AT=645.025n

.meas tran vdout1_95ck1280 FIND v(dout1_95) AT=645.025n

.meas tran vdout1_96ck1280 FIND v(dout1_96) AT=645.025n

.meas tran vdout1_97ck1280 FIND v(dout1_97) AT=645.025n

.meas tran vdout1_98ck1280 FIND v(dout1_98) AT=645.025n

.meas tran vdout1_99ck1280 FIND v(dout1_99) AT=645.025n

.meas tran vdout1_100ck1280 FIND v(dout1_100) AT=645.025n

.meas tran vdout1_101ck1280 FIND v(dout1_101) AT=645.025n

.meas tran vdout1_102ck1280 FIND v(dout1_102) AT=645.025n

.meas tran vdout1_103ck1280 FIND v(dout1_103) AT=645.025n

.meas tran vdout1_104ck1280 FIND v(dout1_104) AT=645.025n

.meas tran vdout1_105ck1280 FIND v(dout1_105) AT=645.025n

.meas tran vdout1_106ck1280 FIND v(dout1_106) AT=645.025n

.meas tran vdout1_107ck1280 FIND v(dout1_107) AT=645.025n

.meas tran vdout1_108ck1280 FIND v(dout1_108) AT=645.025n

.meas tran vdout1_109ck1280 FIND v(dout1_109) AT=645.025n

.meas tran vdout1_110ck1280 FIND v(dout1_110) AT=645.025n

.meas tran vdout1_111ck1280 FIND v(dout1_111) AT=645.025n

.meas tran vdout1_112ck1280 FIND v(dout1_112) AT=645.025n

.meas tran vdout1_113ck1280 FIND v(dout1_113) AT=645.025n

.meas tran vdout1_114ck1280 FIND v(dout1_114) AT=645.025n

.meas tran vdout1_115ck1280 FIND v(dout1_115) AT=645.025n

.meas tran vdout1_116ck1280 FIND v(dout1_116) AT=645.025n

.meas tran vdout1_117ck1280 FIND v(dout1_117) AT=645.025n

.meas tran vdout1_118ck1280 FIND v(dout1_118) AT=645.025n

.meas tran vdout1_119ck1280 FIND v(dout1_119) AT=645.025n

.meas tran vdout1_120ck1280 FIND v(dout1_120) AT=645.025n

.meas tran vdout1_121ck1280 FIND v(dout1_121) AT=645.025n

.meas tran vdout1_122ck1280 FIND v(dout1_122) AT=645.025n

.meas tran vdout1_123ck1280 FIND v(dout1_123) AT=645.025n

.meas tran vdout1_124ck1280 FIND v(dout1_124) AT=645.025n

.meas tran vdout1_125ck1280 FIND v(dout1_125) AT=645.025n

.meas tran vdout1_126ck1280 FIND v(dout1_126) AT=645.025n

.meas tran vdout1_127ck1280 FIND v(dout1_127) AT=645.025n

.meas tran vdout1_128ck1280 FIND v(dout1_128) AT=645.025n

.meas tran vdout1_129ck1280 FIND v(dout1_129) AT=645.025n

.meas tran vdout1_130ck1280 FIND v(dout1_130) AT=645.025n

.meas tran vdout1_131ck1280 FIND v(dout1_131) AT=645.025n

.meas tran vdout1_132ck1280 FIND v(dout1_132) AT=645.025n

.meas tran vdout1_133ck1280 FIND v(dout1_133) AT=645.025n

.meas tran vdout1_134ck1280 FIND v(dout1_134) AT=645.025n

.meas tran vdout1_135ck1280 FIND v(dout1_135) AT=645.025n

.meas tran vdout1_136ck1280 FIND v(dout1_136) AT=645.025n

.meas tran vdout1_137ck1280 FIND v(dout1_137) AT=645.025n

.meas tran vdout1_138ck1280 FIND v(dout1_138) AT=645.025n

.meas tran vdout1_139ck1280 FIND v(dout1_139) AT=645.025n

.meas tran vdout1_140ck1280 FIND v(dout1_140) AT=645.025n

.meas tran vdout1_141ck1280 FIND v(dout1_141) AT=645.025n

.meas tran vdout1_142ck1280 FIND v(dout1_142) AT=645.025n

.meas tran vdout1_143ck1280 FIND v(dout1_143) AT=645.025n

.meas tran vdout1_144ck1280 FIND v(dout1_144) AT=645.025n

.meas tran vdout1_145ck1280 FIND v(dout1_145) AT=645.025n

.meas tran vdout1_146ck1280 FIND v(dout1_146) AT=645.025n

.meas tran vdout1_147ck1280 FIND v(dout1_147) AT=645.025n

.meas tran vdout1_148ck1280 FIND v(dout1_148) AT=645.025n

.meas tran vdout1_149ck1280 FIND v(dout1_149) AT=645.025n

.meas tran vdout1_150ck1280 FIND v(dout1_150) AT=645.025n

.meas tran vdout1_151ck1280 FIND v(dout1_151) AT=645.025n

.meas tran vdout1_152ck1280 FIND v(dout1_152) AT=645.025n

.meas tran vdout1_153ck1280 FIND v(dout1_153) AT=645.025n

.meas tran vdout1_154ck1280 FIND v(dout1_154) AT=645.025n

.meas tran vdout1_155ck1280 FIND v(dout1_155) AT=645.025n

.meas tran vdout1_156ck1280 FIND v(dout1_156) AT=645.025n

.meas tran vdout1_157ck1280 FIND v(dout1_157) AT=645.025n

.meas tran vdout1_158ck1280 FIND v(dout1_158) AT=645.025n

.meas tran vdout1_159ck1280 FIND v(dout1_159) AT=645.025n

.meas tran vdout1_160ck1280 FIND v(dout1_160) AT=645.025n

.meas tran vdout1_161ck1280 FIND v(dout1_161) AT=645.025n

.meas tran vdout1_162ck1280 FIND v(dout1_162) AT=645.025n

.meas tran vdout1_163ck1280 FIND v(dout1_163) AT=645.025n

.meas tran vdout1_164ck1280 FIND v(dout1_164) AT=645.025n

.meas tran vdout1_165ck1280 FIND v(dout1_165) AT=645.025n

.meas tran vdout1_166ck1280 FIND v(dout1_166) AT=645.025n

.meas tran vdout1_167ck1280 FIND v(dout1_167) AT=645.025n

.meas tran vdout1_168ck1280 FIND v(dout1_168) AT=645.025n

.meas tran vdout1_169ck1280 FIND v(dout1_169) AT=645.025n

.meas tran vdout1_170ck1280 FIND v(dout1_170) AT=645.025n

.meas tran vdout1_171ck1280 FIND v(dout1_171) AT=645.025n

.meas tran vdout1_172ck1280 FIND v(dout1_172) AT=645.025n

.meas tran vdout1_173ck1280 FIND v(dout1_173) AT=645.025n

.meas tran vdout1_174ck1280 FIND v(dout1_174) AT=645.025n

.meas tran vdout1_175ck1280 FIND v(dout1_175) AT=645.025n

.meas tran vdout1_176ck1280 FIND v(dout1_176) AT=645.025n

.meas tran vdout1_177ck1280 FIND v(dout1_177) AT=645.025n

.meas tran vdout1_178ck1280 FIND v(dout1_178) AT=645.025n

.meas tran vdout1_179ck1280 FIND v(dout1_179) AT=645.025n

.meas tran vdout1_180ck1280 FIND v(dout1_180) AT=645.025n

.meas tran vdout1_181ck1280 FIND v(dout1_181) AT=645.025n

.meas tran vdout1_182ck1280 FIND v(dout1_182) AT=645.025n

.meas tran vdout1_183ck1280 FIND v(dout1_183) AT=645.025n

.meas tran vdout1_184ck1280 FIND v(dout1_184) AT=645.025n

.meas tran vdout1_185ck1280 FIND v(dout1_185) AT=645.025n

.meas tran vdout1_186ck1280 FIND v(dout1_186) AT=645.025n

.meas tran vdout1_187ck1280 FIND v(dout1_187) AT=645.025n

.meas tran vdout1_188ck1280 FIND v(dout1_188) AT=645.025n

.meas tran vdout1_189ck1280 FIND v(dout1_189) AT=645.025n

.meas tran vdout1_190ck1280 FIND v(dout1_190) AT=645.025n

.meas tran vdout1_191ck1280 FIND v(dout1_191) AT=645.025n

.meas tran vdout1_192ck1280 FIND v(dout1_192) AT=645.025n

.meas tran vdout1_193ck1280 FIND v(dout1_193) AT=645.025n

.meas tran vdout1_194ck1280 FIND v(dout1_194) AT=645.025n

.meas tran vdout1_195ck1280 FIND v(dout1_195) AT=645.025n

.meas tran vdout1_196ck1280 FIND v(dout1_196) AT=645.025n

.meas tran vdout1_197ck1280 FIND v(dout1_197) AT=645.025n

.meas tran vdout1_198ck1280 FIND v(dout1_198) AT=645.025n

.meas tran vdout1_199ck1280 FIND v(dout1_199) AT=645.025n

.meas tran vdout1_200ck1280 FIND v(dout1_200) AT=645.025n

.meas tran vdout1_201ck1280 FIND v(dout1_201) AT=645.025n

.meas tran vdout1_202ck1280 FIND v(dout1_202) AT=645.025n

.meas tran vdout1_203ck1280 FIND v(dout1_203) AT=645.025n

.meas tran vdout1_204ck1280 FIND v(dout1_204) AT=645.025n

.meas tran vdout1_205ck1280 FIND v(dout1_205) AT=645.025n

.meas tran vdout1_206ck1280 FIND v(dout1_206) AT=645.025n

.meas tran vdout1_207ck1280 FIND v(dout1_207) AT=645.025n

.meas tran vdout1_208ck1280 FIND v(dout1_208) AT=645.025n

.meas tran vdout1_209ck1280 FIND v(dout1_209) AT=645.025n

.meas tran vdout1_210ck1280 FIND v(dout1_210) AT=645.025n

.meas tran vdout1_211ck1280 FIND v(dout1_211) AT=645.025n

.meas tran vdout1_212ck1280 FIND v(dout1_212) AT=645.025n

.meas tran vdout1_213ck1280 FIND v(dout1_213) AT=645.025n

.meas tran vdout1_214ck1280 FIND v(dout1_214) AT=645.025n

.meas tran vdout1_215ck1280 FIND v(dout1_215) AT=645.025n

.meas tran vdout1_216ck1280 FIND v(dout1_216) AT=645.025n

.meas tran vdout1_217ck1280 FIND v(dout1_217) AT=645.025n

.meas tran vdout1_218ck1280 FIND v(dout1_218) AT=645.025n

.meas tran vdout1_219ck1280 FIND v(dout1_219) AT=645.025n

.meas tran vdout1_220ck1280 FIND v(dout1_220) AT=645.025n

.meas tran vdout1_221ck1280 FIND v(dout1_221) AT=645.025n

.meas tran vdout1_222ck1280 FIND v(dout1_222) AT=645.025n

.meas tran vdout1_223ck1280 FIND v(dout1_223) AT=645.025n

.meas tran vdout1_224ck1280 FIND v(dout1_224) AT=645.025n

.meas tran vdout1_225ck1280 FIND v(dout1_225) AT=645.025n

.meas tran vdout1_226ck1280 FIND v(dout1_226) AT=645.025n

.meas tran vdout1_227ck1280 FIND v(dout1_227) AT=645.025n

.meas tran vdout1_228ck1280 FIND v(dout1_228) AT=645.025n

.meas tran vdout1_229ck1280 FIND v(dout1_229) AT=645.025n

.meas tran vdout1_230ck1280 FIND v(dout1_230) AT=645.025n

.meas tran vdout1_231ck1280 FIND v(dout1_231) AT=645.025n

.meas tran vdout1_232ck1280 FIND v(dout1_232) AT=645.025n

.meas tran vdout1_233ck1280 FIND v(dout1_233) AT=645.025n

.meas tran vdout1_234ck1280 FIND v(dout1_234) AT=645.025n

.meas tran vdout1_235ck1280 FIND v(dout1_235) AT=645.025n

.meas tran vdout1_236ck1280 FIND v(dout1_236) AT=645.025n

.meas tran vdout1_237ck1280 FIND v(dout1_237) AT=645.025n

.meas tran vdout1_238ck1280 FIND v(dout1_238) AT=645.025n

.meas tran vdout1_239ck1280 FIND v(dout1_239) AT=645.025n

.meas tran vdout1_240ck1280 FIND v(dout1_240) AT=645.025n

.meas tran vdout1_241ck1280 FIND v(dout1_241) AT=645.025n

.meas tran vdout1_242ck1280 FIND v(dout1_242) AT=645.025n

.meas tran vdout1_243ck1280 FIND v(dout1_243) AT=645.025n

.meas tran vdout1_244ck1280 FIND v(dout1_244) AT=645.025n

.meas tran vdout1_245ck1280 FIND v(dout1_245) AT=645.025n

.meas tran vdout1_246ck1280 FIND v(dout1_246) AT=645.025n

.meas tran vdout1_247ck1280 FIND v(dout1_247) AT=645.025n

.meas tran vdout1_248ck1280 FIND v(dout1_248) AT=645.025n

.meas tran vdout1_249ck1280 FIND v(dout1_249) AT=645.025n

.meas tran vdout1_250ck1280 FIND v(dout1_250) AT=645.025n

.meas tran vdout1_251ck1280 FIND v(dout1_251) AT=645.025n

.meas tran vdout1_252ck1280 FIND v(dout1_252) AT=645.025n

.meas tran vdout1_253ck1280 FIND v(dout1_253) AT=645.025n

.meas tran vdout1_254ck1280 FIND v(dout1_254) AT=645.025n

.meas tran vdout1_255ck1280 FIND v(dout1_255) AT=645.025n

.meas tran vdout1_256ck1280 FIND v(dout1_256) AT=645.025n

.meas tran vdout1_257ck1280 FIND v(dout1_257) AT=645.025n

.meas tran vdout1_258ck1280 FIND v(dout1_258) AT=645.025n

.meas tran vdout1_259ck1280 FIND v(dout1_259) AT=645.025n

.meas tran vdout1_260ck1280 FIND v(dout1_260) AT=645.025n

.meas tran vdout1_261ck1280 FIND v(dout1_261) AT=645.025n

.meas tran vdout1_262ck1280 FIND v(dout1_262) AT=645.025n

.meas tran vdout1_263ck1280 FIND v(dout1_263) AT=645.025n

.meas tran vdout1_264ck1280 FIND v(dout1_264) AT=645.025n

.meas tran vdout1_265ck1280 FIND v(dout1_265) AT=645.025n

.meas tran vdout1_266ck1280 FIND v(dout1_266) AT=645.025n

.meas tran vdout1_267ck1280 FIND v(dout1_267) AT=645.025n

.meas tran vdout1_268ck1280 FIND v(dout1_268) AT=645.025n

.meas tran vdout1_269ck1280 FIND v(dout1_269) AT=645.025n

.meas tran vdout1_270ck1280 FIND v(dout1_270) AT=645.025n

.meas tran vdout1_271ck1280 FIND v(dout1_271) AT=645.025n

.meas tran vdout1_272ck1280 FIND v(dout1_272) AT=645.025n

.meas tran vdout1_273ck1280 FIND v(dout1_273) AT=645.025n

.meas tran vdout1_274ck1280 FIND v(dout1_274) AT=645.025n

.meas tran vdout1_275ck1280 FIND v(dout1_275) AT=645.025n

.meas tran vdout1_276ck1280 FIND v(dout1_276) AT=645.025n

.meas tran vdout1_277ck1280 FIND v(dout1_277) AT=645.025n

.meas tran vdout1_278ck1280 FIND v(dout1_278) AT=645.025n

.meas tran vdout1_279ck1280 FIND v(dout1_279) AT=645.025n

.meas tran vdout1_280ck1280 FIND v(dout1_280) AT=645.025n

.meas tran vdout1_281ck1280 FIND v(dout1_281) AT=645.025n

.meas tran vdout1_282ck1280 FIND v(dout1_282) AT=645.025n

.meas tran vdout1_283ck1280 FIND v(dout1_283) AT=645.025n

.meas tran vdout1_284ck1280 FIND v(dout1_284) AT=645.025n

.meas tran vdout1_285ck1280 FIND v(dout1_285) AT=645.025n

.meas tran vdout1_286ck1280 FIND v(dout1_286) AT=645.025n

.meas tran vdout1_287ck1280 FIND v(dout1_287) AT=645.025n

.meas tran vdout1_288ck1280 FIND v(dout1_288) AT=645.025n

.meas tran vdout1_289ck1280 FIND v(dout1_289) AT=645.025n

.meas tran vdout1_290ck1280 FIND v(dout1_290) AT=645.025n

.meas tran vdout1_291ck1280 FIND v(dout1_291) AT=645.025n

.meas tran vdout1_292ck1280 FIND v(dout1_292) AT=645.025n

.meas tran vdout1_293ck1280 FIND v(dout1_293) AT=645.025n

.meas tran vdout1_294ck1280 FIND v(dout1_294) AT=645.025n

.meas tran vdout1_295ck1280 FIND v(dout1_295) AT=645.025n

.meas tran vdout1_296ck1280 FIND v(dout1_296) AT=645.025n

.meas tran vdout1_297ck1280 FIND v(dout1_297) AT=645.025n

.meas tran vdout1_298ck1280 FIND v(dout1_298) AT=645.025n

.meas tran vdout1_299ck1280 FIND v(dout1_299) AT=645.025n

.meas tran vdout1_300ck1280 FIND v(dout1_300) AT=645.025n

.meas tran vdout1_301ck1280 FIND v(dout1_301) AT=645.025n

.meas tran vdout1_302ck1280 FIND v(dout1_302) AT=645.025n

.meas tran vdout1_303ck1280 FIND v(dout1_303) AT=645.025n

.meas tran vdout1_304ck1280 FIND v(dout1_304) AT=645.025n

.meas tran vdout1_305ck1280 FIND v(dout1_305) AT=645.025n

.meas tran vdout1_306ck1280 FIND v(dout1_306) AT=645.025n

.meas tran vdout1_307ck1280 FIND v(dout1_307) AT=645.025n

.meas tran vdout1_308ck1280 FIND v(dout1_308) AT=645.025n

.meas tran vdout1_309ck1280 FIND v(dout1_309) AT=645.025n

.meas tran vdout1_310ck1280 FIND v(dout1_310) AT=645.025n

.meas tran vdout1_311ck1280 FIND v(dout1_311) AT=645.025n

.meas tran vdout1_312ck1280 FIND v(dout1_312) AT=645.025n

.meas tran vdout1_313ck1280 FIND v(dout1_313) AT=645.025n

.meas tran vdout1_314ck1280 FIND v(dout1_314) AT=645.025n

.meas tran vdout1_315ck1280 FIND v(dout1_315) AT=645.025n

.meas tran vdout1_316ck1280 FIND v(dout1_316) AT=645.025n

.meas tran vdout1_317ck1280 FIND v(dout1_317) AT=645.025n

.meas tran vdout1_318ck1280 FIND v(dout1_318) AT=645.025n

.meas tran vdout1_319ck1280 FIND v(dout1_319) AT=645.025n

.meas tran vdout1_320ck1280 FIND v(dout1_320) AT=645.025n

.meas tran vdout1_321ck1280 FIND v(dout1_321) AT=645.025n

.meas tran vdout1_322ck1280 FIND v(dout1_322) AT=645.025n

.meas tran vdout1_323ck1280 FIND v(dout1_323) AT=645.025n

.meas tran vdout1_324ck1280 FIND v(dout1_324) AT=645.025n

.meas tran vdout1_325ck1280 FIND v(dout1_325) AT=645.025n

.meas tran vdout1_326ck1280 FIND v(dout1_326) AT=645.025n

.meas tran vdout1_327ck1280 FIND v(dout1_327) AT=645.025n

.meas tran vdout1_328ck1280 FIND v(dout1_328) AT=645.025n

.meas tran vdout1_329ck1280 FIND v(dout1_329) AT=645.025n

.meas tran vdout1_330ck1280 FIND v(dout1_330) AT=645.025n

.meas tran vdout1_331ck1280 FIND v(dout1_331) AT=645.025n

.meas tran vdout1_332ck1280 FIND v(dout1_332) AT=645.025n

.meas tran vdout1_333ck1280 FIND v(dout1_333) AT=645.025n

.meas tran vdout1_334ck1280 FIND v(dout1_334) AT=645.025n

.meas tran vdout1_335ck1280 FIND v(dout1_335) AT=645.025n

.meas tran vdout1_336ck1280 FIND v(dout1_336) AT=645.025n

.meas tran vdout1_337ck1280 FIND v(dout1_337) AT=645.025n

.meas tran vdout1_338ck1280 FIND v(dout1_338) AT=645.025n

.meas tran vdout1_339ck1280 FIND v(dout1_339) AT=645.025n

.meas tran vdout1_340ck1280 FIND v(dout1_340) AT=645.025n

.meas tran vdout1_341ck1280 FIND v(dout1_341) AT=645.025n

.meas tran vdout1_342ck1280 FIND v(dout1_342) AT=645.025n

.meas tran vdout1_343ck1280 FIND v(dout1_343) AT=645.025n

.meas tran vdout1_344ck1280 FIND v(dout1_344) AT=645.025n

.meas tran vdout1_345ck1280 FIND v(dout1_345) AT=645.025n

.meas tran vdout1_346ck1280 FIND v(dout1_346) AT=645.025n

.meas tran vdout1_347ck1280 FIND v(dout1_347) AT=645.025n

.meas tran vdout1_348ck1280 FIND v(dout1_348) AT=645.025n

.meas tran vdout1_349ck1280 FIND v(dout1_349) AT=645.025n

.meas tran vdout1_350ck1280 FIND v(dout1_350) AT=645.025n

.meas tran vdout1_351ck1280 FIND v(dout1_351) AT=645.025n

.meas tran vdout1_352ck1280 FIND v(dout1_352) AT=645.025n

.meas tran vdout1_353ck1280 FIND v(dout1_353) AT=645.025n

.meas tran vdout1_354ck1280 FIND v(dout1_354) AT=645.025n

.meas tran vdout1_355ck1280 FIND v(dout1_355) AT=645.025n

.meas tran vdout1_356ck1280 FIND v(dout1_356) AT=645.025n

.meas tran vdout1_357ck1280 FIND v(dout1_357) AT=645.025n

.meas tran vdout1_358ck1280 FIND v(dout1_358) AT=645.025n

.meas tran vdout1_359ck1280 FIND v(dout1_359) AT=645.025n

.meas tran vdout1_360ck1280 FIND v(dout1_360) AT=645.025n

.meas tran vdout1_361ck1280 FIND v(dout1_361) AT=645.025n

.meas tran vdout1_362ck1280 FIND v(dout1_362) AT=645.025n

.meas tran vdout1_363ck1280 FIND v(dout1_363) AT=645.025n

.meas tran vdout1_364ck1280 FIND v(dout1_364) AT=645.025n

.meas tran vdout1_365ck1280 FIND v(dout1_365) AT=645.025n

.meas tran vdout1_366ck1280 FIND v(dout1_366) AT=645.025n

.meas tran vdout1_367ck1280 FIND v(dout1_367) AT=645.025n

.meas tran vdout1_368ck1280 FIND v(dout1_368) AT=645.025n

.meas tran vdout1_369ck1280 FIND v(dout1_369) AT=645.025n

.meas tran vdout1_370ck1280 FIND v(dout1_370) AT=645.025n

.meas tran vdout1_371ck1280 FIND v(dout1_371) AT=645.025n

.meas tran vdout1_372ck1280 FIND v(dout1_372) AT=645.025n

.meas tran vdout1_373ck1280 FIND v(dout1_373) AT=645.025n

.meas tran vdout1_374ck1280 FIND v(dout1_374) AT=645.025n

.meas tran vdout1_375ck1280 FIND v(dout1_375) AT=645.025n

.meas tran vdout1_376ck1280 FIND v(dout1_376) AT=645.025n

.meas tran vdout1_377ck1280 FIND v(dout1_377) AT=645.025n

.meas tran vdout1_378ck1280 FIND v(dout1_378) AT=645.025n

.meas tran vdout1_379ck1280 FIND v(dout1_379) AT=645.025n

.meas tran vdout1_380ck1280 FIND v(dout1_380) AT=645.025n

.meas tran vdout1_381ck1280 FIND v(dout1_381) AT=645.025n

.meas tran vdout1_382ck1280 FIND v(dout1_382) AT=645.025n

.meas tran vdout1_383ck1280 FIND v(dout1_383) AT=645.025n

.meas tran vdout1_384ck1280 FIND v(dout1_384) AT=645.025n

.meas tran vdout1_385ck1280 FIND v(dout1_385) AT=645.025n

.meas tran vdout1_386ck1280 FIND v(dout1_386) AT=645.025n

.meas tran vdout1_387ck1280 FIND v(dout1_387) AT=645.025n

.meas tran vdout1_388ck1280 FIND v(dout1_388) AT=645.025n

.meas tran vdout1_389ck1280 FIND v(dout1_389) AT=645.025n

.meas tran vdout1_390ck1280 FIND v(dout1_390) AT=645.025n

.meas tran vdout1_391ck1280 FIND v(dout1_391) AT=645.025n

.meas tran vdout1_392ck1280 FIND v(dout1_392) AT=645.025n

.meas tran vdout1_393ck1280 FIND v(dout1_393) AT=645.025n

.meas tran vdout1_394ck1280 FIND v(dout1_394) AT=645.025n

.meas tran vdout1_395ck1280 FIND v(dout1_395) AT=645.025n

.meas tran vdout1_396ck1280 FIND v(dout1_396) AT=645.025n

.meas tran vdout1_397ck1280 FIND v(dout1_397) AT=645.025n

.meas tran vdout1_398ck1280 FIND v(dout1_398) AT=645.025n

.meas tran vdout1_399ck1280 FIND v(dout1_399) AT=645.025n

.meas tran vdout1_400ck1280 FIND v(dout1_400) AT=645.025n

.meas tran vdout1_401ck1280 FIND v(dout1_401) AT=645.025n

.meas tran vdout1_402ck1280 FIND v(dout1_402) AT=645.025n

.meas tran vdout1_403ck1280 FIND v(dout1_403) AT=645.025n

.meas tran vdout1_404ck1280 FIND v(dout1_404) AT=645.025n

.meas tran vdout1_405ck1280 FIND v(dout1_405) AT=645.025n

.meas tran vdout1_406ck1280 FIND v(dout1_406) AT=645.025n

.meas tran vdout1_407ck1280 FIND v(dout1_407) AT=645.025n

.meas tran vdout1_408ck1280 FIND v(dout1_408) AT=645.025n

.meas tran vdout1_409ck1280 FIND v(dout1_409) AT=645.025n

.meas tran vdout1_410ck1280 FIND v(dout1_410) AT=645.025n

.meas tran vdout1_411ck1280 FIND v(dout1_411) AT=645.025n

.meas tran vdout1_412ck1280 FIND v(dout1_412) AT=645.025n

.meas tran vdout1_413ck1280 FIND v(dout1_413) AT=645.025n

.meas tran vdout1_414ck1280 FIND v(dout1_414) AT=645.025n

.meas tran vdout1_415ck1280 FIND v(dout1_415) AT=645.025n

.meas tran vdout1_416ck1280 FIND v(dout1_416) AT=645.025n

.meas tran vdout1_417ck1280 FIND v(dout1_417) AT=645.025n

.meas tran vdout1_418ck1280 FIND v(dout1_418) AT=645.025n

.meas tran vdout1_419ck1280 FIND v(dout1_419) AT=645.025n

.meas tran vdout1_420ck1280 FIND v(dout1_420) AT=645.025n

.meas tran vdout1_421ck1280 FIND v(dout1_421) AT=645.025n

.meas tran vdout1_422ck1280 FIND v(dout1_422) AT=645.025n

.meas tran vdout1_423ck1280 FIND v(dout1_423) AT=645.025n

.meas tran vdout1_424ck1280 FIND v(dout1_424) AT=645.025n

.meas tran vdout1_425ck1280 FIND v(dout1_425) AT=645.025n

.meas tran vdout1_426ck1280 FIND v(dout1_426) AT=645.025n

.meas tran vdout1_427ck1280 FIND v(dout1_427) AT=645.025n

.meas tran vdout1_428ck1280 FIND v(dout1_428) AT=645.025n

.meas tran vdout1_429ck1280 FIND v(dout1_429) AT=645.025n

.meas tran vdout1_430ck1280 FIND v(dout1_430) AT=645.025n

.meas tran vdout1_431ck1280 FIND v(dout1_431) AT=645.025n

.meas tran vdout1_432ck1280 FIND v(dout1_432) AT=645.025n

.meas tran vdout1_433ck1280 FIND v(dout1_433) AT=645.025n

.meas tran vdout1_434ck1280 FIND v(dout1_434) AT=645.025n

.meas tran vdout1_435ck1280 FIND v(dout1_435) AT=645.025n

.meas tran vdout1_436ck1280 FIND v(dout1_436) AT=645.025n

.meas tran vdout1_437ck1280 FIND v(dout1_437) AT=645.025n

.meas tran vdout1_438ck1280 FIND v(dout1_438) AT=645.025n

.meas tran vdout1_439ck1280 FIND v(dout1_439) AT=645.025n

.meas tran vdout1_440ck1280 FIND v(dout1_440) AT=645.025n

.meas tran vdout1_441ck1280 FIND v(dout1_441) AT=645.025n

.meas tran vdout1_442ck1280 FIND v(dout1_442) AT=645.025n

.meas tran vdout1_443ck1280 FIND v(dout1_443) AT=645.025n

.meas tran vdout1_444ck1280 FIND v(dout1_444) AT=645.025n

.meas tran vdout1_445ck1280 FIND v(dout1_445) AT=645.025n

.meas tran vdout1_446ck1280 FIND v(dout1_446) AT=645.025n

.meas tran vdout1_447ck1280 FIND v(dout1_447) AT=645.025n

.meas tran vdout1_448ck1280 FIND v(dout1_448) AT=645.025n

.meas tran vdout1_449ck1280 FIND v(dout1_449) AT=645.025n

.meas tran vdout1_450ck1280 FIND v(dout1_450) AT=645.025n

.meas tran vdout1_451ck1280 FIND v(dout1_451) AT=645.025n

.meas tran vdout1_452ck1280 FIND v(dout1_452) AT=645.025n

.meas tran vdout1_453ck1280 FIND v(dout1_453) AT=645.025n

.meas tran vdout1_454ck1280 FIND v(dout1_454) AT=645.025n

.meas tran vdout1_455ck1280 FIND v(dout1_455) AT=645.025n

.meas tran vdout1_456ck1280 FIND v(dout1_456) AT=645.025n

.meas tran vdout1_457ck1280 FIND v(dout1_457) AT=645.025n

.meas tran vdout1_458ck1280 FIND v(dout1_458) AT=645.025n

.meas tran vdout1_459ck1280 FIND v(dout1_459) AT=645.025n

.meas tran vdout1_460ck1280 FIND v(dout1_460) AT=645.025n

.meas tran vdout1_461ck1280 FIND v(dout1_461) AT=645.025n

.meas tran vdout1_462ck1280 FIND v(dout1_462) AT=645.025n

.meas tran vdout1_463ck1280 FIND v(dout1_463) AT=645.025n

.meas tran vdout1_464ck1280 FIND v(dout1_464) AT=645.025n

.meas tran vdout1_465ck1280 FIND v(dout1_465) AT=645.025n

.meas tran vdout1_466ck1280 FIND v(dout1_466) AT=645.025n

.meas tran vdout1_467ck1280 FIND v(dout1_467) AT=645.025n

.meas tran vdout1_468ck1280 FIND v(dout1_468) AT=645.025n

.meas tran vdout1_469ck1280 FIND v(dout1_469) AT=645.025n

.meas tran vdout1_470ck1280 FIND v(dout1_470) AT=645.025n

.meas tran vdout1_471ck1280 FIND v(dout1_471) AT=645.025n

.meas tran vdout1_472ck1280 FIND v(dout1_472) AT=645.025n

.meas tran vdout1_473ck1280 FIND v(dout1_473) AT=645.025n

.meas tran vdout1_474ck1280 FIND v(dout1_474) AT=645.025n

.meas tran vdout1_475ck1280 FIND v(dout1_475) AT=645.025n

.meas tran vdout1_476ck1280 FIND v(dout1_476) AT=645.025n

.meas tran vdout1_477ck1280 FIND v(dout1_477) AT=645.025n

.meas tran vdout1_478ck1280 FIND v(dout1_478) AT=645.025n

.meas tran vdout1_479ck1280 FIND v(dout1_479) AT=645.025n

.meas tran vdout1_480ck1280 FIND v(dout1_480) AT=645.025n

.meas tran vdout1_481ck1280 FIND v(dout1_481) AT=645.025n

.meas tran vdout1_482ck1280 FIND v(dout1_482) AT=645.025n

.meas tran vdout1_483ck1280 FIND v(dout1_483) AT=645.025n

.meas tran vdout1_484ck1280 FIND v(dout1_484) AT=645.025n

.meas tran vdout1_485ck1280 FIND v(dout1_485) AT=645.025n

.meas tran vdout1_486ck1280 FIND v(dout1_486) AT=645.025n

.meas tran vdout1_487ck1280 FIND v(dout1_487) AT=645.025n

.meas tran vdout1_488ck1280 FIND v(dout1_488) AT=645.025n

.meas tran vdout1_489ck1280 FIND v(dout1_489) AT=645.025n

.meas tran vdout1_490ck1280 FIND v(dout1_490) AT=645.025n

.meas tran vdout1_491ck1280 FIND v(dout1_491) AT=645.025n

.meas tran vdout1_492ck1280 FIND v(dout1_492) AT=645.025n

.meas tran vdout1_493ck1280 FIND v(dout1_493) AT=645.025n

.meas tran vdout1_494ck1280 FIND v(dout1_494) AT=645.025n

.meas tran vdout1_495ck1280 FIND v(dout1_495) AT=645.025n

.meas tran vdout1_496ck1280 FIND v(dout1_496) AT=645.025n

.meas tran vdout1_497ck1280 FIND v(dout1_497) AT=645.025n

.meas tran vdout1_498ck1280 FIND v(dout1_498) AT=645.025n

.meas tran vdout1_499ck1280 FIND v(dout1_499) AT=645.025n

.meas tran vdout1_500ck1280 FIND v(dout1_500) AT=645.025n

.meas tran vdout1_501ck1280 FIND v(dout1_501) AT=645.025n

.meas tran vdout1_502ck1280 FIND v(dout1_502) AT=645.025n

.meas tran vdout1_503ck1280 FIND v(dout1_503) AT=645.025n

.meas tran vdout1_504ck1280 FIND v(dout1_504) AT=645.025n

.meas tran vdout1_505ck1280 FIND v(dout1_505) AT=645.025n

.meas tran vdout1_506ck1280 FIND v(dout1_506) AT=645.025n

.meas tran vdout1_507ck1280 FIND v(dout1_507) AT=645.025n

.meas tran vdout1_508ck1280 FIND v(dout1_508) AT=645.025n

.meas tran vdout1_509ck1280 FIND v(dout1_509) AT=645.025n

.meas tran vdout1_510ck1280 FIND v(dout1_510) AT=645.025n

.meas tran vdout1_511ck1280 FIND v(dout1_511) AT=645.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_19ck1310 FIND v(dout1_19) AT=660.025n

.meas tran vdout1_20ck1310 FIND v(dout1_20) AT=660.025n

.meas tran vdout1_21ck1310 FIND v(dout1_21) AT=660.025n

.meas tran vdout1_22ck1310 FIND v(dout1_22) AT=660.025n

.meas tran vdout1_23ck1310 FIND v(dout1_23) AT=660.025n

.meas tran vdout1_24ck1310 FIND v(dout1_24) AT=660.025n

.meas tran vdout1_25ck1310 FIND v(dout1_25) AT=660.025n

.meas tran vdout1_26ck1310 FIND v(dout1_26) AT=660.025n

.meas tran vdout1_27ck1310 FIND v(dout1_27) AT=660.025n

.meas tran vdout1_28ck1310 FIND v(dout1_28) AT=660.025n

.meas tran vdout1_29ck1310 FIND v(dout1_29) AT=660.025n

.meas tran vdout1_30ck1310 FIND v(dout1_30) AT=660.025n

.meas tran vdout1_31ck1310 FIND v(dout1_31) AT=660.025n

.meas tran vdout1_32ck1310 FIND v(dout1_32) AT=660.025n

.meas tran vdout1_33ck1310 FIND v(dout1_33) AT=660.025n

.meas tran vdout1_34ck1310 FIND v(dout1_34) AT=660.025n

.meas tran vdout1_35ck1310 FIND v(dout1_35) AT=660.025n

.meas tran vdout1_36ck1310 FIND v(dout1_36) AT=660.025n

.meas tran vdout1_37ck1310 FIND v(dout1_37) AT=660.025n

.meas tran vdout1_38ck1310 FIND v(dout1_38) AT=660.025n

.meas tran vdout1_39ck1310 FIND v(dout1_39) AT=660.025n

.meas tran vdout1_40ck1310 FIND v(dout1_40) AT=660.025n

.meas tran vdout1_41ck1310 FIND v(dout1_41) AT=660.025n

.meas tran vdout1_42ck1310 FIND v(dout1_42) AT=660.025n

.meas tran vdout1_43ck1310 FIND v(dout1_43) AT=660.025n

.meas tran vdout1_44ck1310 FIND v(dout1_44) AT=660.025n

.meas tran vdout1_45ck1310 FIND v(dout1_45) AT=660.025n

.meas tran vdout1_46ck1310 FIND v(dout1_46) AT=660.025n

.meas tran vdout1_47ck1310 FIND v(dout1_47) AT=660.025n

.meas tran vdout1_48ck1310 FIND v(dout1_48) AT=660.025n

.meas tran vdout1_49ck1310 FIND v(dout1_49) AT=660.025n

.meas tran vdout1_50ck1310 FIND v(dout1_50) AT=660.025n

.meas tran vdout1_51ck1310 FIND v(dout1_51) AT=660.025n

.meas tran vdout1_52ck1310 FIND v(dout1_52) AT=660.025n

.meas tran vdout1_53ck1310 FIND v(dout1_53) AT=660.025n

.meas tran vdout1_54ck1310 FIND v(dout1_54) AT=660.025n

.meas tran vdout1_55ck1310 FIND v(dout1_55) AT=660.025n

.meas tran vdout1_56ck1310 FIND v(dout1_56) AT=660.025n

.meas tran vdout1_57ck1310 FIND v(dout1_57) AT=660.025n

.meas tran vdout1_58ck1310 FIND v(dout1_58) AT=660.025n

.meas tran vdout1_59ck1310 FIND v(dout1_59) AT=660.025n

.meas tran vdout1_60ck1310 FIND v(dout1_60) AT=660.025n

.meas tran vdout1_61ck1310 FIND v(dout1_61) AT=660.025n

.meas tran vdout1_62ck1310 FIND v(dout1_62) AT=660.025n

.meas tran vdout1_63ck1310 FIND v(dout1_63) AT=660.025n

.meas tran vdout1_64ck1310 FIND v(dout1_64) AT=660.025n

.meas tran vdout1_65ck1310 FIND v(dout1_65) AT=660.025n

.meas tran vdout1_66ck1310 FIND v(dout1_66) AT=660.025n

.meas tran vdout1_67ck1310 FIND v(dout1_67) AT=660.025n

.meas tran vdout1_68ck1310 FIND v(dout1_68) AT=660.025n

.meas tran vdout1_69ck1310 FIND v(dout1_69) AT=660.025n

.meas tran vdout1_70ck1310 FIND v(dout1_70) AT=660.025n

.meas tran vdout1_71ck1310 FIND v(dout1_71) AT=660.025n

.meas tran vdout1_72ck1310 FIND v(dout1_72) AT=660.025n

.meas tran vdout1_73ck1310 FIND v(dout1_73) AT=660.025n

.meas tran vdout1_74ck1310 FIND v(dout1_74) AT=660.025n

.meas tran vdout1_75ck1310 FIND v(dout1_75) AT=660.025n

.meas tran vdout1_76ck1310 FIND v(dout1_76) AT=660.025n

.meas tran vdout1_77ck1310 FIND v(dout1_77) AT=660.025n

.meas tran vdout1_78ck1310 FIND v(dout1_78) AT=660.025n

.meas tran vdout1_79ck1310 FIND v(dout1_79) AT=660.025n

.meas tran vdout1_80ck1310 FIND v(dout1_80) AT=660.025n

.meas tran vdout1_81ck1310 FIND v(dout1_81) AT=660.025n

.meas tran vdout1_82ck1310 FIND v(dout1_82) AT=660.025n

.meas tran vdout1_83ck1310 FIND v(dout1_83) AT=660.025n

.meas tran vdout1_84ck1310 FIND v(dout1_84) AT=660.025n

.meas tran vdout1_85ck1310 FIND v(dout1_85) AT=660.025n

.meas tran vdout1_86ck1310 FIND v(dout1_86) AT=660.025n

.meas tran vdout1_87ck1310 FIND v(dout1_87) AT=660.025n

.meas tran vdout1_88ck1310 FIND v(dout1_88) AT=660.025n

.meas tran vdout1_89ck1310 FIND v(dout1_89) AT=660.025n

.meas tran vdout1_90ck1310 FIND v(dout1_90) AT=660.025n

.meas tran vdout1_91ck1310 FIND v(dout1_91) AT=660.025n

.meas tran vdout1_92ck1310 FIND v(dout1_92) AT=660.025n

.meas tran vdout1_93ck1310 FIND v(dout1_93) AT=660.025n

.meas tran vdout1_94ck1310 FIND v(dout1_94) AT=660.025n

.meas tran vdout1_95ck1310 FIND v(dout1_95) AT=660.025n

.meas tran vdout1_96ck1310 FIND v(dout1_96) AT=660.025n

.meas tran vdout1_97ck1310 FIND v(dout1_97) AT=660.025n

.meas tran vdout1_98ck1310 FIND v(dout1_98) AT=660.025n

.meas tran vdout1_99ck1310 FIND v(dout1_99) AT=660.025n

.meas tran vdout1_100ck1310 FIND v(dout1_100) AT=660.025n

.meas tran vdout1_101ck1310 FIND v(dout1_101) AT=660.025n

.meas tran vdout1_102ck1310 FIND v(dout1_102) AT=660.025n

.meas tran vdout1_103ck1310 FIND v(dout1_103) AT=660.025n

.meas tran vdout1_104ck1310 FIND v(dout1_104) AT=660.025n

.meas tran vdout1_105ck1310 FIND v(dout1_105) AT=660.025n

.meas tran vdout1_106ck1310 FIND v(dout1_106) AT=660.025n

.meas tran vdout1_107ck1310 FIND v(dout1_107) AT=660.025n

.meas tran vdout1_108ck1310 FIND v(dout1_108) AT=660.025n

.meas tran vdout1_109ck1310 FIND v(dout1_109) AT=660.025n

.meas tran vdout1_110ck1310 FIND v(dout1_110) AT=660.025n

.meas tran vdout1_111ck1310 FIND v(dout1_111) AT=660.025n

.meas tran vdout1_112ck1310 FIND v(dout1_112) AT=660.025n

.meas tran vdout1_113ck1310 FIND v(dout1_113) AT=660.025n

.meas tran vdout1_114ck1310 FIND v(dout1_114) AT=660.025n

.meas tran vdout1_115ck1310 FIND v(dout1_115) AT=660.025n

.meas tran vdout1_116ck1310 FIND v(dout1_116) AT=660.025n

.meas tran vdout1_117ck1310 FIND v(dout1_117) AT=660.025n

.meas tran vdout1_118ck1310 FIND v(dout1_118) AT=660.025n

.meas tran vdout1_119ck1310 FIND v(dout1_119) AT=660.025n

.meas tran vdout1_120ck1310 FIND v(dout1_120) AT=660.025n

.meas tran vdout1_121ck1310 FIND v(dout1_121) AT=660.025n

.meas tran vdout1_122ck1310 FIND v(dout1_122) AT=660.025n

.meas tran vdout1_123ck1310 FIND v(dout1_123) AT=660.025n

.meas tran vdout1_124ck1310 FIND v(dout1_124) AT=660.025n

.meas tran vdout1_125ck1310 FIND v(dout1_125) AT=660.025n

.meas tran vdout1_126ck1310 FIND v(dout1_126) AT=660.025n

.meas tran vdout1_127ck1310 FIND v(dout1_127) AT=660.025n

.meas tran vdout1_128ck1310 FIND v(dout1_128) AT=660.025n

.meas tran vdout1_129ck1310 FIND v(dout1_129) AT=660.025n

.meas tran vdout1_130ck1310 FIND v(dout1_130) AT=660.025n

.meas tran vdout1_131ck1310 FIND v(dout1_131) AT=660.025n

.meas tran vdout1_132ck1310 FIND v(dout1_132) AT=660.025n

.meas tran vdout1_133ck1310 FIND v(dout1_133) AT=660.025n

.meas tran vdout1_134ck1310 FIND v(dout1_134) AT=660.025n

.meas tran vdout1_135ck1310 FIND v(dout1_135) AT=660.025n

.meas tran vdout1_136ck1310 FIND v(dout1_136) AT=660.025n

.meas tran vdout1_137ck1310 FIND v(dout1_137) AT=660.025n

.meas tran vdout1_138ck1310 FIND v(dout1_138) AT=660.025n

.meas tran vdout1_139ck1310 FIND v(dout1_139) AT=660.025n

.meas tran vdout1_140ck1310 FIND v(dout1_140) AT=660.025n

.meas tran vdout1_141ck1310 FIND v(dout1_141) AT=660.025n

.meas tran vdout1_142ck1310 FIND v(dout1_142) AT=660.025n

.meas tran vdout1_143ck1310 FIND v(dout1_143) AT=660.025n

.meas tran vdout1_144ck1310 FIND v(dout1_144) AT=660.025n

.meas tran vdout1_145ck1310 FIND v(dout1_145) AT=660.025n

.meas tran vdout1_146ck1310 FIND v(dout1_146) AT=660.025n

.meas tran vdout1_147ck1310 FIND v(dout1_147) AT=660.025n

.meas tran vdout1_148ck1310 FIND v(dout1_148) AT=660.025n

.meas tran vdout1_149ck1310 FIND v(dout1_149) AT=660.025n

.meas tran vdout1_150ck1310 FIND v(dout1_150) AT=660.025n

.meas tran vdout1_151ck1310 FIND v(dout1_151) AT=660.025n

.meas tran vdout1_152ck1310 FIND v(dout1_152) AT=660.025n

.meas tran vdout1_153ck1310 FIND v(dout1_153) AT=660.025n

.meas tran vdout1_154ck1310 FIND v(dout1_154) AT=660.025n

.meas tran vdout1_155ck1310 FIND v(dout1_155) AT=660.025n

.meas tran vdout1_156ck1310 FIND v(dout1_156) AT=660.025n

.meas tran vdout1_157ck1310 FIND v(dout1_157) AT=660.025n

.meas tran vdout1_158ck1310 FIND v(dout1_158) AT=660.025n

.meas tran vdout1_159ck1310 FIND v(dout1_159) AT=660.025n

.meas tran vdout1_160ck1310 FIND v(dout1_160) AT=660.025n

.meas tran vdout1_161ck1310 FIND v(dout1_161) AT=660.025n

.meas tran vdout1_162ck1310 FIND v(dout1_162) AT=660.025n

.meas tran vdout1_163ck1310 FIND v(dout1_163) AT=660.025n

.meas tran vdout1_164ck1310 FIND v(dout1_164) AT=660.025n

.meas tran vdout1_165ck1310 FIND v(dout1_165) AT=660.025n

.meas tran vdout1_166ck1310 FIND v(dout1_166) AT=660.025n

.meas tran vdout1_167ck1310 FIND v(dout1_167) AT=660.025n

.meas tran vdout1_168ck1310 FIND v(dout1_168) AT=660.025n

.meas tran vdout1_169ck1310 FIND v(dout1_169) AT=660.025n

.meas tran vdout1_170ck1310 FIND v(dout1_170) AT=660.025n

.meas tran vdout1_171ck1310 FIND v(dout1_171) AT=660.025n

.meas tran vdout1_172ck1310 FIND v(dout1_172) AT=660.025n

.meas tran vdout1_173ck1310 FIND v(dout1_173) AT=660.025n

.meas tran vdout1_174ck1310 FIND v(dout1_174) AT=660.025n

.meas tran vdout1_175ck1310 FIND v(dout1_175) AT=660.025n

.meas tran vdout1_176ck1310 FIND v(dout1_176) AT=660.025n

.meas tran vdout1_177ck1310 FIND v(dout1_177) AT=660.025n

.meas tran vdout1_178ck1310 FIND v(dout1_178) AT=660.025n

.meas tran vdout1_179ck1310 FIND v(dout1_179) AT=660.025n

.meas tran vdout1_180ck1310 FIND v(dout1_180) AT=660.025n

.meas tran vdout1_181ck1310 FIND v(dout1_181) AT=660.025n

.meas tran vdout1_182ck1310 FIND v(dout1_182) AT=660.025n

.meas tran vdout1_183ck1310 FIND v(dout1_183) AT=660.025n

.meas tran vdout1_184ck1310 FIND v(dout1_184) AT=660.025n

.meas tran vdout1_185ck1310 FIND v(dout1_185) AT=660.025n

.meas tran vdout1_186ck1310 FIND v(dout1_186) AT=660.025n

.meas tran vdout1_187ck1310 FIND v(dout1_187) AT=660.025n

.meas tran vdout1_188ck1310 FIND v(dout1_188) AT=660.025n

.meas tran vdout1_189ck1310 FIND v(dout1_189) AT=660.025n

.meas tran vdout1_190ck1310 FIND v(dout1_190) AT=660.025n

.meas tran vdout1_191ck1310 FIND v(dout1_191) AT=660.025n

.meas tran vdout1_192ck1310 FIND v(dout1_192) AT=660.025n

.meas tran vdout1_193ck1310 FIND v(dout1_193) AT=660.025n

.meas tran vdout1_194ck1310 FIND v(dout1_194) AT=660.025n

.meas tran vdout1_195ck1310 FIND v(dout1_195) AT=660.025n

.meas tran vdout1_196ck1310 FIND v(dout1_196) AT=660.025n

.meas tran vdout1_197ck1310 FIND v(dout1_197) AT=660.025n

.meas tran vdout1_198ck1310 FIND v(dout1_198) AT=660.025n

.meas tran vdout1_199ck1310 FIND v(dout1_199) AT=660.025n

.meas tran vdout1_200ck1310 FIND v(dout1_200) AT=660.025n

.meas tran vdout1_201ck1310 FIND v(dout1_201) AT=660.025n

.meas tran vdout1_202ck1310 FIND v(dout1_202) AT=660.025n

.meas tran vdout1_203ck1310 FIND v(dout1_203) AT=660.025n

.meas tran vdout1_204ck1310 FIND v(dout1_204) AT=660.025n

.meas tran vdout1_205ck1310 FIND v(dout1_205) AT=660.025n

.meas tran vdout1_206ck1310 FIND v(dout1_206) AT=660.025n

.meas tran vdout1_207ck1310 FIND v(dout1_207) AT=660.025n

.meas tran vdout1_208ck1310 FIND v(dout1_208) AT=660.025n

.meas tran vdout1_209ck1310 FIND v(dout1_209) AT=660.025n

.meas tran vdout1_210ck1310 FIND v(dout1_210) AT=660.025n

.meas tran vdout1_211ck1310 FIND v(dout1_211) AT=660.025n

.meas tran vdout1_212ck1310 FIND v(dout1_212) AT=660.025n

.meas tran vdout1_213ck1310 FIND v(dout1_213) AT=660.025n

.meas tran vdout1_214ck1310 FIND v(dout1_214) AT=660.025n

.meas tran vdout1_215ck1310 FIND v(dout1_215) AT=660.025n

.meas tran vdout1_216ck1310 FIND v(dout1_216) AT=660.025n

.meas tran vdout1_217ck1310 FIND v(dout1_217) AT=660.025n

.meas tran vdout1_218ck1310 FIND v(dout1_218) AT=660.025n

.meas tran vdout1_219ck1310 FIND v(dout1_219) AT=660.025n

.meas tran vdout1_220ck1310 FIND v(dout1_220) AT=660.025n

.meas tran vdout1_221ck1310 FIND v(dout1_221) AT=660.025n

.meas tran vdout1_222ck1310 FIND v(dout1_222) AT=660.025n

.meas tran vdout1_223ck1310 FIND v(dout1_223) AT=660.025n

.meas tran vdout1_224ck1310 FIND v(dout1_224) AT=660.025n

.meas tran vdout1_225ck1310 FIND v(dout1_225) AT=660.025n

.meas tran vdout1_226ck1310 FIND v(dout1_226) AT=660.025n

.meas tran vdout1_227ck1310 FIND v(dout1_227) AT=660.025n

.meas tran vdout1_228ck1310 FIND v(dout1_228) AT=660.025n

.meas tran vdout1_229ck1310 FIND v(dout1_229) AT=660.025n

.meas tran vdout1_230ck1310 FIND v(dout1_230) AT=660.025n

.meas tran vdout1_231ck1310 FIND v(dout1_231) AT=660.025n

.meas tran vdout1_232ck1310 FIND v(dout1_232) AT=660.025n

.meas tran vdout1_233ck1310 FIND v(dout1_233) AT=660.025n

.meas tran vdout1_234ck1310 FIND v(dout1_234) AT=660.025n

.meas tran vdout1_235ck1310 FIND v(dout1_235) AT=660.025n

.meas tran vdout1_236ck1310 FIND v(dout1_236) AT=660.025n

.meas tran vdout1_237ck1310 FIND v(dout1_237) AT=660.025n

.meas tran vdout1_238ck1310 FIND v(dout1_238) AT=660.025n

.meas tran vdout1_239ck1310 FIND v(dout1_239) AT=660.025n

.meas tran vdout1_240ck1310 FIND v(dout1_240) AT=660.025n

.meas tran vdout1_241ck1310 FIND v(dout1_241) AT=660.025n

.meas tran vdout1_242ck1310 FIND v(dout1_242) AT=660.025n

.meas tran vdout1_243ck1310 FIND v(dout1_243) AT=660.025n

.meas tran vdout1_244ck1310 FIND v(dout1_244) AT=660.025n

.meas tran vdout1_245ck1310 FIND v(dout1_245) AT=660.025n

.meas tran vdout1_246ck1310 FIND v(dout1_246) AT=660.025n

.meas tran vdout1_247ck1310 FIND v(dout1_247) AT=660.025n

.meas tran vdout1_248ck1310 FIND v(dout1_248) AT=660.025n

.meas tran vdout1_249ck1310 FIND v(dout1_249) AT=660.025n

.meas tran vdout1_250ck1310 FIND v(dout1_250) AT=660.025n

.meas tran vdout1_251ck1310 FIND v(dout1_251) AT=660.025n

.meas tran vdout1_252ck1310 FIND v(dout1_252) AT=660.025n

.meas tran vdout1_253ck1310 FIND v(dout1_253) AT=660.025n

.meas tran vdout1_254ck1310 FIND v(dout1_254) AT=660.025n

.meas tran vdout1_255ck1310 FIND v(dout1_255) AT=660.025n

.meas tran vdout1_256ck1310 FIND v(dout1_256) AT=660.025n

.meas tran vdout1_257ck1310 FIND v(dout1_257) AT=660.025n

.meas tran vdout1_258ck1310 FIND v(dout1_258) AT=660.025n

.meas tran vdout1_259ck1310 FIND v(dout1_259) AT=660.025n

.meas tran vdout1_260ck1310 FIND v(dout1_260) AT=660.025n

.meas tran vdout1_261ck1310 FIND v(dout1_261) AT=660.025n

.meas tran vdout1_262ck1310 FIND v(dout1_262) AT=660.025n

.meas tran vdout1_263ck1310 FIND v(dout1_263) AT=660.025n

.meas tran vdout1_264ck1310 FIND v(dout1_264) AT=660.025n

.meas tran vdout1_265ck1310 FIND v(dout1_265) AT=660.025n

.meas tran vdout1_266ck1310 FIND v(dout1_266) AT=660.025n

.meas tran vdout1_267ck1310 FIND v(dout1_267) AT=660.025n

.meas tran vdout1_268ck1310 FIND v(dout1_268) AT=660.025n

.meas tran vdout1_269ck1310 FIND v(dout1_269) AT=660.025n

.meas tran vdout1_270ck1310 FIND v(dout1_270) AT=660.025n

.meas tran vdout1_271ck1310 FIND v(dout1_271) AT=660.025n

.meas tran vdout1_272ck1310 FIND v(dout1_272) AT=660.025n

.meas tran vdout1_273ck1310 FIND v(dout1_273) AT=660.025n

.meas tran vdout1_274ck1310 FIND v(dout1_274) AT=660.025n

.meas tran vdout1_275ck1310 FIND v(dout1_275) AT=660.025n

.meas tran vdout1_276ck1310 FIND v(dout1_276) AT=660.025n

.meas tran vdout1_277ck1310 FIND v(dout1_277) AT=660.025n

.meas tran vdout1_278ck1310 FIND v(dout1_278) AT=660.025n

.meas tran vdout1_279ck1310 FIND v(dout1_279) AT=660.025n

.meas tran vdout1_280ck1310 FIND v(dout1_280) AT=660.025n

.meas tran vdout1_281ck1310 FIND v(dout1_281) AT=660.025n

.meas tran vdout1_282ck1310 FIND v(dout1_282) AT=660.025n

.meas tran vdout1_283ck1310 FIND v(dout1_283) AT=660.025n

.meas tran vdout1_284ck1310 FIND v(dout1_284) AT=660.025n

.meas tran vdout1_285ck1310 FIND v(dout1_285) AT=660.025n

.meas tran vdout1_286ck1310 FIND v(dout1_286) AT=660.025n

.meas tran vdout1_287ck1310 FIND v(dout1_287) AT=660.025n

.meas tran vdout1_288ck1310 FIND v(dout1_288) AT=660.025n

.meas tran vdout1_289ck1310 FIND v(dout1_289) AT=660.025n

.meas tran vdout1_290ck1310 FIND v(dout1_290) AT=660.025n

.meas tran vdout1_291ck1310 FIND v(dout1_291) AT=660.025n

.meas tran vdout1_292ck1310 FIND v(dout1_292) AT=660.025n

.meas tran vdout1_293ck1310 FIND v(dout1_293) AT=660.025n

.meas tran vdout1_294ck1310 FIND v(dout1_294) AT=660.025n

.meas tran vdout1_295ck1310 FIND v(dout1_295) AT=660.025n

.meas tran vdout1_296ck1310 FIND v(dout1_296) AT=660.025n

.meas tran vdout1_297ck1310 FIND v(dout1_297) AT=660.025n

.meas tran vdout1_298ck1310 FIND v(dout1_298) AT=660.025n

.meas tran vdout1_299ck1310 FIND v(dout1_299) AT=660.025n

.meas tran vdout1_300ck1310 FIND v(dout1_300) AT=660.025n

.meas tran vdout1_301ck1310 FIND v(dout1_301) AT=660.025n

.meas tran vdout1_302ck1310 FIND v(dout1_302) AT=660.025n

.meas tran vdout1_303ck1310 FIND v(dout1_303) AT=660.025n

.meas tran vdout1_304ck1310 FIND v(dout1_304) AT=660.025n

.meas tran vdout1_305ck1310 FIND v(dout1_305) AT=660.025n

.meas tran vdout1_306ck1310 FIND v(dout1_306) AT=660.025n

.meas tran vdout1_307ck1310 FIND v(dout1_307) AT=660.025n

.meas tran vdout1_308ck1310 FIND v(dout1_308) AT=660.025n

.meas tran vdout1_309ck1310 FIND v(dout1_309) AT=660.025n

.meas tran vdout1_310ck1310 FIND v(dout1_310) AT=660.025n

.meas tran vdout1_311ck1310 FIND v(dout1_311) AT=660.025n

.meas tran vdout1_312ck1310 FIND v(dout1_312) AT=660.025n

.meas tran vdout1_313ck1310 FIND v(dout1_313) AT=660.025n

.meas tran vdout1_314ck1310 FIND v(dout1_314) AT=660.025n

.meas tran vdout1_315ck1310 FIND v(dout1_315) AT=660.025n

.meas tran vdout1_316ck1310 FIND v(dout1_316) AT=660.025n

.meas tran vdout1_317ck1310 FIND v(dout1_317) AT=660.025n

.meas tran vdout1_318ck1310 FIND v(dout1_318) AT=660.025n

.meas tran vdout1_319ck1310 FIND v(dout1_319) AT=660.025n

.meas tran vdout1_320ck1310 FIND v(dout1_320) AT=660.025n

.meas tran vdout1_321ck1310 FIND v(dout1_321) AT=660.025n

.meas tran vdout1_322ck1310 FIND v(dout1_322) AT=660.025n

.meas tran vdout1_323ck1310 FIND v(dout1_323) AT=660.025n

.meas tran vdout1_324ck1310 FIND v(dout1_324) AT=660.025n

.meas tran vdout1_325ck1310 FIND v(dout1_325) AT=660.025n

.meas tran vdout1_326ck1310 FIND v(dout1_326) AT=660.025n

.meas tran vdout1_327ck1310 FIND v(dout1_327) AT=660.025n

.meas tran vdout1_328ck1310 FIND v(dout1_328) AT=660.025n

.meas tran vdout1_329ck1310 FIND v(dout1_329) AT=660.025n

.meas tran vdout1_330ck1310 FIND v(dout1_330) AT=660.025n

.meas tran vdout1_331ck1310 FIND v(dout1_331) AT=660.025n

.meas tran vdout1_332ck1310 FIND v(dout1_332) AT=660.025n

.meas tran vdout1_333ck1310 FIND v(dout1_333) AT=660.025n

.meas tran vdout1_334ck1310 FIND v(dout1_334) AT=660.025n

.meas tran vdout1_335ck1310 FIND v(dout1_335) AT=660.025n

.meas tran vdout1_336ck1310 FIND v(dout1_336) AT=660.025n

.meas tran vdout1_337ck1310 FIND v(dout1_337) AT=660.025n

.meas tran vdout1_338ck1310 FIND v(dout1_338) AT=660.025n

.meas tran vdout1_339ck1310 FIND v(dout1_339) AT=660.025n

.meas tran vdout1_340ck1310 FIND v(dout1_340) AT=660.025n

.meas tran vdout1_341ck1310 FIND v(dout1_341) AT=660.025n

.meas tran vdout1_342ck1310 FIND v(dout1_342) AT=660.025n

.meas tran vdout1_343ck1310 FIND v(dout1_343) AT=660.025n

.meas tran vdout1_344ck1310 FIND v(dout1_344) AT=660.025n

.meas tran vdout1_345ck1310 FIND v(dout1_345) AT=660.025n

.meas tran vdout1_346ck1310 FIND v(dout1_346) AT=660.025n

.meas tran vdout1_347ck1310 FIND v(dout1_347) AT=660.025n

.meas tran vdout1_348ck1310 FIND v(dout1_348) AT=660.025n

.meas tran vdout1_349ck1310 FIND v(dout1_349) AT=660.025n

.meas tran vdout1_350ck1310 FIND v(dout1_350) AT=660.025n

.meas tran vdout1_351ck1310 FIND v(dout1_351) AT=660.025n

.meas tran vdout1_352ck1310 FIND v(dout1_352) AT=660.025n

.meas tran vdout1_353ck1310 FIND v(dout1_353) AT=660.025n

.meas tran vdout1_354ck1310 FIND v(dout1_354) AT=660.025n

.meas tran vdout1_355ck1310 FIND v(dout1_355) AT=660.025n

.meas tran vdout1_356ck1310 FIND v(dout1_356) AT=660.025n

.meas tran vdout1_357ck1310 FIND v(dout1_357) AT=660.025n

.meas tran vdout1_358ck1310 FIND v(dout1_358) AT=660.025n

.meas tran vdout1_359ck1310 FIND v(dout1_359) AT=660.025n

.meas tran vdout1_360ck1310 FIND v(dout1_360) AT=660.025n

.meas tran vdout1_361ck1310 FIND v(dout1_361) AT=660.025n

.meas tran vdout1_362ck1310 FIND v(dout1_362) AT=660.025n

.meas tran vdout1_363ck1310 FIND v(dout1_363) AT=660.025n

.meas tran vdout1_364ck1310 FIND v(dout1_364) AT=660.025n

.meas tran vdout1_365ck1310 FIND v(dout1_365) AT=660.025n

.meas tran vdout1_366ck1310 FIND v(dout1_366) AT=660.025n

.meas tran vdout1_367ck1310 FIND v(dout1_367) AT=660.025n

.meas tran vdout1_368ck1310 FIND v(dout1_368) AT=660.025n

.meas tran vdout1_369ck1310 FIND v(dout1_369) AT=660.025n

.meas tran vdout1_370ck1310 FIND v(dout1_370) AT=660.025n

.meas tran vdout1_371ck1310 FIND v(dout1_371) AT=660.025n

.meas tran vdout1_372ck1310 FIND v(dout1_372) AT=660.025n

.meas tran vdout1_373ck1310 FIND v(dout1_373) AT=660.025n

.meas tran vdout1_374ck1310 FIND v(dout1_374) AT=660.025n

.meas tran vdout1_375ck1310 FIND v(dout1_375) AT=660.025n

.meas tran vdout1_376ck1310 FIND v(dout1_376) AT=660.025n

.meas tran vdout1_377ck1310 FIND v(dout1_377) AT=660.025n

.meas tran vdout1_378ck1310 FIND v(dout1_378) AT=660.025n

.meas tran vdout1_379ck1310 FIND v(dout1_379) AT=660.025n

.meas tran vdout1_380ck1310 FIND v(dout1_380) AT=660.025n

.meas tran vdout1_381ck1310 FIND v(dout1_381) AT=660.025n

.meas tran vdout1_382ck1310 FIND v(dout1_382) AT=660.025n

.meas tran vdout1_383ck1310 FIND v(dout1_383) AT=660.025n

.meas tran vdout1_384ck1310 FIND v(dout1_384) AT=660.025n

.meas tran vdout1_385ck1310 FIND v(dout1_385) AT=660.025n

.meas tran vdout1_386ck1310 FIND v(dout1_386) AT=660.025n

.meas tran vdout1_387ck1310 FIND v(dout1_387) AT=660.025n

.meas tran vdout1_388ck1310 FIND v(dout1_388) AT=660.025n

.meas tran vdout1_389ck1310 FIND v(dout1_389) AT=660.025n

.meas tran vdout1_390ck1310 FIND v(dout1_390) AT=660.025n

.meas tran vdout1_391ck1310 FIND v(dout1_391) AT=660.025n

.meas tran vdout1_392ck1310 FIND v(dout1_392) AT=660.025n

.meas tran vdout1_393ck1310 FIND v(dout1_393) AT=660.025n

.meas tran vdout1_394ck1310 FIND v(dout1_394) AT=660.025n

.meas tran vdout1_395ck1310 FIND v(dout1_395) AT=660.025n

.meas tran vdout1_396ck1310 FIND v(dout1_396) AT=660.025n

.meas tran vdout1_397ck1310 FIND v(dout1_397) AT=660.025n

.meas tran vdout1_398ck1310 FIND v(dout1_398) AT=660.025n

.meas tran vdout1_399ck1310 FIND v(dout1_399) AT=660.025n

.meas tran vdout1_400ck1310 FIND v(dout1_400) AT=660.025n

.meas tran vdout1_401ck1310 FIND v(dout1_401) AT=660.025n

.meas tran vdout1_402ck1310 FIND v(dout1_402) AT=660.025n

.meas tran vdout1_403ck1310 FIND v(dout1_403) AT=660.025n

.meas tran vdout1_404ck1310 FIND v(dout1_404) AT=660.025n

.meas tran vdout1_405ck1310 FIND v(dout1_405) AT=660.025n

.meas tran vdout1_406ck1310 FIND v(dout1_406) AT=660.025n

.meas tran vdout1_407ck1310 FIND v(dout1_407) AT=660.025n

.meas tran vdout1_408ck1310 FIND v(dout1_408) AT=660.025n

.meas tran vdout1_409ck1310 FIND v(dout1_409) AT=660.025n

.meas tran vdout1_410ck1310 FIND v(dout1_410) AT=660.025n

.meas tran vdout1_411ck1310 FIND v(dout1_411) AT=660.025n

.meas tran vdout1_412ck1310 FIND v(dout1_412) AT=660.025n

.meas tran vdout1_413ck1310 FIND v(dout1_413) AT=660.025n

.meas tran vdout1_414ck1310 FIND v(dout1_414) AT=660.025n

.meas tran vdout1_415ck1310 FIND v(dout1_415) AT=660.025n

.meas tran vdout1_416ck1310 FIND v(dout1_416) AT=660.025n

.meas tran vdout1_417ck1310 FIND v(dout1_417) AT=660.025n

.meas tran vdout1_418ck1310 FIND v(dout1_418) AT=660.025n

.meas tran vdout1_419ck1310 FIND v(dout1_419) AT=660.025n

.meas tran vdout1_420ck1310 FIND v(dout1_420) AT=660.025n

.meas tran vdout1_421ck1310 FIND v(dout1_421) AT=660.025n

.meas tran vdout1_422ck1310 FIND v(dout1_422) AT=660.025n

.meas tran vdout1_423ck1310 FIND v(dout1_423) AT=660.025n

.meas tran vdout1_424ck1310 FIND v(dout1_424) AT=660.025n

.meas tran vdout1_425ck1310 FIND v(dout1_425) AT=660.025n

.meas tran vdout1_426ck1310 FIND v(dout1_426) AT=660.025n

.meas tran vdout1_427ck1310 FIND v(dout1_427) AT=660.025n

.meas tran vdout1_428ck1310 FIND v(dout1_428) AT=660.025n

.meas tran vdout1_429ck1310 FIND v(dout1_429) AT=660.025n

.meas tran vdout1_430ck1310 FIND v(dout1_430) AT=660.025n

.meas tran vdout1_431ck1310 FIND v(dout1_431) AT=660.025n

.meas tran vdout1_432ck1310 FIND v(dout1_432) AT=660.025n

.meas tran vdout1_433ck1310 FIND v(dout1_433) AT=660.025n

.meas tran vdout1_434ck1310 FIND v(dout1_434) AT=660.025n

.meas tran vdout1_435ck1310 FIND v(dout1_435) AT=660.025n

.meas tran vdout1_436ck1310 FIND v(dout1_436) AT=660.025n

.meas tran vdout1_437ck1310 FIND v(dout1_437) AT=660.025n

.meas tran vdout1_438ck1310 FIND v(dout1_438) AT=660.025n

.meas tran vdout1_439ck1310 FIND v(dout1_439) AT=660.025n

.meas tran vdout1_440ck1310 FIND v(dout1_440) AT=660.025n

.meas tran vdout1_441ck1310 FIND v(dout1_441) AT=660.025n

.meas tran vdout1_442ck1310 FIND v(dout1_442) AT=660.025n

.meas tran vdout1_443ck1310 FIND v(dout1_443) AT=660.025n

.meas tran vdout1_444ck1310 FIND v(dout1_444) AT=660.025n

.meas tran vdout1_445ck1310 FIND v(dout1_445) AT=660.025n

.meas tran vdout1_446ck1310 FIND v(dout1_446) AT=660.025n

.meas tran vdout1_447ck1310 FIND v(dout1_447) AT=660.025n

.meas tran vdout1_448ck1310 FIND v(dout1_448) AT=660.025n

.meas tran vdout1_449ck1310 FIND v(dout1_449) AT=660.025n

.meas tran vdout1_450ck1310 FIND v(dout1_450) AT=660.025n

.meas tran vdout1_451ck1310 FIND v(dout1_451) AT=660.025n

.meas tran vdout1_452ck1310 FIND v(dout1_452) AT=660.025n

.meas tran vdout1_453ck1310 FIND v(dout1_453) AT=660.025n

.meas tran vdout1_454ck1310 FIND v(dout1_454) AT=660.025n

.meas tran vdout1_455ck1310 FIND v(dout1_455) AT=660.025n

.meas tran vdout1_456ck1310 FIND v(dout1_456) AT=660.025n

.meas tran vdout1_457ck1310 FIND v(dout1_457) AT=660.025n

.meas tran vdout1_458ck1310 FIND v(dout1_458) AT=660.025n

.meas tran vdout1_459ck1310 FIND v(dout1_459) AT=660.025n

.meas tran vdout1_460ck1310 FIND v(dout1_460) AT=660.025n

.meas tran vdout1_461ck1310 FIND v(dout1_461) AT=660.025n

.meas tran vdout1_462ck1310 FIND v(dout1_462) AT=660.025n

.meas tran vdout1_463ck1310 FIND v(dout1_463) AT=660.025n

.meas tran vdout1_464ck1310 FIND v(dout1_464) AT=660.025n

.meas tran vdout1_465ck1310 FIND v(dout1_465) AT=660.025n

.meas tran vdout1_466ck1310 FIND v(dout1_466) AT=660.025n

.meas tran vdout1_467ck1310 FIND v(dout1_467) AT=660.025n

.meas tran vdout1_468ck1310 FIND v(dout1_468) AT=660.025n

.meas tran vdout1_469ck1310 FIND v(dout1_469) AT=660.025n

.meas tran vdout1_470ck1310 FIND v(dout1_470) AT=660.025n

.meas tran vdout1_471ck1310 FIND v(dout1_471) AT=660.025n

.meas tran vdout1_472ck1310 FIND v(dout1_472) AT=660.025n

.meas tran vdout1_473ck1310 FIND v(dout1_473) AT=660.025n

.meas tran vdout1_474ck1310 FIND v(dout1_474) AT=660.025n

.meas tran vdout1_475ck1310 FIND v(dout1_475) AT=660.025n

.meas tran vdout1_476ck1310 FIND v(dout1_476) AT=660.025n

.meas tran vdout1_477ck1310 FIND v(dout1_477) AT=660.025n

.meas tran vdout1_478ck1310 FIND v(dout1_478) AT=660.025n

.meas tran vdout1_479ck1310 FIND v(dout1_479) AT=660.025n

.meas tran vdout1_480ck1310 FIND v(dout1_480) AT=660.025n

.meas tran vdout1_481ck1310 FIND v(dout1_481) AT=660.025n

.meas tran vdout1_482ck1310 FIND v(dout1_482) AT=660.025n

.meas tran vdout1_483ck1310 FIND v(dout1_483) AT=660.025n

.meas tran vdout1_484ck1310 FIND v(dout1_484) AT=660.025n

.meas tran vdout1_485ck1310 FIND v(dout1_485) AT=660.025n

.meas tran vdout1_486ck1310 FIND v(dout1_486) AT=660.025n

.meas tran vdout1_487ck1310 FIND v(dout1_487) AT=660.025n

.meas tran vdout1_488ck1310 FIND v(dout1_488) AT=660.025n

.meas tran vdout1_489ck1310 FIND v(dout1_489) AT=660.025n

.meas tran vdout1_490ck1310 FIND v(dout1_490) AT=660.025n

.meas tran vdout1_491ck1310 FIND v(dout1_491) AT=660.025n

.meas tran vdout1_492ck1310 FIND v(dout1_492) AT=660.025n

.meas tran vdout1_493ck1310 FIND v(dout1_493) AT=660.025n

.meas tran vdout1_494ck1310 FIND v(dout1_494) AT=660.025n

.meas tran vdout1_495ck1310 FIND v(dout1_495) AT=660.025n

.meas tran vdout1_496ck1310 FIND v(dout1_496) AT=660.025n

.meas tran vdout1_497ck1310 FIND v(dout1_497) AT=660.025n

.meas tran vdout1_498ck1310 FIND v(dout1_498) AT=660.025n

.meas tran vdout1_499ck1310 FIND v(dout1_499) AT=660.025n

.meas tran vdout1_500ck1310 FIND v(dout1_500) AT=660.025n

.meas tran vdout1_501ck1310 FIND v(dout1_501) AT=660.025n

.meas tran vdout1_502ck1310 FIND v(dout1_502) AT=660.025n

.meas tran vdout1_503ck1310 FIND v(dout1_503) AT=660.025n

.meas tran vdout1_504ck1310 FIND v(dout1_504) AT=660.025n

.meas tran vdout1_505ck1310 FIND v(dout1_505) AT=660.025n

.meas tran vdout1_506ck1310 FIND v(dout1_506) AT=660.025n

.meas tran vdout1_507ck1310 FIND v(dout1_507) AT=660.025n

.meas tran vdout1_508ck1310 FIND v(dout1_508) AT=660.025n

.meas tran vdout1_509ck1310 FIND v(dout1_509) AT=660.025n

.meas tran vdout1_510ck1310 FIND v(dout1_510) AT=660.025n

.meas tran vdout1_511ck1310 FIND v(dout1_511) AT=660.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_32ck1350 FIND v(dout1_32) AT=680.025n

.meas tran vdout1_33ck1350 FIND v(dout1_33) AT=680.025n

.meas tran vdout1_34ck1350 FIND v(dout1_34) AT=680.025n

.meas tran vdout1_35ck1350 FIND v(dout1_35) AT=680.025n

.meas tran vdout1_36ck1350 FIND v(dout1_36) AT=680.025n

.meas tran vdout1_37ck1350 FIND v(dout1_37) AT=680.025n

.meas tran vdout1_38ck1350 FIND v(dout1_38) AT=680.025n

.meas tran vdout1_39ck1350 FIND v(dout1_39) AT=680.025n

.meas tran vdout1_40ck1350 FIND v(dout1_40) AT=680.025n

.meas tran vdout1_41ck1350 FIND v(dout1_41) AT=680.025n

.meas tran vdout1_42ck1350 FIND v(dout1_42) AT=680.025n

.meas tran vdout1_43ck1350 FIND v(dout1_43) AT=680.025n

.meas tran vdout1_44ck1350 FIND v(dout1_44) AT=680.025n

.meas tran vdout1_45ck1350 FIND v(dout1_45) AT=680.025n

.meas tran vdout1_46ck1350 FIND v(dout1_46) AT=680.025n

.meas tran vdout1_47ck1350 FIND v(dout1_47) AT=680.025n

.meas tran vdout1_48ck1350 FIND v(dout1_48) AT=680.025n

.meas tran vdout1_49ck1350 FIND v(dout1_49) AT=680.025n

.meas tran vdout1_50ck1350 FIND v(dout1_50) AT=680.025n

.meas tran vdout1_51ck1350 FIND v(dout1_51) AT=680.025n

.meas tran vdout1_52ck1350 FIND v(dout1_52) AT=680.025n

.meas tran vdout1_53ck1350 FIND v(dout1_53) AT=680.025n

.meas tran vdout1_54ck1350 FIND v(dout1_54) AT=680.025n

.meas tran vdout1_55ck1350 FIND v(dout1_55) AT=680.025n

.meas tran vdout1_56ck1350 FIND v(dout1_56) AT=680.025n

.meas tran vdout1_57ck1350 FIND v(dout1_57) AT=680.025n

.meas tran vdout1_58ck1350 FIND v(dout1_58) AT=680.025n

.meas tran vdout1_59ck1350 FIND v(dout1_59) AT=680.025n

.meas tran vdout1_60ck1350 FIND v(dout1_60) AT=680.025n

.meas tran vdout1_61ck1350 FIND v(dout1_61) AT=680.025n

.meas tran vdout1_62ck1350 FIND v(dout1_62) AT=680.025n

.meas tran vdout1_63ck1350 FIND v(dout1_63) AT=680.025n

.meas tran vdout1_64ck1350 FIND v(dout1_64) AT=680.025n

.meas tran vdout1_65ck1350 FIND v(dout1_65) AT=680.025n

.meas tran vdout1_66ck1350 FIND v(dout1_66) AT=680.025n

.meas tran vdout1_67ck1350 FIND v(dout1_67) AT=680.025n

.meas tran vdout1_68ck1350 FIND v(dout1_68) AT=680.025n

.meas tran vdout1_69ck1350 FIND v(dout1_69) AT=680.025n

.meas tran vdout1_70ck1350 FIND v(dout1_70) AT=680.025n

.meas tran vdout1_71ck1350 FIND v(dout1_71) AT=680.025n

.meas tran vdout1_72ck1350 FIND v(dout1_72) AT=680.025n

.meas tran vdout1_73ck1350 FIND v(dout1_73) AT=680.025n

.meas tran vdout1_74ck1350 FIND v(dout1_74) AT=680.025n

.meas tran vdout1_75ck1350 FIND v(dout1_75) AT=680.025n

.meas tran vdout1_76ck1350 FIND v(dout1_76) AT=680.025n

.meas tran vdout1_77ck1350 FIND v(dout1_77) AT=680.025n

.meas tran vdout1_78ck1350 FIND v(dout1_78) AT=680.025n

.meas tran vdout1_79ck1350 FIND v(dout1_79) AT=680.025n

.meas tran vdout1_80ck1350 FIND v(dout1_80) AT=680.025n

.meas tran vdout1_81ck1350 FIND v(dout1_81) AT=680.025n

.meas tran vdout1_82ck1350 FIND v(dout1_82) AT=680.025n

.meas tran vdout1_83ck1350 FIND v(dout1_83) AT=680.025n

.meas tran vdout1_84ck1350 FIND v(dout1_84) AT=680.025n

.meas tran vdout1_85ck1350 FIND v(dout1_85) AT=680.025n

.meas tran vdout1_86ck1350 FIND v(dout1_86) AT=680.025n

.meas tran vdout1_87ck1350 FIND v(dout1_87) AT=680.025n

.meas tran vdout1_88ck1350 FIND v(dout1_88) AT=680.025n

.meas tran vdout1_89ck1350 FIND v(dout1_89) AT=680.025n

.meas tran vdout1_90ck1350 FIND v(dout1_90) AT=680.025n

.meas tran vdout1_91ck1350 FIND v(dout1_91) AT=680.025n

.meas tran vdout1_92ck1350 FIND v(dout1_92) AT=680.025n

.meas tran vdout1_93ck1350 FIND v(dout1_93) AT=680.025n

.meas tran vdout1_94ck1350 FIND v(dout1_94) AT=680.025n

.meas tran vdout1_95ck1350 FIND v(dout1_95) AT=680.025n

.meas tran vdout1_96ck1350 FIND v(dout1_96) AT=680.025n

.meas tran vdout1_97ck1350 FIND v(dout1_97) AT=680.025n

.meas tran vdout1_98ck1350 FIND v(dout1_98) AT=680.025n

.meas tran vdout1_99ck1350 FIND v(dout1_99) AT=680.025n

.meas tran vdout1_100ck1350 FIND v(dout1_100) AT=680.025n

.meas tran vdout1_101ck1350 FIND v(dout1_101) AT=680.025n

.meas tran vdout1_102ck1350 FIND v(dout1_102) AT=680.025n

.meas tran vdout1_103ck1350 FIND v(dout1_103) AT=680.025n

.meas tran vdout1_104ck1350 FIND v(dout1_104) AT=680.025n

.meas tran vdout1_105ck1350 FIND v(dout1_105) AT=680.025n

.meas tran vdout1_106ck1350 FIND v(dout1_106) AT=680.025n

.meas tran vdout1_107ck1350 FIND v(dout1_107) AT=680.025n

.meas tran vdout1_108ck1350 FIND v(dout1_108) AT=680.025n

.meas tran vdout1_109ck1350 FIND v(dout1_109) AT=680.025n

.meas tran vdout1_110ck1350 FIND v(dout1_110) AT=680.025n

.meas tran vdout1_111ck1350 FIND v(dout1_111) AT=680.025n

.meas tran vdout1_112ck1350 FIND v(dout1_112) AT=680.025n

.meas tran vdout1_113ck1350 FIND v(dout1_113) AT=680.025n

.meas tran vdout1_114ck1350 FIND v(dout1_114) AT=680.025n

.meas tran vdout1_115ck1350 FIND v(dout1_115) AT=680.025n

.meas tran vdout1_116ck1350 FIND v(dout1_116) AT=680.025n

.meas tran vdout1_117ck1350 FIND v(dout1_117) AT=680.025n

.meas tran vdout1_118ck1350 FIND v(dout1_118) AT=680.025n

.meas tran vdout1_119ck1350 FIND v(dout1_119) AT=680.025n

.meas tran vdout1_120ck1350 FIND v(dout1_120) AT=680.025n

.meas tran vdout1_121ck1350 FIND v(dout1_121) AT=680.025n

.meas tran vdout1_122ck1350 FIND v(dout1_122) AT=680.025n

.meas tran vdout1_123ck1350 FIND v(dout1_123) AT=680.025n

.meas tran vdout1_124ck1350 FIND v(dout1_124) AT=680.025n

.meas tran vdout1_125ck1350 FIND v(dout1_125) AT=680.025n

.meas tran vdout1_126ck1350 FIND v(dout1_126) AT=680.025n

.meas tran vdout1_127ck1350 FIND v(dout1_127) AT=680.025n

.meas tran vdout1_128ck1350 FIND v(dout1_128) AT=680.025n

.meas tran vdout1_129ck1350 FIND v(dout1_129) AT=680.025n

.meas tran vdout1_130ck1350 FIND v(dout1_130) AT=680.025n

.meas tran vdout1_131ck1350 FIND v(dout1_131) AT=680.025n

.meas tran vdout1_132ck1350 FIND v(dout1_132) AT=680.025n

.meas tran vdout1_133ck1350 FIND v(dout1_133) AT=680.025n

.meas tran vdout1_134ck1350 FIND v(dout1_134) AT=680.025n

.meas tran vdout1_135ck1350 FIND v(dout1_135) AT=680.025n

.meas tran vdout1_136ck1350 FIND v(dout1_136) AT=680.025n

.meas tran vdout1_137ck1350 FIND v(dout1_137) AT=680.025n

.meas tran vdout1_138ck1350 FIND v(dout1_138) AT=680.025n

.meas tran vdout1_139ck1350 FIND v(dout1_139) AT=680.025n

.meas tran vdout1_140ck1350 FIND v(dout1_140) AT=680.025n

.meas tran vdout1_141ck1350 FIND v(dout1_141) AT=680.025n

.meas tran vdout1_142ck1350 FIND v(dout1_142) AT=680.025n

.meas tran vdout1_143ck1350 FIND v(dout1_143) AT=680.025n

.meas tran vdout1_144ck1350 FIND v(dout1_144) AT=680.025n

.meas tran vdout1_145ck1350 FIND v(dout1_145) AT=680.025n

.meas tran vdout1_146ck1350 FIND v(dout1_146) AT=680.025n

.meas tran vdout1_147ck1350 FIND v(dout1_147) AT=680.025n

.meas tran vdout1_148ck1350 FIND v(dout1_148) AT=680.025n

.meas tran vdout1_149ck1350 FIND v(dout1_149) AT=680.025n

.meas tran vdout1_150ck1350 FIND v(dout1_150) AT=680.025n

.meas tran vdout1_151ck1350 FIND v(dout1_151) AT=680.025n

.meas tran vdout1_152ck1350 FIND v(dout1_152) AT=680.025n

.meas tran vdout1_153ck1350 FIND v(dout1_153) AT=680.025n

.meas tran vdout1_154ck1350 FIND v(dout1_154) AT=680.025n

.meas tran vdout1_155ck1350 FIND v(dout1_155) AT=680.025n

.meas tran vdout1_156ck1350 FIND v(dout1_156) AT=680.025n

.meas tran vdout1_157ck1350 FIND v(dout1_157) AT=680.025n

.meas tran vdout1_158ck1350 FIND v(dout1_158) AT=680.025n

.meas tran vdout1_159ck1350 FIND v(dout1_159) AT=680.025n

.meas tran vdout1_160ck1350 FIND v(dout1_160) AT=680.025n

.meas tran vdout1_161ck1350 FIND v(dout1_161) AT=680.025n

.meas tran vdout1_162ck1350 FIND v(dout1_162) AT=680.025n

.meas tran vdout1_163ck1350 FIND v(dout1_163) AT=680.025n

.meas tran vdout1_164ck1350 FIND v(dout1_164) AT=680.025n

.meas tran vdout1_165ck1350 FIND v(dout1_165) AT=680.025n

.meas tran vdout1_166ck1350 FIND v(dout1_166) AT=680.025n

.meas tran vdout1_167ck1350 FIND v(dout1_167) AT=680.025n

.meas tran vdout1_168ck1350 FIND v(dout1_168) AT=680.025n

.meas tran vdout1_169ck1350 FIND v(dout1_169) AT=680.025n

.meas tran vdout1_170ck1350 FIND v(dout1_170) AT=680.025n

.meas tran vdout1_171ck1350 FIND v(dout1_171) AT=680.025n

.meas tran vdout1_172ck1350 FIND v(dout1_172) AT=680.025n

.meas tran vdout1_173ck1350 FIND v(dout1_173) AT=680.025n

.meas tran vdout1_174ck1350 FIND v(dout1_174) AT=680.025n

.meas tran vdout1_175ck1350 FIND v(dout1_175) AT=680.025n

.meas tran vdout1_176ck1350 FIND v(dout1_176) AT=680.025n

.meas tran vdout1_177ck1350 FIND v(dout1_177) AT=680.025n

.meas tran vdout1_178ck1350 FIND v(dout1_178) AT=680.025n

.meas tran vdout1_179ck1350 FIND v(dout1_179) AT=680.025n

.meas tran vdout1_180ck1350 FIND v(dout1_180) AT=680.025n

.meas tran vdout1_181ck1350 FIND v(dout1_181) AT=680.025n

.meas tran vdout1_182ck1350 FIND v(dout1_182) AT=680.025n

.meas tran vdout1_183ck1350 FIND v(dout1_183) AT=680.025n

.meas tran vdout1_184ck1350 FIND v(dout1_184) AT=680.025n

.meas tran vdout1_185ck1350 FIND v(dout1_185) AT=680.025n

.meas tran vdout1_186ck1350 FIND v(dout1_186) AT=680.025n

.meas tran vdout1_187ck1350 FIND v(dout1_187) AT=680.025n

.meas tran vdout1_188ck1350 FIND v(dout1_188) AT=680.025n

.meas tran vdout1_189ck1350 FIND v(dout1_189) AT=680.025n

.meas tran vdout1_190ck1350 FIND v(dout1_190) AT=680.025n

.meas tran vdout1_191ck1350 FIND v(dout1_191) AT=680.025n

.meas tran vdout1_192ck1350 FIND v(dout1_192) AT=680.025n

.meas tran vdout1_193ck1350 FIND v(dout1_193) AT=680.025n

.meas tran vdout1_194ck1350 FIND v(dout1_194) AT=680.025n

.meas tran vdout1_195ck1350 FIND v(dout1_195) AT=680.025n

.meas tran vdout1_196ck1350 FIND v(dout1_196) AT=680.025n

.meas tran vdout1_197ck1350 FIND v(dout1_197) AT=680.025n

.meas tran vdout1_198ck1350 FIND v(dout1_198) AT=680.025n

.meas tran vdout1_199ck1350 FIND v(dout1_199) AT=680.025n

.meas tran vdout1_200ck1350 FIND v(dout1_200) AT=680.025n

.meas tran vdout1_201ck1350 FIND v(dout1_201) AT=680.025n

.meas tran vdout1_202ck1350 FIND v(dout1_202) AT=680.025n

.meas tran vdout1_203ck1350 FIND v(dout1_203) AT=680.025n

.meas tran vdout1_204ck1350 FIND v(dout1_204) AT=680.025n

.meas tran vdout1_205ck1350 FIND v(dout1_205) AT=680.025n

.meas tran vdout1_206ck1350 FIND v(dout1_206) AT=680.025n

.meas tran vdout1_207ck1350 FIND v(dout1_207) AT=680.025n

.meas tran vdout1_208ck1350 FIND v(dout1_208) AT=680.025n

.meas tran vdout1_209ck1350 FIND v(dout1_209) AT=680.025n

.meas tran vdout1_210ck1350 FIND v(dout1_210) AT=680.025n

.meas tran vdout1_211ck1350 FIND v(dout1_211) AT=680.025n

.meas tran vdout1_212ck1350 FIND v(dout1_212) AT=680.025n

.meas tran vdout1_213ck1350 FIND v(dout1_213) AT=680.025n

.meas tran vdout1_214ck1350 FIND v(dout1_214) AT=680.025n

.meas tran vdout1_215ck1350 FIND v(dout1_215) AT=680.025n

.meas tran vdout1_216ck1350 FIND v(dout1_216) AT=680.025n

.meas tran vdout1_217ck1350 FIND v(dout1_217) AT=680.025n

.meas tran vdout1_218ck1350 FIND v(dout1_218) AT=680.025n

.meas tran vdout1_219ck1350 FIND v(dout1_219) AT=680.025n

.meas tran vdout1_220ck1350 FIND v(dout1_220) AT=680.025n

.meas tran vdout1_221ck1350 FIND v(dout1_221) AT=680.025n

.meas tran vdout1_222ck1350 FIND v(dout1_222) AT=680.025n

.meas tran vdout1_223ck1350 FIND v(dout1_223) AT=680.025n

.meas tran vdout1_224ck1350 FIND v(dout1_224) AT=680.025n

.meas tran vdout1_225ck1350 FIND v(dout1_225) AT=680.025n

.meas tran vdout1_226ck1350 FIND v(dout1_226) AT=680.025n

.meas tran vdout1_227ck1350 FIND v(dout1_227) AT=680.025n

.meas tran vdout1_228ck1350 FIND v(dout1_228) AT=680.025n

.meas tran vdout1_229ck1350 FIND v(dout1_229) AT=680.025n

.meas tran vdout1_230ck1350 FIND v(dout1_230) AT=680.025n

.meas tran vdout1_231ck1350 FIND v(dout1_231) AT=680.025n

.meas tran vdout1_232ck1350 FIND v(dout1_232) AT=680.025n

.meas tran vdout1_233ck1350 FIND v(dout1_233) AT=680.025n

.meas tran vdout1_234ck1350 FIND v(dout1_234) AT=680.025n

.meas tran vdout1_235ck1350 FIND v(dout1_235) AT=680.025n

.meas tran vdout1_236ck1350 FIND v(dout1_236) AT=680.025n

.meas tran vdout1_237ck1350 FIND v(dout1_237) AT=680.025n

.meas tran vdout1_238ck1350 FIND v(dout1_238) AT=680.025n

.meas tran vdout1_239ck1350 FIND v(dout1_239) AT=680.025n

.meas tran vdout1_240ck1350 FIND v(dout1_240) AT=680.025n

.meas tran vdout1_241ck1350 FIND v(dout1_241) AT=680.025n

.meas tran vdout1_242ck1350 FIND v(dout1_242) AT=680.025n

.meas tran vdout1_243ck1350 FIND v(dout1_243) AT=680.025n

.meas tran vdout1_244ck1350 FIND v(dout1_244) AT=680.025n

.meas tran vdout1_245ck1350 FIND v(dout1_245) AT=680.025n

.meas tran vdout1_246ck1350 FIND v(dout1_246) AT=680.025n

.meas tran vdout1_247ck1350 FIND v(dout1_247) AT=680.025n

.meas tran vdout1_248ck1350 FIND v(dout1_248) AT=680.025n

.meas tran vdout1_249ck1350 FIND v(dout1_249) AT=680.025n

.meas tran vdout1_250ck1350 FIND v(dout1_250) AT=680.025n

.meas tran vdout1_251ck1350 FIND v(dout1_251) AT=680.025n

.meas tran vdout1_252ck1350 FIND v(dout1_252) AT=680.025n

.meas tran vdout1_253ck1350 FIND v(dout1_253) AT=680.025n

.meas tran vdout1_254ck1350 FIND v(dout1_254) AT=680.025n

.meas tran vdout1_255ck1350 FIND v(dout1_255) AT=680.025n

.meas tran vdout1_256ck1350 FIND v(dout1_256) AT=680.025n

.meas tran vdout1_257ck1350 FIND v(dout1_257) AT=680.025n

.meas tran vdout1_258ck1350 FIND v(dout1_258) AT=680.025n

.meas tran vdout1_259ck1350 FIND v(dout1_259) AT=680.025n

.meas tran vdout1_260ck1350 FIND v(dout1_260) AT=680.025n

.meas tran vdout1_261ck1350 FIND v(dout1_261) AT=680.025n

.meas tran vdout1_262ck1350 FIND v(dout1_262) AT=680.025n

.meas tran vdout1_263ck1350 FIND v(dout1_263) AT=680.025n

.meas tran vdout1_264ck1350 FIND v(dout1_264) AT=680.025n

.meas tran vdout1_265ck1350 FIND v(dout1_265) AT=680.025n

.meas tran vdout1_266ck1350 FIND v(dout1_266) AT=680.025n

.meas tran vdout1_267ck1350 FIND v(dout1_267) AT=680.025n

.meas tran vdout1_268ck1350 FIND v(dout1_268) AT=680.025n

.meas tran vdout1_269ck1350 FIND v(dout1_269) AT=680.025n

.meas tran vdout1_270ck1350 FIND v(dout1_270) AT=680.025n

.meas tran vdout1_271ck1350 FIND v(dout1_271) AT=680.025n

.meas tran vdout1_272ck1350 FIND v(dout1_272) AT=680.025n

.meas tran vdout1_273ck1350 FIND v(dout1_273) AT=680.025n

.meas tran vdout1_274ck1350 FIND v(dout1_274) AT=680.025n

.meas tran vdout1_275ck1350 FIND v(dout1_275) AT=680.025n

.meas tran vdout1_276ck1350 FIND v(dout1_276) AT=680.025n

.meas tran vdout1_277ck1350 FIND v(dout1_277) AT=680.025n

.meas tran vdout1_278ck1350 FIND v(dout1_278) AT=680.025n

.meas tran vdout1_279ck1350 FIND v(dout1_279) AT=680.025n

.meas tran vdout1_280ck1350 FIND v(dout1_280) AT=680.025n

.meas tran vdout1_281ck1350 FIND v(dout1_281) AT=680.025n

.meas tran vdout1_282ck1350 FIND v(dout1_282) AT=680.025n

.meas tran vdout1_283ck1350 FIND v(dout1_283) AT=680.025n

.meas tran vdout1_284ck1350 FIND v(dout1_284) AT=680.025n

.meas tran vdout1_285ck1350 FIND v(dout1_285) AT=680.025n

.meas tran vdout1_286ck1350 FIND v(dout1_286) AT=680.025n

.meas tran vdout1_287ck1350 FIND v(dout1_287) AT=680.025n

.meas tran vdout1_288ck1350 FIND v(dout1_288) AT=680.025n

.meas tran vdout1_289ck1350 FIND v(dout1_289) AT=680.025n

.meas tran vdout1_290ck1350 FIND v(dout1_290) AT=680.025n

.meas tran vdout1_291ck1350 FIND v(dout1_291) AT=680.025n

.meas tran vdout1_292ck1350 FIND v(dout1_292) AT=680.025n

.meas tran vdout1_293ck1350 FIND v(dout1_293) AT=680.025n

.meas tran vdout1_294ck1350 FIND v(dout1_294) AT=680.025n

.meas tran vdout1_295ck1350 FIND v(dout1_295) AT=680.025n

.meas tran vdout1_296ck1350 FIND v(dout1_296) AT=680.025n

.meas tran vdout1_297ck1350 FIND v(dout1_297) AT=680.025n

.meas tran vdout1_298ck1350 FIND v(dout1_298) AT=680.025n

.meas tran vdout1_299ck1350 FIND v(dout1_299) AT=680.025n

.meas tran vdout1_300ck1350 FIND v(dout1_300) AT=680.025n

.meas tran vdout1_301ck1350 FIND v(dout1_301) AT=680.025n

.meas tran vdout1_302ck1350 FIND v(dout1_302) AT=680.025n

.meas tran vdout1_303ck1350 FIND v(dout1_303) AT=680.025n

.meas tran vdout1_304ck1350 FIND v(dout1_304) AT=680.025n

.meas tran vdout1_305ck1350 FIND v(dout1_305) AT=680.025n

.meas tran vdout1_306ck1350 FIND v(dout1_306) AT=680.025n

.meas tran vdout1_307ck1350 FIND v(dout1_307) AT=680.025n

.meas tran vdout1_308ck1350 FIND v(dout1_308) AT=680.025n

.meas tran vdout1_309ck1350 FIND v(dout1_309) AT=680.025n

.meas tran vdout1_310ck1350 FIND v(dout1_310) AT=680.025n

.meas tran vdout1_311ck1350 FIND v(dout1_311) AT=680.025n

.meas tran vdout1_312ck1350 FIND v(dout1_312) AT=680.025n

.meas tran vdout1_313ck1350 FIND v(dout1_313) AT=680.025n

.meas tran vdout1_314ck1350 FIND v(dout1_314) AT=680.025n

.meas tran vdout1_315ck1350 FIND v(dout1_315) AT=680.025n

.meas tran vdout1_316ck1350 FIND v(dout1_316) AT=680.025n

.meas tran vdout1_317ck1350 FIND v(dout1_317) AT=680.025n

.meas tran vdout1_318ck1350 FIND v(dout1_318) AT=680.025n

.meas tran vdout1_319ck1350 FIND v(dout1_319) AT=680.025n

.meas tran vdout1_320ck1350 FIND v(dout1_320) AT=680.025n

.meas tran vdout1_321ck1350 FIND v(dout1_321) AT=680.025n

.meas tran vdout1_322ck1350 FIND v(dout1_322) AT=680.025n

.meas tran vdout1_323ck1350 FIND v(dout1_323) AT=680.025n

.meas tran vdout1_324ck1350 FIND v(dout1_324) AT=680.025n

.meas tran vdout1_325ck1350 FIND v(dout1_325) AT=680.025n

.meas tran vdout1_326ck1350 FIND v(dout1_326) AT=680.025n

.meas tran vdout1_327ck1350 FIND v(dout1_327) AT=680.025n

.meas tran vdout1_328ck1350 FIND v(dout1_328) AT=680.025n

.meas tran vdout1_329ck1350 FIND v(dout1_329) AT=680.025n

.meas tran vdout1_330ck1350 FIND v(dout1_330) AT=680.025n

.meas tran vdout1_331ck1350 FIND v(dout1_331) AT=680.025n

.meas tran vdout1_332ck1350 FIND v(dout1_332) AT=680.025n

.meas tran vdout1_333ck1350 FIND v(dout1_333) AT=680.025n

.meas tran vdout1_334ck1350 FIND v(dout1_334) AT=680.025n

.meas tran vdout1_335ck1350 FIND v(dout1_335) AT=680.025n

.meas tran vdout1_336ck1350 FIND v(dout1_336) AT=680.025n

.meas tran vdout1_337ck1350 FIND v(dout1_337) AT=680.025n

.meas tran vdout1_338ck1350 FIND v(dout1_338) AT=680.025n

.meas tran vdout1_339ck1350 FIND v(dout1_339) AT=680.025n

.meas tran vdout1_340ck1350 FIND v(dout1_340) AT=680.025n

.meas tran vdout1_341ck1350 FIND v(dout1_341) AT=680.025n

.meas tran vdout1_342ck1350 FIND v(dout1_342) AT=680.025n

.meas tran vdout1_343ck1350 FIND v(dout1_343) AT=680.025n

.meas tran vdout1_344ck1350 FIND v(dout1_344) AT=680.025n

.meas tran vdout1_345ck1350 FIND v(dout1_345) AT=680.025n

.meas tran vdout1_346ck1350 FIND v(dout1_346) AT=680.025n

.meas tran vdout1_347ck1350 FIND v(dout1_347) AT=680.025n

.meas tran vdout1_348ck1350 FIND v(dout1_348) AT=680.025n

.meas tran vdout1_349ck1350 FIND v(dout1_349) AT=680.025n

.meas tran vdout1_350ck1350 FIND v(dout1_350) AT=680.025n

.meas tran vdout1_351ck1350 FIND v(dout1_351) AT=680.025n

.meas tran vdout1_352ck1350 FIND v(dout1_352) AT=680.025n

.meas tran vdout1_353ck1350 FIND v(dout1_353) AT=680.025n

.meas tran vdout1_354ck1350 FIND v(dout1_354) AT=680.025n

.meas tran vdout1_355ck1350 FIND v(dout1_355) AT=680.025n

.meas tran vdout1_356ck1350 FIND v(dout1_356) AT=680.025n

.meas tran vdout1_357ck1350 FIND v(dout1_357) AT=680.025n

.meas tran vdout1_358ck1350 FIND v(dout1_358) AT=680.025n

.meas tran vdout1_359ck1350 FIND v(dout1_359) AT=680.025n

.meas tran vdout1_360ck1350 FIND v(dout1_360) AT=680.025n

.meas tran vdout1_361ck1350 FIND v(dout1_361) AT=680.025n

.meas tran vdout1_362ck1350 FIND v(dout1_362) AT=680.025n

.meas tran vdout1_363ck1350 FIND v(dout1_363) AT=680.025n

.meas tran vdout1_364ck1350 FIND v(dout1_364) AT=680.025n

.meas tran vdout1_365ck1350 FIND v(dout1_365) AT=680.025n

.meas tran vdout1_366ck1350 FIND v(dout1_366) AT=680.025n

.meas tran vdout1_367ck1350 FIND v(dout1_367) AT=680.025n

.meas tran vdout1_368ck1350 FIND v(dout1_368) AT=680.025n

.meas tran vdout1_369ck1350 FIND v(dout1_369) AT=680.025n

.meas tran vdout1_370ck1350 FIND v(dout1_370) AT=680.025n

.meas tran vdout1_371ck1350 FIND v(dout1_371) AT=680.025n

.meas tran vdout1_372ck1350 FIND v(dout1_372) AT=680.025n

.meas tran vdout1_373ck1350 FIND v(dout1_373) AT=680.025n

.meas tran vdout1_374ck1350 FIND v(dout1_374) AT=680.025n

.meas tran vdout1_375ck1350 FIND v(dout1_375) AT=680.025n

.meas tran vdout1_376ck1350 FIND v(dout1_376) AT=680.025n

.meas tran vdout1_377ck1350 FIND v(dout1_377) AT=680.025n

.meas tran vdout1_378ck1350 FIND v(dout1_378) AT=680.025n

.meas tran vdout1_379ck1350 FIND v(dout1_379) AT=680.025n

.meas tran vdout1_380ck1350 FIND v(dout1_380) AT=680.025n

.meas tran vdout1_381ck1350 FIND v(dout1_381) AT=680.025n

.meas tran vdout1_382ck1350 FIND v(dout1_382) AT=680.025n

.meas tran vdout1_383ck1350 FIND v(dout1_383) AT=680.025n

.meas tran vdout1_384ck1350 FIND v(dout1_384) AT=680.025n

.meas tran vdout1_385ck1350 FIND v(dout1_385) AT=680.025n

.meas tran vdout1_386ck1350 FIND v(dout1_386) AT=680.025n

.meas tran vdout1_387ck1350 FIND v(dout1_387) AT=680.025n

.meas tran vdout1_388ck1350 FIND v(dout1_388) AT=680.025n

.meas tran vdout1_389ck1350 FIND v(dout1_389) AT=680.025n

.meas tran vdout1_390ck1350 FIND v(dout1_390) AT=680.025n

.meas tran vdout1_391ck1350 FIND v(dout1_391) AT=680.025n

.meas tran vdout1_392ck1350 FIND v(dout1_392) AT=680.025n

.meas tran vdout1_393ck1350 FIND v(dout1_393) AT=680.025n

.meas tran vdout1_394ck1350 FIND v(dout1_394) AT=680.025n

.meas tran vdout1_395ck1350 FIND v(dout1_395) AT=680.025n

.meas tran vdout1_396ck1350 FIND v(dout1_396) AT=680.025n

.meas tran vdout1_397ck1350 FIND v(dout1_397) AT=680.025n

.meas tran vdout1_398ck1350 FIND v(dout1_398) AT=680.025n

.meas tran vdout1_399ck1350 FIND v(dout1_399) AT=680.025n

.meas tran vdout1_400ck1350 FIND v(dout1_400) AT=680.025n

.meas tran vdout1_401ck1350 FIND v(dout1_401) AT=680.025n

.meas tran vdout1_402ck1350 FIND v(dout1_402) AT=680.025n

.meas tran vdout1_403ck1350 FIND v(dout1_403) AT=680.025n

.meas tran vdout1_404ck1350 FIND v(dout1_404) AT=680.025n

.meas tran vdout1_405ck1350 FIND v(dout1_405) AT=680.025n

.meas tran vdout1_406ck1350 FIND v(dout1_406) AT=680.025n

.meas tran vdout1_407ck1350 FIND v(dout1_407) AT=680.025n

.meas tran vdout1_408ck1350 FIND v(dout1_408) AT=680.025n

.meas tran vdout1_409ck1350 FIND v(dout1_409) AT=680.025n

.meas tran vdout1_410ck1350 FIND v(dout1_410) AT=680.025n

.meas tran vdout1_411ck1350 FIND v(dout1_411) AT=680.025n

.meas tran vdout1_412ck1350 FIND v(dout1_412) AT=680.025n

.meas tran vdout1_413ck1350 FIND v(dout1_413) AT=680.025n

.meas tran vdout1_414ck1350 FIND v(dout1_414) AT=680.025n

.meas tran vdout1_415ck1350 FIND v(dout1_415) AT=680.025n

.meas tran vdout1_416ck1350 FIND v(dout1_416) AT=680.025n

.meas tran vdout1_417ck1350 FIND v(dout1_417) AT=680.025n

.meas tran vdout1_418ck1350 FIND v(dout1_418) AT=680.025n

.meas tran vdout1_419ck1350 FIND v(dout1_419) AT=680.025n

.meas tran vdout1_420ck1350 FIND v(dout1_420) AT=680.025n

.meas tran vdout1_421ck1350 FIND v(dout1_421) AT=680.025n

.meas tran vdout1_422ck1350 FIND v(dout1_422) AT=680.025n

.meas tran vdout1_423ck1350 FIND v(dout1_423) AT=680.025n

.meas tran vdout1_424ck1350 FIND v(dout1_424) AT=680.025n

.meas tran vdout1_425ck1350 FIND v(dout1_425) AT=680.025n

.meas tran vdout1_426ck1350 FIND v(dout1_426) AT=680.025n

.meas tran vdout1_427ck1350 FIND v(dout1_427) AT=680.025n

.meas tran vdout1_428ck1350 FIND v(dout1_428) AT=680.025n

.meas tran vdout1_429ck1350 FIND v(dout1_429) AT=680.025n

.meas tran vdout1_430ck1350 FIND v(dout1_430) AT=680.025n

.meas tran vdout1_431ck1350 FIND v(dout1_431) AT=680.025n

.meas tran vdout1_432ck1350 FIND v(dout1_432) AT=680.025n

.meas tran vdout1_433ck1350 FIND v(dout1_433) AT=680.025n

.meas tran vdout1_434ck1350 FIND v(dout1_434) AT=680.025n

.meas tran vdout1_435ck1350 FIND v(dout1_435) AT=680.025n

.meas tran vdout1_436ck1350 FIND v(dout1_436) AT=680.025n

.meas tran vdout1_437ck1350 FIND v(dout1_437) AT=680.025n

.meas tran vdout1_438ck1350 FIND v(dout1_438) AT=680.025n

.meas tran vdout1_439ck1350 FIND v(dout1_439) AT=680.025n

.meas tran vdout1_440ck1350 FIND v(dout1_440) AT=680.025n

.meas tran vdout1_441ck1350 FIND v(dout1_441) AT=680.025n

.meas tran vdout1_442ck1350 FIND v(dout1_442) AT=680.025n

.meas tran vdout1_443ck1350 FIND v(dout1_443) AT=680.025n

.meas tran vdout1_444ck1350 FIND v(dout1_444) AT=680.025n

.meas tran vdout1_445ck1350 FIND v(dout1_445) AT=680.025n

.meas tran vdout1_446ck1350 FIND v(dout1_446) AT=680.025n

.meas tran vdout1_447ck1350 FIND v(dout1_447) AT=680.025n

.meas tran vdout1_448ck1350 FIND v(dout1_448) AT=680.025n

.meas tran vdout1_449ck1350 FIND v(dout1_449) AT=680.025n

.meas tran vdout1_450ck1350 FIND v(dout1_450) AT=680.025n

.meas tran vdout1_451ck1350 FIND v(dout1_451) AT=680.025n

.meas tran vdout1_452ck1350 FIND v(dout1_452) AT=680.025n

.meas tran vdout1_453ck1350 FIND v(dout1_453) AT=680.025n

.meas tran vdout1_454ck1350 FIND v(dout1_454) AT=680.025n

.meas tran vdout1_455ck1350 FIND v(dout1_455) AT=680.025n

.meas tran vdout1_456ck1350 FIND v(dout1_456) AT=680.025n

.meas tran vdout1_457ck1350 FIND v(dout1_457) AT=680.025n

.meas tran vdout1_458ck1350 FIND v(dout1_458) AT=680.025n

.meas tran vdout1_459ck1350 FIND v(dout1_459) AT=680.025n

.meas tran vdout1_460ck1350 FIND v(dout1_460) AT=680.025n

.meas tran vdout1_461ck1350 FIND v(dout1_461) AT=680.025n

.meas tran vdout1_462ck1350 FIND v(dout1_462) AT=680.025n

.meas tran vdout1_463ck1350 FIND v(dout1_463) AT=680.025n

.meas tran vdout1_464ck1350 FIND v(dout1_464) AT=680.025n

.meas tran vdout1_465ck1350 FIND v(dout1_465) AT=680.025n

.meas tran vdout1_466ck1350 FIND v(dout1_466) AT=680.025n

.meas tran vdout1_467ck1350 FIND v(dout1_467) AT=680.025n

.meas tran vdout1_468ck1350 FIND v(dout1_468) AT=680.025n

.meas tran vdout1_469ck1350 FIND v(dout1_469) AT=680.025n

.meas tran vdout1_470ck1350 FIND v(dout1_470) AT=680.025n

.meas tran vdout1_471ck1350 FIND v(dout1_471) AT=680.025n

.meas tran vdout1_472ck1350 FIND v(dout1_472) AT=680.025n

.meas tran vdout1_473ck1350 FIND v(dout1_473) AT=680.025n

.meas tran vdout1_474ck1350 FIND v(dout1_474) AT=680.025n

.meas tran vdout1_475ck1350 FIND v(dout1_475) AT=680.025n

.meas tran vdout1_476ck1350 FIND v(dout1_476) AT=680.025n

.meas tran vdout1_477ck1350 FIND v(dout1_477) AT=680.025n

.meas tran vdout1_478ck1350 FIND v(dout1_478) AT=680.025n

.meas tran vdout1_479ck1350 FIND v(dout1_479) AT=680.025n

.meas tran vdout1_480ck1350 FIND v(dout1_480) AT=680.025n

.meas tran vdout1_481ck1350 FIND v(dout1_481) AT=680.025n

.meas tran vdout1_482ck1350 FIND v(dout1_482) AT=680.025n

.meas tran vdout1_483ck1350 FIND v(dout1_483) AT=680.025n

.meas tran vdout1_484ck1350 FIND v(dout1_484) AT=680.025n

.meas tran vdout1_485ck1350 FIND v(dout1_485) AT=680.025n

.meas tran vdout1_486ck1350 FIND v(dout1_486) AT=680.025n

.meas tran vdout1_487ck1350 FIND v(dout1_487) AT=680.025n

.meas tran vdout1_488ck1350 FIND v(dout1_488) AT=680.025n

.meas tran vdout1_489ck1350 FIND v(dout1_489) AT=680.025n

.meas tran vdout1_490ck1350 FIND v(dout1_490) AT=680.025n

.meas tran vdout1_491ck1350 FIND v(dout1_491) AT=680.025n

.meas tran vdout1_492ck1350 FIND v(dout1_492) AT=680.025n

.meas tran vdout1_493ck1350 FIND v(dout1_493) AT=680.025n

.meas tran vdout1_494ck1350 FIND v(dout1_494) AT=680.025n

.meas tran vdout1_495ck1350 FIND v(dout1_495) AT=680.025n

.meas tran vdout1_496ck1350 FIND v(dout1_496) AT=680.025n

.meas tran vdout1_497ck1350 FIND v(dout1_497) AT=680.025n

.meas tran vdout1_498ck1350 FIND v(dout1_498) AT=680.025n

.meas tran vdout1_499ck1350 FIND v(dout1_499) AT=680.025n

.meas tran vdout1_500ck1350 FIND v(dout1_500) AT=680.025n

.meas tran vdout1_501ck1350 FIND v(dout1_501) AT=680.025n

.meas tran vdout1_502ck1350 FIND v(dout1_502) AT=680.025n

.meas tran vdout1_503ck1350 FIND v(dout1_503) AT=680.025n

.meas tran vdout1_504ck1350 FIND v(dout1_504) AT=680.025n

.meas tran vdout1_505ck1350 FIND v(dout1_505) AT=680.025n

.meas tran vdout1_506ck1350 FIND v(dout1_506) AT=680.025n

.meas tran vdout1_507ck1350 FIND v(dout1_507) AT=680.025n

.meas tran vdout1_508ck1350 FIND v(dout1_508) AT=680.025n

.meas tran vdout1_509ck1350 FIND v(dout1_509) AT=680.025n

.meas tran vdout1_510ck1350 FIND v(dout1_510) AT=680.025n

.meas tran vdout1_511ck1350 FIND v(dout1_511) AT=680.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_32ck1380 FIND v(dout1_32) AT=695.025n

.meas tran vdout1_33ck1380 FIND v(dout1_33) AT=695.025n

.meas tran vdout1_34ck1380 FIND v(dout1_34) AT=695.025n

.meas tran vdout1_35ck1380 FIND v(dout1_35) AT=695.025n

.meas tran vdout1_36ck1380 FIND v(dout1_36) AT=695.025n

.meas tran vdout1_37ck1380 FIND v(dout1_37) AT=695.025n

.meas tran vdout1_38ck1380 FIND v(dout1_38) AT=695.025n

.meas tran vdout1_39ck1380 FIND v(dout1_39) AT=695.025n

.meas tran vdout1_40ck1380 FIND v(dout1_40) AT=695.025n

.meas tran vdout1_41ck1380 FIND v(dout1_41) AT=695.025n

.meas tran vdout1_42ck1380 FIND v(dout1_42) AT=695.025n

.meas tran vdout1_43ck1380 FIND v(dout1_43) AT=695.025n

.meas tran vdout1_44ck1380 FIND v(dout1_44) AT=695.025n

.meas tran vdout1_45ck1380 FIND v(dout1_45) AT=695.025n

.meas tran vdout1_46ck1380 FIND v(dout1_46) AT=695.025n

.meas tran vdout1_47ck1380 FIND v(dout1_47) AT=695.025n

.meas tran vdout1_48ck1380 FIND v(dout1_48) AT=695.025n

.meas tran vdout1_49ck1380 FIND v(dout1_49) AT=695.025n

.meas tran vdout1_50ck1380 FIND v(dout1_50) AT=695.025n

.meas tran vdout1_51ck1380 FIND v(dout1_51) AT=695.025n

.meas tran vdout1_52ck1380 FIND v(dout1_52) AT=695.025n

.meas tran vdout1_53ck1380 FIND v(dout1_53) AT=695.025n

.meas tran vdout1_54ck1380 FIND v(dout1_54) AT=695.025n

.meas tran vdout1_55ck1380 FIND v(dout1_55) AT=695.025n

.meas tran vdout1_56ck1380 FIND v(dout1_56) AT=695.025n

.meas tran vdout1_57ck1380 FIND v(dout1_57) AT=695.025n

.meas tran vdout1_58ck1380 FIND v(dout1_58) AT=695.025n

.meas tran vdout1_59ck1380 FIND v(dout1_59) AT=695.025n

.meas tran vdout1_60ck1380 FIND v(dout1_60) AT=695.025n

.meas tran vdout1_61ck1380 FIND v(dout1_61) AT=695.025n

.meas tran vdout1_62ck1380 FIND v(dout1_62) AT=695.025n

.meas tran vdout1_63ck1380 FIND v(dout1_63) AT=695.025n

.meas tran vdout1_64ck1380 FIND v(dout1_64) AT=695.025n

.meas tran vdout1_65ck1380 FIND v(dout1_65) AT=695.025n

.meas tran vdout1_66ck1380 FIND v(dout1_66) AT=695.025n

.meas tran vdout1_67ck1380 FIND v(dout1_67) AT=695.025n

.meas tran vdout1_68ck1380 FIND v(dout1_68) AT=695.025n

.meas tran vdout1_69ck1380 FIND v(dout1_69) AT=695.025n

.meas tran vdout1_70ck1380 FIND v(dout1_70) AT=695.025n

.meas tran vdout1_71ck1380 FIND v(dout1_71) AT=695.025n

.meas tran vdout1_72ck1380 FIND v(dout1_72) AT=695.025n

.meas tran vdout1_73ck1380 FIND v(dout1_73) AT=695.025n

.meas tran vdout1_74ck1380 FIND v(dout1_74) AT=695.025n

.meas tran vdout1_75ck1380 FIND v(dout1_75) AT=695.025n

.meas tran vdout1_76ck1380 FIND v(dout1_76) AT=695.025n

.meas tran vdout1_77ck1380 FIND v(dout1_77) AT=695.025n

.meas tran vdout1_78ck1380 FIND v(dout1_78) AT=695.025n

.meas tran vdout1_79ck1380 FIND v(dout1_79) AT=695.025n

.meas tran vdout1_80ck1380 FIND v(dout1_80) AT=695.025n

.meas tran vdout1_81ck1380 FIND v(dout1_81) AT=695.025n

.meas tran vdout1_82ck1380 FIND v(dout1_82) AT=695.025n

.meas tran vdout1_83ck1380 FIND v(dout1_83) AT=695.025n

.meas tran vdout1_84ck1380 FIND v(dout1_84) AT=695.025n

.meas tran vdout1_85ck1380 FIND v(dout1_85) AT=695.025n

.meas tran vdout1_86ck1380 FIND v(dout1_86) AT=695.025n

.meas tran vdout1_87ck1380 FIND v(dout1_87) AT=695.025n

.meas tran vdout1_88ck1380 FIND v(dout1_88) AT=695.025n

.meas tran vdout1_89ck1380 FIND v(dout1_89) AT=695.025n

.meas tran vdout1_90ck1380 FIND v(dout1_90) AT=695.025n

.meas tran vdout1_91ck1380 FIND v(dout1_91) AT=695.025n

.meas tran vdout1_92ck1380 FIND v(dout1_92) AT=695.025n

.meas tran vdout1_93ck1380 FIND v(dout1_93) AT=695.025n

.meas tran vdout1_94ck1380 FIND v(dout1_94) AT=695.025n

.meas tran vdout1_95ck1380 FIND v(dout1_95) AT=695.025n

.meas tran vdout1_96ck1380 FIND v(dout1_96) AT=695.025n

.meas tran vdout1_97ck1380 FIND v(dout1_97) AT=695.025n

.meas tran vdout1_98ck1380 FIND v(dout1_98) AT=695.025n

.meas tran vdout1_99ck1380 FIND v(dout1_99) AT=695.025n

.meas tran vdout1_100ck1380 FIND v(dout1_100) AT=695.025n

.meas tran vdout1_101ck1380 FIND v(dout1_101) AT=695.025n

.meas tran vdout1_102ck1380 FIND v(dout1_102) AT=695.025n

.meas tran vdout1_103ck1380 FIND v(dout1_103) AT=695.025n

.meas tran vdout1_104ck1380 FIND v(dout1_104) AT=695.025n

.meas tran vdout1_105ck1380 FIND v(dout1_105) AT=695.025n

.meas tran vdout1_106ck1380 FIND v(dout1_106) AT=695.025n

.meas tran vdout1_107ck1380 FIND v(dout1_107) AT=695.025n

.meas tran vdout1_108ck1380 FIND v(dout1_108) AT=695.025n

.meas tran vdout1_109ck1380 FIND v(dout1_109) AT=695.025n

.meas tran vdout1_110ck1380 FIND v(dout1_110) AT=695.025n

.meas tran vdout1_111ck1380 FIND v(dout1_111) AT=695.025n

.meas tran vdout1_112ck1380 FIND v(dout1_112) AT=695.025n

.meas tran vdout1_113ck1380 FIND v(dout1_113) AT=695.025n

.meas tran vdout1_114ck1380 FIND v(dout1_114) AT=695.025n

.meas tran vdout1_115ck1380 FIND v(dout1_115) AT=695.025n

.meas tran vdout1_116ck1380 FIND v(dout1_116) AT=695.025n

.meas tran vdout1_117ck1380 FIND v(dout1_117) AT=695.025n

.meas tran vdout1_118ck1380 FIND v(dout1_118) AT=695.025n

.meas tran vdout1_119ck1380 FIND v(dout1_119) AT=695.025n

.meas tran vdout1_120ck1380 FIND v(dout1_120) AT=695.025n

.meas tran vdout1_121ck1380 FIND v(dout1_121) AT=695.025n

.meas tran vdout1_122ck1380 FIND v(dout1_122) AT=695.025n

.meas tran vdout1_123ck1380 FIND v(dout1_123) AT=695.025n

.meas tran vdout1_124ck1380 FIND v(dout1_124) AT=695.025n

.meas tran vdout1_125ck1380 FIND v(dout1_125) AT=695.025n

.meas tran vdout1_126ck1380 FIND v(dout1_126) AT=695.025n

.meas tran vdout1_127ck1380 FIND v(dout1_127) AT=695.025n

.meas tran vdout1_128ck1380 FIND v(dout1_128) AT=695.025n

.meas tran vdout1_129ck1380 FIND v(dout1_129) AT=695.025n

.meas tran vdout1_130ck1380 FIND v(dout1_130) AT=695.025n

.meas tran vdout1_131ck1380 FIND v(dout1_131) AT=695.025n

.meas tran vdout1_132ck1380 FIND v(dout1_132) AT=695.025n

.meas tran vdout1_133ck1380 FIND v(dout1_133) AT=695.025n

.meas tran vdout1_134ck1380 FIND v(dout1_134) AT=695.025n

.meas tran vdout1_135ck1380 FIND v(dout1_135) AT=695.025n

.meas tran vdout1_136ck1380 FIND v(dout1_136) AT=695.025n

.meas tran vdout1_137ck1380 FIND v(dout1_137) AT=695.025n

.meas tran vdout1_138ck1380 FIND v(dout1_138) AT=695.025n

.meas tran vdout1_139ck1380 FIND v(dout1_139) AT=695.025n

.meas tran vdout1_140ck1380 FIND v(dout1_140) AT=695.025n

.meas tran vdout1_141ck1380 FIND v(dout1_141) AT=695.025n

.meas tran vdout1_142ck1380 FIND v(dout1_142) AT=695.025n

.meas tran vdout1_143ck1380 FIND v(dout1_143) AT=695.025n

.meas tran vdout1_144ck1380 FIND v(dout1_144) AT=695.025n

.meas tran vdout1_145ck1380 FIND v(dout1_145) AT=695.025n

.meas tran vdout1_146ck1380 FIND v(dout1_146) AT=695.025n

.meas tran vdout1_147ck1380 FIND v(dout1_147) AT=695.025n

.meas tran vdout1_148ck1380 FIND v(dout1_148) AT=695.025n

.meas tran vdout1_149ck1380 FIND v(dout1_149) AT=695.025n

.meas tran vdout1_150ck1380 FIND v(dout1_150) AT=695.025n

.meas tran vdout1_151ck1380 FIND v(dout1_151) AT=695.025n

.meas tran vdout1_152ck1380 FIND v(dout1_152) AT=695.025n

.meas tran vdout1_153ck1380 FIND v(dout1_153) AT=695.025n

.meas tran vdout1_154ck1380 FIND v(dout1_154) AT=695.025n

.meas tran vdout1_155ck1380 FIND v(dout1_155) AT=695.025n

.meas tran vdout1_156ck1380 FIND v(dout1_156) AT=695.025n

.meas tran vdout1_157ck1380 FIND v(dout1_157) AT=695.025n

.meas tran vdout1_158ck1380 FIND v(dout1_158) AT=695.025n

.meas tran vdout1_159ck1380 FIND v(dout1_159) AT=695.025n

.meas tran vdout1_160ck1380 FIND v(dout1_160) AT=695.025n

.meas tran vdout1_161ck1380 FIND v(dout1_161) AT=695.025n

.meas tran vdout1_162ck1380 FIND v(dout1_162) AT=695.025n

.meas tran vdout1_163ck1380 FIND v(dout1_163) AT=695.025n

.meas tran vdout1_164ck1380 FIND v(dout1_164) AT=695.025n

.meas tran vdout1_165ck1380 FIND v(dout1_165) AT=695.025n

.meas tran vdout1_166ck1380 FIND v(dout1_166) AT=695.025n

.meas tran vdout1_167ck1380 FIND v(dout1_167) AT=695.025n

.meas tran vdout1_168ck1380 FIND v(dout1_168) AT=695.025n

.meas tran vdout1_169ck1380 FIND v(dout1_169) AT=695.025n

.meas tran vdout1_170ck1380 FIND v(dout1_170) AT=695.025n

.meas tran vdout1_171ck1380 FIND v(dout1_171) AT=695.025n

.meas tran vdout1_172ck1380 FIND v(dout1_172) AT=695.025n

.meas tran vdout1_173ck1380 FIND v(dout1_173) AT=695.025n

.meas tran vdout1_174ck1380 FIND v(dout1_174) AT=695.025n

.meas tran vdout1_175ck1380 FIND v(dout1_175) AT=695.025n

.meas tran vdout1_176ck1380 FIND v(dout1_176) AT=695.025n

.meas tran vdout1_177ck1380 FIND v(dout1_177) AT=695.025n

.meas tran vdout1_178ck1380 FIND v(dout1_178) AT=695.025n

.meas tran vdout1_179ck1380 FIND v(dout1_179) AT=695.025n

.meas tran vdout1_180ck1380 FIND v(dout1_180) AT=695.025n

.meas tran vdout1_181ck1380 FIND v(dout1_181) AT=695.025n

.meas tran vdout1_182ck1380 FIND v(dout1_182) AT=695.025n

.meas tran vdout1_183ck1380 FIND v(dout1_183) AT=695.025n

.meas tran vdout1_184ck1380 FIND v(dout1_184) AT=695.025n

.meas tran vdout1_185ck1380 FIND v(dout1_185) AT=695.025n

.meas tran vdout1_186ck1380 FIND v(dout1_186) AT=695.025n

.meas tran vdout1_187ck1380 FIND v(dout1_187) AT=695.025n

.meas tran vdout1_188ck1380 FIND v(dout1_188) AT=695.025n

.meas tran vdout1_189ck1380 FIND v(dout1_189) AT=695.025n

.meas tran vdout1_190ck1380 FIND v(dout1_190) AT=695.025n

.meas tran vdout1_191ck1380 FIND v(dout1_191) AT=695.025n

.meas tran vdout1_192ck1380 FIND v(dout1_192) AT=695.025n

.meas tran vdout1_193ck1380 FIND v(dout1_193) AT=695.025n

.meas tran vdout1_194ck1380 FIND v(dout1_194) AT=695.025n

.meas tran vdout1_195ck1380 FIND v(dout1_195) AT=695.025n

.meas tran vdout1_196ck1380 FIND v(dout1_196) AT=695.025n

.meas tran vdout1_197ck1380 FIND v(dout1_197) AT=695.025n

.meas tran vdout1_198ck1380 FIND v(dout1_198) AT=695.025n

.meas tran vdout1_199ck1380 FIND v(dout1_199) AT=695.025n

.meas tran vdout1_200ck1380 FIND v(dout1_200) AT=695.025n

.meas tran vdout1_201ck1380 FIND v(dout1_201) AT=695.025n

.meas tran vdout1_202ck1380 FIND v(dout1_202) AT=695.025n

.meas tran vdout1_203ck1380 FIND v(dout1_203) AT=695.025n

.meas tran vdout1_204ck1380 FIND v(dout1_204) AT=695.025n

.meas tran vdout1_205ck1380 FIND v(dout1_205) AT=695.025n

.meas tran vdout1_206ck1380 FIND v(dout1_206) AT=695.025n

.meas tran vdout1_207ck1380 FIND v(dout1_207) AT=695.025n

.meas tran vdout1_208ck1380 FIND v(dout1_208) AT=695.025n

.meas tran vdout1_209ck1380 FIND v(dout1_209) AT=695.025n

.meas tran vdout1_210ck1380 FIND v(dout1_210) AT=695.025n

.meas tran vdout1_211ck1380 FIND v(dout1_211) AT=695.025n

.meas tran vdout1_212ck1380 FIND v(dout1_212) AT=695.025n

.meas tran vdout1_213ck1380 FIND v(dout1_213) AT=695.025n

.meas tran vdout1_214ck1380 FIND v(dout1_214) AT=695.025n

.meas tran vdout1_215ck1380 FIND v(dout1_215) AT=695.025n

.meas tran vdout1_216ck1380 FIND v(dout1_216) AT=695.025n

.meas tran vdout1_217ck1380 FIND v(dout1_217) AT=695.025n

.meas tran vdout1_218ck1380 FIND v(dout1_218) AT=695.025n

.meas tran vdout1_219ck1380 FIND v(dout1_219) AT=695.025n

.meas tran vdout1_220ck1380 FIND v(dout1_220) AT=695.025n

.meas tran vdout1_221ck1380 FIND v(dout1_221) AT=695.025n

.meas tran vdout1_222ck1380 FIND v(dout1_222) AT=695.025n

.meas tran vdout1_223ck1380 FIND v(dout1_223) AT=695.025n

.meas tran vdout1_224ck1380 FIND v(dout1_224) AT=695.025n

.meas tran vdout1_225ck1380 FIND v(dout1_225) AT=695.025n

.meas tran vdout1_226ck1380 FIND v(dout1_226) AT=695.025n

.meas tran vdout1_227ck1380 FIND v(dout1_227) AT=695.025n

.meas tran vdout1_228ck1380 FIND v(dout1_228) AT=695.025n

.meas tran vdout1_229ck1380 FIND v(dout1_229) AT=695.025n

.meas tran vdout1_230ck1380 FIND v(dout1_230) AT=695.025n

.meas tran vdout1_231ck1380 FIND v(dout1_231) AT=695.025n

.meas tran vdout1_232ck1380 FIND v(dout1_232) AT=695.025n

.meas tran vdout1_233ck1380 FIND v(dout1_233) AT=695.025n

.meas tran vdout1_234ck1380 FIND v(dout1_234) AT=695.025n

.meas tran vdout1_235ck1380 FIND v(dout1_235) AT=695.025n

.meas tran vdout1_236ck1380 FIND v(dout1_236) AT=695.025n

.meas tran vdout1_237ck1380 FIND v(dout1_237) AT=695.025n

.meas tran vdout1_238ck1380 FIND v(dout1_238) AT=695.025n

.meas tran vdout1_239ck1380 FIND v(dout1_239) AT=695.025n

.meas tran vdout1_240ck1380 FIND v(dout1_240) AT=695.025n

.meas tran vdout1_241ck1380 FIND v(dout1_241) AT=695.025n

.meas tran vdout1_242ck1380 FIND v(dout1_242) AT=695.025n

.meas tran vdout1_243ck1380 FIND v(dout1_243) AT=695.025n

.meas tran vdout1_244ck1380 FIND v(dout1_244) AT=695.025n

.meas tran vdout1_245ck1380 FIND v(dout1_245) AT=695.025n

.meas tran vdout1_246ck1380 FIND v(dout1_246) AT=695.025n

.meas tran vdout1_247ck1380 FIND v(dout1_247) AT=695.025n

.meas tran vdout1_248ck1380 FIND v(dout1_248) AT=695.025n

.meas tran vdout1_249ck1380 FIND v(dout1_249) AT=695.025n

.meas tran vdout1_250ck1380 FIND v(dout1_250) AT=695.025n

.meas tran vdout1_251ck1380 FIND v(dout1_251) AT=695.025n

.meas tran vdout1_252ck1380 FIND v(dout1_252) AT=695.025n

.meas tran vdout1_253ck1380 FIND v(dout1_253) AT=695.025n

.meas tran vdout1_254ck1380 FIND v(dout1_254) AT=695.025n

.meas tran vdout1_255ck1380 FIND v(dout1_255) AT=695.025n

.meas tran vdout1_256ck1380 FIND v(dout1_256) AT=695.025n

.meas tran vdout1_257ck1380 FIND v(dout1_257) AT=695.025n

.meas tran vdout1_258ck1380 FIND v(dout1_258) AT=695.025n

.meas tran vdout1_259ck1380 FIND v(dout1_259) AT=695.025n

.meas tran vdout1_260ck1380 FIND v(dout1_260) AT=695.025n

.meas tran vdout1_261ck1380 FIND v(dout1_261) AT=695.025n

.meas tran vdout1_262ck1380 FIND v(dout1_262) AT=695.025n

.meas tran vdout1_263ck1380 FIND v(dout1_263) AT=695.025n

.meas tran vdout1_264ck1380 FIND v(dout1_264) AT=695.025n

.meas tran vdout1_265ck1380 FIND v(dout1_265) AT=695.025n

.meas tran vdout1_266ck1380 FIND v(dout1_266) AT=695.025n

.meas tran vdout1_267ck1380 FIND v(dout1_267) AT=695.025n

.meas tran vdout1_268ck1380 FIND v(dout1_268) AT=695.025n

.meas tran vdout1_269ck1380 FIND v(dout1_269) AT=695.025n

.meas tran vdout1_270ck1380 FIND v(dout1_270) AT=695.025n

.meas tran vdout1_271ck1380 FIND v(dout1_271) AT=695.025n

.meas tran vdout1_272ck1380 FIND v(dout1_272) AT=695.025n

.meas tran vdout1_273ck1380 FIND v(dout1_273) AT=695.025n

.meas tran vdout1_274ck1380 FIND v(dout1_274) AT=695.025n

.meas tran vdout1_275ck1380 FIND v(dout1_275) AT=695.025n

.meas tran vdout1_276ck1380 FIND v(dout1_276) AT=695.025n

.meas tran vdout1_277ck1380 FIND v(dout1_277) AT=695.025n

.meas tran vdout1_278ck1380 FIND v(dout1_278) AT=695.025n

.meas tran vdout1_279ck1380 FIND v(dout1_279) AT=695.025n

.meas tran vdout1_280ck1380 FIND v(dout1_280) AT=695.025n

.meas tran vdout1_281ck1380 FIND v(dout1_281) AT=695.025n

.meas tran vdout1_282ck1380 FIND v(dout1_282) AT=695.025n

.meas tran vdout1_283ck1380 FIND v(dout1_283) AT=695.025n

.meas tran vdout1_284ck1380 FIND v(dout1_284) AT=695.025n

.meas tran vdout1_285ck1380 FIND v(dout1_285) AT=695.025n

.meas tran vdout1_286ck1380 FIND v(dout1_286) AT=695.025n

.meas tran vdout1_287ck1380 FIND v(dout1_287) AT=695.025n

.meas tran vdout1_288ck1380 FIND v(dout1_288) AT=695.025n

.meas tran vdout1_289ck1380 FIND v(dout1_289) AT=695.025n

.meas tran vdout1_290ck1380 FIND v(dout1_290) AT=695.025n

.meas tran vdout1_291ck1380 FIND v(dout1_291) AT=695.025n

.meas tran vdout1_292ck1380 FIND v(dout1_292) AT=695.025n

.meas tran vdout1_293ck1380 FIND v(dout1_293) AT=695.025n

.meas tran vdout1_294ck1380 FIND v(dout1_294) AT=695.025n

.meas tran vdout1_295ck1380 FIND v(dout1_295) AT=695.025n

.meas tran vdout1_296ck1380 FIND v(dout1_296) AT=695.025n

.meas tran vdout1_297ck1380 FIND v(dout1_297) AT=695.025n

.meas tran vdout1_298ck1380 FIND v(dout1_298) AT=695.025n

.meas tran vdout1_299ck1380 FIND v(dout1_299) AT=695.025n

.meas tran vdout1_300ck1380 FIND v(dout1_300) AT=695.025n

.meas tran vdout1_301ck1380 FIND v(dout1_301) AT=695.025n

.meas tran vdout1_302ck1380 FIND v(dout1_302) AT=695.025n

.meas tran vdout1_303ck1380 FIND v(dout1_303) AT=695.025n

.meas tran vdout1_304ck1380 FIND v(dout1_304) AT=695.025n

.meas tran vdout1_305ck1380 FIND v(dout1_305) AT=695.025n

.meas tran vdout1_306ck1380 FIND v(dout1_306) AT=695.025n

.meas tran vdout1_307ck1380 FIND v(dout1_307) AT=695.025n

.meas tran vdout1_308ck1380 FIND v(dout1_308) AT=695.025n

.meas tran vdout1_309ck1380 FIND v(dout1_309) AT=695.025n

.meas tran vdout1_310ck1380 FIND v(dout1_310) AT=695.025n

.meas tran vdout1_311ck1380 FIND v(dout1_311) AT=695.025n

.meas tran vdout1_312ck1380 FIND v(dout1_312) AT=695.025n

.meas tran vdout1_313ck1380 FIND v(dout1_313) AT=695.025n

.meas tran vdout1_314ck1380 FIND v(dout1_314) AT=695.025n

.meas tran vdout1_315ck1380 FIND v(dout1_315) AT=695.025n

.meas tran vdout1_316ck1380 FIND v(dout1_316) AT=695.025n

.meas tran vdout1_317ck1380 FIND v(dout1_317) AT=695.025n

.meas tran vdout1_318ck1380 FIND v(dout1_318) AT=695.025n

.meas tran vdout1_319ck1380 FIND v(dout1_319) AT=695.025n

.meas tran vdout1_320ck1380 FIND v(dout1_320) AT=695.025n

.meas tran vdout1_321ck1380 FIND v(dout1_321) AT=695.025n

.meas tran vdout1_322ck1380 FIND v(dout1_322) AT=695.025n

.meas tran vdout1_323ck1380 FIND v(dout1_323) AT=695.025n

.meas tran vdout1_324ck1380 FIND v(dout1_324) AT=695.025n

.meas tran vdout1_325ck1380 FIND v(dout1_325) AT=695.025n

.meas tran vdout1_326ck1380 FIND v(dout1_326) AT=695.025n

.meas tran vdout1_327ck1380 FIND v(dout1_327) AT=695.025n

.meas tran vdout1_328ck1380 FIND v(dout1_328) AT=695.025n

.meas tran vdout1_329ck1380 FIND v(dout1_329) AT=695.025n

.meas tran vdout1_330ck1380 FIND v(dout1_330) AT=695.025n

.meas tran vdout1_331ck1380 FIND v(dout1_331) AT=695.025n

.meas tran vdout1_332ck1380 FIND v(dout1_332) AT=695.025n

.meas tran vdout1_333ck1380 FIND v(dout1_333) AT=695.025n

.meas tran vdout1_334ck1380 FIND v(dout1_334) AT=695.025n

.meas tran vdout1_335ck1380 FIND v(dout1_335) AT=695.025n

.meas tran vdout1_336ck1380 FIND v(dout1_336) AT=695.025n

.meas tran vdout1_337ck1380 FIND v(dout1_337) AT=695.025n

.meas tran vdout1_338ck1380 FIND v(dout1_338) AT=695.025n

.meas tran vdout1_339ck1380 FIND v(dout1_339) AT=695.025n

.meas tran vdout1_340ck1380 FIND v(dout1_340) AT=695.025n

.meas tran vdout1_341ck1380 FIND v(dout1_341) AT=695.025n

.meas tran vdout1_342ck1380 FIND v(dout1_342) AT=695.025n

.meas tran vdout1_343ck1380 FIND v(dout1_343) AT=695.025n

.meas tran vdout1_344ck1380 FIND v(dout1_344) AT=695.025n

.meas tran vdout1_345ck1380 FIND v(dout1_345) AT=695.025n

.meas tran vdout1_346ck1380 FIND v(dout1_346) AT=695.025n

.meas tran vdout1_347ck1380 FIND v(dout1_347) AT=695.025n

.meas tran vdout1_348ck1380 FIND v(dout1_348) AT=695.025n

.meas tran vdout1_349ck1380 FIND v(dout1_349) AT=695.025n

.meas tran vdout1_350ck1380 FIND v(dout1_350) AT=695.025n

.meas tran vdout1_351ck1380 FIND v(dout1_351) AT=695.025n

.meas tran vdout1_352ck1380 FIND v(dout1_352) AT=695.025n

.meas tran vdout1_353ck1380 FIND v(dout1_353) AT=695.025n

.meas tran vdout1_354ck1380 FIND v(dout1_354) AT=695.025n

.meas tran vdout1_355ck1380 FIND v(dout1_355) AT=695.025n

.meas tran vdout1_356ck1380 FIND v(dout1_356) AT=695.025n

.meas tran vdout1_357ck1380 FIND v(dout1_357) AT=695.025n

.meas tran vdout1_358ck1380 FIND v(dout1_358) AT=695.025n

.meas tran vdout1_359ck1380 FIND v(dout1_359) AT=695.025n

.meas tran vdout1_360ck1380 FIND v(dout1_360) AT=695.025n

.meas tran vdout1_361ck1380 FIND v(dout1_361) AT=695.025n

.meas tran vdout1_362ck1380 FIND v(dout1_362) AT=695.025n

.meas tran vdout1_363ck1380 FIND v(dout1_363) AT=695.025n

.meas tran vdout1_364ck1380 FIND v(dout1_364) AT=695.025n

.meas tran vdout1_365ck1380 FIND v(dout1_365) AT=695.025n

.meas tran vdout1_366ck1380 FIND v(dout1_366) AT=695.025n

.meas tran vdout1_367ck1380 FIND v(dout1_367) AT=695.025n

.meas tran vdout1_368ck1380 FIND v(dout1_368) AT=695.025n

.meas tran vdout1_369ck1380 FIND v(dout1_369) AT=695.025n

.meas tran vdout1_370ck1380 FIND v(dout1_370) AT=695.025n

.meas tran vdout1_371ck1380 FIND v(dout1_371) AT=695.025n

.meas tran vdout1_372ck1380 FIND v(dout1_372) AT=695.025n

.meas tran vdout1_373ck1380 FIND v(dout1_373) AT=695.025n

.meas tran vdout1_374ck1380 FIND v(dout1_374) AT=695.025n

.meas tran vdout1_375ck1380 FIND v(dout1_375) AT=695.025n

.meas tran vdout1_376ck1380 FIND v(dout1_376) AT=695.025n

.meas tran vdout1_377ck1380 FIND v(dout1_377) AT=695.025n

.meas tran vdout1_378ck1380 FIND v(dout1_378) AT=695.025n

.meas tran vdout1_379ck1380 FIND v(dout1_379) AT=695.025n

.meas tran vdout1_380ck1380 FIND v(dout1_380) AT=695.025n

.meas tran vdout1_381ck1380 FIND v(dout1_381) AT=695.025n

.meas tran vdout1_382ck1380 FIND v(dout1_382) AT=695.025n

.meas tran vdout1_383ck1380 FIND v(dout1_383) AT=695.025n

.meas tran vdout1_384ck1380 FIND v(dout1_384) AT=695.025n

.meas tran vdout1_385ck1380 FIND v(dout1_385) AT=695.025n

.meas tran vdout1_386ck1380 FIND v(dout1_386) AT=695.025n

.meas tran vdout1_387ck1380 FIND v(dout1_387) AT=695.025n

.meas tran vdout1_388ck1380 FIND v(dout1_388) AT=695.025n

.meas tran vdout1_389ck1380 FIND v(dout1_389) AT=695.025n

.meas tran vdout1_390ck1380 FIND v(dout1_390) AT=695.025n

.meas tran vdout1_391ck1380 FIND v(dout1_391) AT=695.025n

.meas tran vdout1_392ck1380 FIND v(dout1_392) AT=695.025n

.meas tran vdout1_393ck1380 FIND v(dout1_393) AT=695.025n

.meas tran vdout1_394ck1380 FIND v(dout1_394) AT=695.025n

.meas tran vdout1_395ck1380 FIND v(dout1_395) AT=695.025n

.meas tran vdout1_396ck1380 FIND v(dout1_396) AT=695.025n

.meas tran vdout1_397ck1380 FIND v(dout1_397) AT=695.025n

.meas tran vdout1_398ck1380 FIND v(dout1_398) AT=695.025n

.meas tran vdout1_399ck1380 FIND v(dout1_399) AT=695.025n

.meas tran vdout1_400ck1380 FIND v(dout1_400) AT=695.025n

.meas tran vdout1_401ck1380 FIND v(dout1_401) AT=695.025n

.meas tran vdout1_402ck1380 FIND v(dout1_402) AT=695.025n

.meas tran vdout1_403ck1380 FIND v(dout1_403) AT=695.025n

.meas tran vdout1_404ck1380 FIND v(dout1_404) AT=695.025n

.meas tran vdout1_405ck1380 FIND v(dout1_405) AT=695.025n

.meas tran vdout1_406ck1380 FIND v(dout1_406) AT=695.025n

.meas tran vdout1_407ck1380 FIND v(dout1_407) AT=695.025n

.meas tran vdout1_408ck1380 FIND v(dout1_408) AT=695.025n

.meas tran vdout1_409ck1380 FIND v(dout1_409) AT=695.025n

.meas tran vdout1_410ck1380 FIND v(dout1_410) AT=695.025n

.meas tran vdout1_411ck1380 FIND v(dout1_411) AT=695.025n

.meas tran vdout1_412ck1380 FIND v(dout1_412) AT=695.025n

.meas tran vdout1_413ck1380 FIND v(dout1_413) AT=695.025n

.meas tran vdout1_414ck1380 FIND v(dout1_414) AT=695.025n

.meas tran vdout1_415ck1380 FIND v(dout1_415) AT=695.025n

.meas tran vdout1_416ck1380 FIND v(dout1_416) AT=695.025n

.meas tran vdout1_417ck1380 FIND v(dout1_417) AT=695.025n

.meas tran vdout1_418ck1380 FIND v(dout1_418) AT=695.025n

.meas tran vdout1_419ck1380 FIND v(dout1_419) AT=695.025n

.meas tran vdout1_420ck1380 FIND v(dout1_420) AT=695.025n

.meas tran vdout1_421ck1380 FIND v(dout1_421) AT=695.025n

.meas tran vdout1_422ck1380 FIND v(dout1_422) AT=695.025n

.meas tran vdout1_423ck1380 FIND v(dout1_423) AT=695.025n

.meas tran vdout1_424ck1380 FIND v(dout1_424) AT=695.025n

.meas tran vdout1_425ck1380 FIND v(dout1_425) AT=695.025n

.meas tran vdout1_426ck1380 FIND v(dout1_426) AT=695.025n

.meas tran vdout1_427ck1380 FIND v(dout1_427) AT=695.025n

.meas tran vdout1_428ck1380 FIND v(dout1_428) AT=695.025n

.meas tran vdout1_429ck1380 FIND v(dout1_429) AT=695.025n

.meas tran vdout1_430ck1380 FIND v(dout1_430) AT=695.025n

.meas tran vdout1_431ck1380 FIND v(dout1_431) AT=695.025n

.meas tran vdout1_432ck1380 FIND v(dout1_432) AT=695.025n

.meas tran vdout1_433ck1380 FIND v(dout1_433) AT=695.025n

.meas tran vdout1_434ck1380 FIND v(dout1_434) AT=695.025n

.meas tran vdout1_435ck1380 FIND v(dout1_435) AT=695.025n

.meas tran vdout1_436ck1380 FIND v(dout1_436) AT=695.025n

.meas tran vdout1_437ck1380 FIND v(dout1_437) AT=695.025n

.meas tran vdout1_438ck1380 FIND v(dout1_438) AT=695.025n

.meas tran vdout1_439ck1380 FIND v(dout1_439) AT=695.025n

.meas tran vdout1_440ck1380 FIND v(dout1_440) AT=695.025n

.meas tran vdout1_441ck1380 FIND v(dout1_441) AT=695.025n

.meas tran vdout1_442ck1380 FIND v(dout1_442) AT=695.025n

.meas tran vdout1_443ck1380 FIND v(dout1_443) AT=695.025n

.meas tran vdout1_444ck1380 FIND v(dout1_444) AT=695.025n

.meas tran vdout1_445ck1380 FIND v(dout1_445) AT=695.025n

.meas tran vdout1_446ck1380 FIND v(dout1_446) AT=695.025n

.meas tran vdout1_447ck1380 FIND v(dout1_447) AT=695.025n

.meas tran vdout1_448ck1380 FIND v(dout1_448) AT=695.025n

.meas tran vdout1_449ck1380 FIND v(dout1_449) AT=695.025n

.meas tran vdout1_450ck1380 FIND v(dout1_450) AT=695.025n

.meas tran vdout1_451ck1380 FIND v(dout1_451) AT=695.025n

.meas tran vdout1_452ck1380 FIND v(dout1_452) AT=695.025n

.meas tran vdout1_453ck1380 FIND v(dout1_453) AT=695.025n

.meas tran vdout1_454ck1380 FIND v(dout1_454) AT=695.025n

.meas tran vdout1_455ck1380 FIND v(dout1_455) AT=695.025n

.meas tran vdout1_456ck1380 FIND v(dout1_456) AT=695.025n

.meas tran vdout1_457ck1380 FIND v(dout1_457) AT=695.025n

.meas tran vdout1_458ck1380 FIND v(dout1_458) AT=695.025n

.meas tran vdout1_459ck1380 FIND v(dout1_459) AT=695.025n

.meas tran vdout1_460ck1380 FIND v(dout1_460) AT=695.025n

.meas tran vdout1_461ck1380 FIND v(dout1_461) AT=695.025n

.meas tran vdout1_462ck1380 FIND v(dout1_462) AT=695.025n

.meas tran vdout1_463ck1380 FIND v(dout1_463) AT=695.025n

.meas tran vdout1_464ck1380 FIND v(dout1_464) AT=695.025n

.meas tran vdout1_465ck1380 FIND v(dout1_465) AT=695.025n

.meas tran vdout1_466ck1380 FIND v(dout1_466) AT=695.025n

.meas tran vdout1_467ck1380 FIND v(dout1_467) AT=695.025n

.meas tran vdout1_468ck1380 FIND v(dout1_468) AT=695.025n

.meas tran vdout1_469ck1380 FIND v(dout1_469) AT=695.025n

.meas tran vdout1_470ck1380 FIND v(dout1_470) AT=695.025n

.meas tran vdout1_471ck1380 FIND v(dout1_471) AT=695.025n

.meas tran vdout1_472ck1380 FIND v(dout1_472) AT=695.025n

.meas tran vdout1_473ck1380 FIND v(dout1_473) AT=695.025n

.meas tran vdout1_474ck1380 FIND v(dout1_474) AT=695.025n

.meas tran vdout1_475ck1380 FIND v(dout1_475) AT=695.025n

.meas tran vdout1_476ck1380 FIND v(dout1_476) AT=695.025n

.meas tran vdout1_477ck1380 FIND v(dout1_477) AT=695.025n

.meas tran vdout1_478ck1380 FIND v(dout1_478) AT=695.025n

.meas tran vdout1_479ck1380 FIND v(dout1_479) AT=695.025n

.meas tran vdout1_480ck1380 FIND v(dout1_480) AT=695.025n

.meas tran vdout1_481ck1380 FIND v(dout1_481) AT=695.025n

.meas tran vdout1_482ck1380 FIND v(dout1_482) AT=695.025n

.meas tran vdout1_483ck1380 FIND v(dout1_483) AT=695.025n

.meas tran vdout1_484ck1380 FIND v(dout1_484) AT=695.025n

.meas tran vdout1_485ck1380 FIND v(dout1_485) AT=695.025n

.meas tran vdout1_486ck1380 FIND v(dout1_486) AT=695.025n

.meas tran vdout1_487ck1380 FIND v(dout1_487) AT=695.025n

.meas tran vdout1_488ck1380 FIND v(dout1_488) AT=695.025n

.meas tran vdout1_489ck1380 FIND v(dout1_489) AT=695.025n

.meas tran vdout1_490ck1380 FIND v(dout1_490) AT=695.025n

.meas tran vdout1_491ck1380 FIND v(dout1_491) AT=695.025n

.meas tran vdout1_492ck1380 FIND v(dout1_492) AT=695.025n

.meas tran vdout1_493ck1380 FIND v(dout1_493) AT=695.025n

.meas tran vdout1_494ck1380 FIND v(dout1_494) AT=695.025n

.meas tran vdout1_495ck1380 FIND v(dout1_495) AT=695.025n

.meas tran vdout1_496ck1380 FIND v(dout1_496) AT=695.025n

.meas tran vdout1_497ck1380 FIND v(dout1_497) AT=695.025n

.meas tran vdout1_498ck1380 FIND v(dout1_498) AT=695.025n

.meas tran vdout1_499ck1380 FIND v(dout1_499) AT=695.025n

.meas tran vdout1_500ck1380 FIND v(dout1_500) AT=695.025n

.meas tran vdout1_501ck1380 FIND v(dout1_501) AT=695.025n

.meas tran vdout1_502ck1380 FIND v(dout1_502) AT=695.025n

.meas tran vdout1_503ck1380 FIND v(dout1_503) AT=695.025n

.meas tran vdout1_504ck1380 FIND v(dout1_504) AT=695.025n

.meas tran vdout1_505ck1380 FIND v(dout1_505) AT=695.025n

.meas tran vdout1_506ck1380 FIND v(dout1_506) AT=695.025n

.meas tran vdout1_507ck1380 FIND v(dout1_507) AT=695.025n

.meas tran vdout1_508ck1380 FIND v(dout1_508) AT=695.025n

.meas tran vdout1_509ck1380 FIND v(dout1_509) AT=695.025n

.meas tran vdout1_510ck1380 FIND v(dout1_510) AT=695.025n

.meas tran vdout1_511ck1380 FIND v(dout1_511) AT=695.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_16ck1390 FIND v(dout1_16) AT=700.025n

.meas tran vdout1_17ck1390 FIND v(dout1_17) AT=700.025n

.meas tran vdout1_18ck1390 FIND v(dout1_18) AT=700.025n

.meas tran vdout1_19ck1390 FIND v(dout1_19) AT=700.025n

.meas tran vdout1_20ck1390 FIND v(dout1_20) AT=700.025n

.meas tran vdout1_21ck1390 FIND v(dout1_21) AT=700.025n

.meas tran vdout1_22ck1390 FIND v(dout1_22) AT=700.025n

.meas tran vdout1_23ck1390 FIND v(dout1_23) AT=700.025n

.meas tran vdout1_24ck1390 FIND v(dout1_24) AT=700.025n

.meas tran vdout1_25ck1390 FIND v(dout1_25) AT=700.025n

.meas tran vdout1_26ck1390 FIND v(dout1_26) AT=700.025n

.meas tran vdout1_27ck1390 FIND v(dout1_27) AT=700.025n

.meas tran vdout1_28ck1390 FIND v(dout1_28) AT=700.025n

.meas tran vdout1_29ck1390 FIND v(dout1_29) AT=700.025n

.meas tran vdout1_30ck1390 FIND v(dout1_30) AT=700.025n

.meas tran vdout1_31ck1390 FIND v(dout1_31) AT=700.025n

.meas tran vdout1_32ck1390 FIND v(dout1_32) AT=700.025n

.meas tran vdout1_33ck1390 FIND v(dout1_33) AT=700.025n

.meas tran vdout1_34ck1390 FIND v(dout1_34) AT=700.025n

.meas tran vdout1_35ck1390 FIND v(dout1_35) AT=700.025n

.meas tran vdout1_36ck1390 FIND v(dout1_36) AT=700.025n

.meas tran vdout1_37ck1390 FIND v(dout1_37) AT=700.025n

.meas tran vdout1_38ck1390 FIND v(dout1_38) AT=700.025n

.meas tran vdout1_39ck1390 FIND v(dout1_39) AT=700.025n

.meas tran vdout1_40ck1390 FIND v(dout1_40) AT=700.025n

.meas tran vdout1_41ck1390 FIND v(dout1_41) AT=700.025n

.meas tran vdout1_42ck1390 FIND v(dout1_42) AT=700.025n

.meas tran vdout1_43ck1390 FIND v(dout1_43) AT=700.025n

.meas tran vdout1_44ck1390 FIND v(dout1_44) AT=700.025n

.meas tran vdout1_45ck1390 FIND v(dout1_45) AT=700.025n

.meas tran vdout1_46ck1390 FIND v(dout1_46) AT=700.025n

.meas tran vdout1_47ck1390 FIND v(dout1_47) AT=700.025n

.meas tran vdout1_48ck1390 FIND v(dout1_48) AT=700.025n

.meas tran vdout1_49ck1390 FIND v(dout1_49) AT=700.025n

.meas tran vdout1_50ck1390 FIND v(dout1_50) AT=700.025n

.meas tran vdout1_51ck1390 FIND v(dout1_51) AT=700.025n

.meas tran vdout1_52ck1390 FIND v(dout1_52) AT=700.025n

.meas tran vdout1_53ck1390 FIND v(dout1_53) AT=700.025n

.meas tran vdout1_54ck1390 FIND v(dout1_54) AT=700.025n

.meas tran vdout1_55ck1390 FIND v(dout1_55) AT=700.025n

.meas tran vdout1_56ck1390 FIND v(dout1_56) AT=700.025n

.meas tran vdout1_57ck1390 FIND v(dout1_57) AT=700.025n

.meas tran vdout1_58ck1390 FIND v(dout1_58) AT=700.025n

.meas tran vdout1_59ck1390 FIND v(dout1_59) AT=700.025n

.meas tran vdout1_60ck1390 FIND v(dout1_60) AT=700.025n

.meas tran vdout1_61ck1390 FIND v(dout1_61) AT=700.025n

.meas tran vdout1_62ck1390 FIND v(dout1_62) AT=700.025n

.meas tran vdout1_63ck1390 FIND v(dout1_63) AT=700.025n

.meas tran vdout1_64ck1390 FIND v(dout1_64) AT=700.025n

.meas tran vdout1_65ck1390 FIND v(dout1_65) AT=700.025n

.meas tran vdout1_66ck1390 FIND v(dout1_66) AT=700.025n

.meas tran vdout1_67ck1390 FIND v(dout1_67) AT=700.025n

.meas tran vdout1_68ck1390 FIND v(dout1_68) AT=700.025n

.meas tran vdout1_69ck1390 FIND v(dout1_69) AT=700.025n

.meas tran vdout1_70ck1390 FIND v(dout1_70) AT=700.025n

.meas tran vdout1_71ck1390 FIND v(dout1_71) AT=700.025n

.meas tran vdout1_72ck1390 FIND v(dout1_72) AT=700.025n

.meas tran vdout1_73ck1390 FIND v(dout1_73) AT=700.025n

.meas tran vdout1_74ck1390 FIND v(dout1_74) AT=700.025n

.meas tran vdout1_75ck1390 FIND v(dout1_75) AT=700.025n

.meas tran vdout1_76ck1390 FIND v(dout1_76) AT=700.025n

.meas tran vdout1_77ck1390 FIND v(dout1_77) AT=700.025n

.meas tran vdout1_78ck1390 FIND v(dout1_78) AT=700.025n

.meas tran vdout1_79ck1390 FIND v(dout1_79) AT=700.025n

.meas tran vdout1_80ck1390 FIND v(dout1_80) AT=700.025n

.meas tran vdout1_81ck1390 FIND v(dout1_81) AT=700.025n

.meas tran vdout1_82ck1390 FIND v(dout1_82) AT=700.025n

.meas tran vdout1_83ck1390 FIND v(dout1_83) AT=700.025n

.meas tran vdout1_84ck1390 FIND v(dout1_84) AT=700.025n

.meas tran vdout1_85ck1390 FIND v(dout1_85) AT=700.025n

.meas tran vdout1_86ck1390 FIND v(dout1_86) AT=700.025n

.meas tran vdout1_87ck1390 FIND v(dout1_87) AT=700.025n

.meas tran vdout1_88ck1390 FIND v(dout1_88) AT=700.025n

.meas tran vdout1_89ck1390 FIND v(dout1_89) AT=700.025n

.meas tran vdout1_90ck1390 FIND v(dout1_90) AT=700.025n

.meas tran vdout1_91ck1390 FIND v(dout1_91) AT=700.025n

.meas tran vdout1_92ck1390 FIND v(dout1_92) AT=700.025n

.meas tran vdout1_93ck1390 FIND v(dout1_93) AT=700.025n

.meas tran vdout1_94ck1390 FIND v(dout1_94) AT=700.025n

.meas tran vdout1_95ck1390 FIND v(dout1_95) AT=700.025n

.meas tran vdout1_96ck1390 FIND v(dout1_96) AT=700.025n

.meas tran vdout1_97ck1390 FIND v(dout1_97) AT=700.025n

.meas tran vdout1_98ck1390 FIND v(dout1_98) AT=700.025n

.meas tran vdout1_99ck1390 FIND v(dout1_99) AT=700.025n

.meas tran vdout1_100ck1390 FIND v(dout1_100) AT=700.025n

.meas tran vdout1_101ck1390 FIND v(dout1_101) AT=700.025n

.meas tran vdout1_102ck1390 FIND v(dout1_102) AT=700.025n

.meas tran vdout1_103ck1390 FIND v(dout1_103) AT=700.025n

.meas tran vdout1_104ck1390 FIND v(dout1_104) AT=700.025n

.meas tran vdout1_105ck1390 FIND v(dout1_105) AT=700.025n

.meas tran vdout1_106ck1390 FIND v(dout1_106) AT=700.025n

.meas tran vdout1_107ck1390 FIND v(dout1_107) AT=700.025n

.meas tran vdout1_108ck1390 FIND v(dout1_108) AT=700.025n

.meas tran vdout1_109ck1390 FIND v(dout1_109) AT=700.025n

.meas tran vdout1_110ck1390 FIND v(dout1_110) AT=700.025n

.meas tran vdout1_111ck1390 FIND v(dout1_111) AT=700.025n

.meas tran vdout1_112ck1390 FIND v(dout1_112) AT=700.025n

.meas tran vdout1_113ck1390 FIND v(dout1_113) AT=700.025n

.meas tran vdout1_114ck1390 FIND v(dout1_114) AT=700.025n

.meas tran vdout1_115ck1390 FIND v(dout1_115) AT=700.025n

.meas tran vdout1_116ck1390 FIND v(dout1_116) AT=700.025n

.meas tran vdout1_117ck1390 FIND v(dout1_117) AT=700.025n

.meas tran vdout1_118ck1390 FIND v(dout1_118) AT=700.025n

.meas tran vdout1_119ck1390 FIND v(dout1_119) AT=700.025n

.meas tran vdout1_120ck1390 FIND v(dout1_120) AT=700.025n

.meas tran vdout1_121ck1390 FIND v(dout1_121) AT=700.025n

.meas tran vdout1_122ck1390 FIND v(dout1_122) AT=700.025n

.meas tran vdout1_123ck1390 FIND v(dout1_123) AT=700.025n

.meas tran vdout1_124ck1390 FIND v(dout1_124) AT=700.025n

.meas tran vdout1_125ck1390 FIND v(dout1_125) AT=700.025n

.meas tran vdout1_126ck1390 FIND v(dout1_126) AT=700.025n

.meas tran vdout1_127ck1390 FIND v(dout1_127) AT=700.025n

.meas tran vdout1_128ck1390 FIND v(dout1_128) AT=700.025n

.meas tran vdout1_129ck1390 FIND v(dout1_129) AT=700.025n

.meas tran vdout1_130ck1390 FIND v(dout1_130) AT=700.025n

.meas tran vdout1_131ck1390 FIND v(dout1_131) AT=700.025n

.meas tran vdout1_132ck1390 FIND v(dout1_132) AT=700.025n

.meas tran vdout1_133ck1390 FIND v(dout1_133) AT=700.025n

.meas tran vdout1_134ck1390 FIND v(dout1_134) AT=700.025n

.meas tran vdout1_135ck1390 FIND v(dout1_135) AT=700.025n

.meas tran vdout1_136ck1390 FIND v(dout1_136) AT=700.025n

.meas tran vdout1_137ck1390 FIND v(dout1_137) AT=700.025n

.meas tran vdout1_138ck1390 FIND v(dout1_138) AT=700.025n

.meas tran vdout1_139ck1390 FIND v(dout1_139) AT=700.025n

.meas tran vdout1_140ck1390 FIND v(dout1_140) AT=700.025n

.meas tran vdout1_141ck1390 FIND v(dout1_141) AT=700.025n

.meas tran vdout1_142ck1390 FIND v(dout1_142) AT=700.025n

.meas tran vdout1_143ck1390 FIND v(dout1_143) AT=700.025n

.meas tran vdout1_144ck1390 FIND v(dout1_144) AT=700.025n

.meas tran vdout1_145ck1390 FIND v(dout1_145) AT=700.025n

.meas tran vdout1_146ck1390 FIND v(dout1_146) AT=700.025n

.meas tran vdout1_147ck1390 FIND v(dout1_147) AT=700.025n

.meas tran vdout1_148ck1390 FIND v(dout1_148) AT=700.025n

.meas tran vdout1_149ck1390 FIND v(dout1_149) AT=700.025n

.meas tran vdout1_150ck1390 FIND v(dout1_150) AT=700.025n

.meas tran vdout1_151ck1390 FIND v(dout1_151) AT=700.025n

.meas tran vdout1_152ck1390 FIND v(dout1_152) AT=700.025n

.meas tran vdout1_153ck1390 FIND v(dout1_153) AT=700.025n

.meas tran vdout1_154ck1390 FIND v(dout1_154) AT=700.025n

.meas tran vdout1_155ck1390 FIND v(dout1_155) AT=700.025n

.meas tran vdout1_156ck1390 FIND v(dout1_156) AT=700.025n

.meas tran vdout1_157ck1390 FIND v(dout1_157) AT=700.025n

.meas tran vdout1_158ck1390 FIND v(dout1_158) AT=700.025n

.meas tran vdout1_159ck1390 FIND v(dout1_159) AT=700.025n

.meas tran vdout1_160ck1390 FIND v(dout1_160) AT=700.025n

.meas tran vdout1_161ck1390 FIND v(dout1_161) AT=700.025n

.meas tran vdout1_162ck1390 FIND v(dout1_162) AT=700.025n

.meas tran vdout1_163ck1390 FIND v(dout1_163) AT=700.025n

.meas tran vdout1_164ck1390 FIND v(dout1_164) AT=700.025n

.meas tran vdout1_165ck1390 FIND v(dout1_165) AT=700.025n

.meas tran vdout1_166ck1390 FIND v(dout1_166) AT=700.025n

.meas tran vdout1_167ck1390 FIND v(dout1_167) AT=700.025n

.meas tran vdout1_168ck1390 FIND v(dout1_168) AT=700.025n

.meas tran vdout1_169ck1390 FIND v(dout1_169) AT=700.025n

.meas tran vdout1_170ck1390 FIND v(dout1_170) AT=700.025n

.meas tran vdout1_171ck1390 FIND v(dout1_171) AT=700.025n

.meas tran vdout1_172ck1390 FIND v(dout1_172) AT=700.025n

.meas tran vdout1_173ck1390 FIND v(dout1_173) AT=700.025n

.meas tran vdout1_174ck1390 FIND v(dout1_174) AT=700.025n

.meas tran vdout1_175ck1390 FIND v(dout1_175) AT=700.025n

.meas tran vdout1_176ck1390 FIND v(dout1_176) AT=700.025n

.meas tran vdout1_177ck1390 FIND v(dout1_177) AT=700.025n

.meas tran vdout1_178ck1390 FIND v(dout1_178) AT=700.025n

.meas tran vdout1_179ck1390 FIND v(dout1_179) AT=700.025n

.meas tran vdout1_180ck1390 FIND v(dout1_180) AT=700.025n

.meas tran vdout1_181ck1390 FIND v(dout1_181) AT=700.025n

.meas tran vdout1_182ck1390 FIND v(dout1_182) AT=700.025n

.meas tran vdout1_183ck1390 FIND v(dout1_183) AT=700.025n

.meas tran vdout1_184ck1390 FIND v(dout1_184) AT=700.025n

.meas tran vdout1_185ck1390 FIND v(dout1_185) AT=700.025n

.meas tran vdout1_186ck1390 FIND v(dout1_186) AT=700.025n

.meas tran vdout1_187ck1390 FIND v(dout1_187) AT=700.025n

.meas tran vdout1_188ck1390 FIND v(dout1_188) AT=700.025n

.meas tran vdout1_189ck1390 FIND v(dout1_189) AT=700.025n

.meas tran vdout1_190ck1390 FIND v(dout1_190) AT=700.025n

.meas tran vdout1_191ck1390 FIND v(dout1_191) AT=700.025n

.meas tran vdout1_192ck1390 FIND v(dout1_192) AT=700.025n

.meas tran vdout1_193ck1390 FIND v(dout1_193) AT=700.025n

.meas tran vdout1_194ck1390 FIND v(dout1_194) AT=700.025n

.meas tran vdout1_195ck1390 FIND v(dout1_195) AT=700.025n

.meas tran vdout1_196ck1390 FIND v(dout1_196) AT=700.025n

.meas tran vdout1_197ck1390 FIND v(dout1_197) AT=700.025n

.meas tran vdout1_198ck1390 FIND v(dout1_198) AT=700.025n

.meas tran vdout1_199ck1390 FIND v(dout1_199) AT=700.025n

.meas tran vdout1_200ck1390 FIND v(dout1_200) AT=700.025n

.meas tran vdout1_201ck1390 FIND v(dout1_201) AT=700.025n

.meas tran vdout1_202ck1390 FIND v(dout1_202) AT=700.025n

.meas tran vdout1_203ck1390 FIND v(dout1_203) AT=700.025n

.meas tran vdout1_204ck1390 FIND v(dout1_204) AT=700.025n

.meas tran vdout1_205ck1390 FIND v(dout1_205) AT=700.025n

.meas tran vdout1_206ck1390 FIND v(dout1_206) AT=700.025n

.meas tran vdout1_207ck1390 FIND v(dout1_207) AT=700.025n

.meas tran vdout1_208ck1390 FIND v(dout1_208) AT=700.025n

.meas tran vdout1_209ck1390 FIND v(dout1_209) AT=700.025n

.meas tran vdout1_210ck1390 FIND v(dout1_210) AT=700.025n

.meas tran vdout1_211ck1390 FIND v(dout1_211) AT=700.025n

.meas tran vdout1_212ck1390 FIND v(dout1_212) AT=700.025n

.meas tran vdout1_213ck1390 FIND v(dout1_213) AT=700.025n

.meas tran vdout1_214ck1390 FIND v(dout1_214) AT=700.025n

.meas tran vdout1_215ck1390 FIND v(dout1_215) AT=700.025n

.meas tran vdout1_216ck1390 FIND v(dout1_216) AT=700.025n

.meas tran vdout1_217ck1390 FIND v(dout1_217) AT=700.025n

.meas tran vdout1_218ck1390 FIND v(dout1_218) AT=700.025n

.meas tran vdout1_219ck1390 FIND v(dout1_219) AT=700.025n

.meas tran vdout1_220ck1390 FIND v(dout1_220) AT=700.025n

.meas tran vdout1_221ck1390 FIND v(dout1_221) AT=700.025n

.meas tran vdout1_222ck1390 FIND v(dout1_222) AT=700.025n

.meas tran vdout1_223ck1390 FIND v(dout1_223) AT=700.025n

.meas tran vdout1_224ck1390 FIND v(dout1_224) AT=700.025n

.meas tran vdout1_225ck1390 FIND v(dout1_225) AT=700.025n

.meas tran vdout1_226ck1390 FIND v(dout1_226) AT=700.025n

.meas tran vdout1_227ck1390 FIND v(dout1_227) AT=700.025n

.meas tran vdout1_228ck1390 FIND v(dout1_228) AT=700.025n

.meas tran vdout1_229ck1390 FIND v(dout1_229) AT=700.025n

.meas tran vdout1_230ck1390 FIND v(dout1_230) AT=700.025n

.meas tran vdout1_231ck1390 FIND v(dout1_231) AT=700.025n

.meas tran vdout1_232ck1390 FIND v(dout1_232) AT=700.025n

.meas tran vdout1_233ck1390 FIND v(dout1_233) AT=700.025n

.meas tran vdout1_234ck1390 FIND v(dout1_234) AT=700.025n

.meas tran vdout1_235ck1390 FIND v(dout1_235) AT=700.025n

.meas tran vdout1_236ck1390 FIND v(dout1_236) AT=700.025n

.meas tran vdout1_237ck1390 FIND v(dout1_237) AT=700.025n

.meas tran vdout1_238ck1390 FIND v(dout1_238) AT=700.025n

.meas tran vdout1_239ck1390 FIND v(dout1_239) AT=700.025n

.meas tran vdout1_240ck1390 FIND v(dout1_240) AT=700.025n

.meas tran vdout1_241ck1390 FIND v(dout1_241) AT=700.025n

.meas tran vdout1_242ck1390 FIND v(dout1_242) AT=700.025n

.meas tran vdout1_243ck1390 FIND v(dout1_243) AT=700.025n

.meas tran vdout1_244ck1390 FIND v(dout1_244) AT=700.025n

.meas tran vdout1_245ck1390 FIND v(dout1_245) AT=700.025n

.meas tran vdout1_246ck1390 FIND v(dout1_246) AT=700.025n

.meas tran vdout1_247ck1390 FIND v(dout1_247) AT=700.025n

.meas tran vdout1_248ck1390 FIND v(dout1_248) AT=700.025n

.meas tran vdout1_249ck1390 FIND v(dout1_249) AT=700.025n

.meas tran vdout1_250ck1390 FIND v(dout1_250) AT=700.025n

.meas tran vdout1_251ck1390 FIND v(dout1_251) AT=700.025n

.meas tran vdout1_252ck1390 FIND v(dout1_252) AT=700.025n

.meas tran vdout1_253ck1390 FIND v(dout1_253) AT=700.025n

.meas tran vdout1_254ck1390 FIND v(dout1_254) AT=700.025n

.meas tran vdout1_255ck1390 FIND v(dout1_255) AT=700.025n

.meas tran vdout1_256ck1390 FIND v(dout1_256) AT=700.025n

.meas tran vdout1_257ck1390 FIND v(dout1_257) AT=700.025n

.meas tran vdout1_258ck1390 FIND v(dout1_258) AT=700.025n

.meas tran vdout1_259ck1390 FIND v(dout1_259) AT=700.025n

.meas tran vdout1_260ck1390 FIND v(dout1_260) AT=700.025n

.meas tran vdout1_261ck1390 FIND v(dout1_261) AT=700.025n

.meas tran vdout1_262ck1390 FIND v(dout1_262) AT=700.025n

.meas tran vdout1_263ck1390 FIND v(dout1_263) AT=700.025n

.meas tran vdout1_264ck1390 FIND v(dout1_264) AT=700.025n

.meas tran vdout1_265ck1390 FIND v(dout1_265) AT=700.025n

.meas tran vdout1_266ck1390 FIND v(dout1_266) AT=700.025n

.meas tran vdout1_267ck1390 FIND v(dout1_267) AT=700.025n

.meas tran vdout1_268ck1390 FIND v(dout1_268) AT=700.025n

.meas tran vdout1_269ck1390 FIND v(dout1_269) AT=700.025n

.meas tran vdout1_270ck1390 FIND v(dout1_270) AT=700.025n

.meas tran vdout1_271ck1390 FIND v(dout1_271) AT=700.025n

.meas tran vdout1_272ck1390 FIND v(dout1_272) AT=700.025n

.meas tran vdout1_273ck1390 FIND v(dout1_273) AT=700.025n

.meas tran vdout1_274ck1390 FIND v(dout1_274) AT=700.025n

.meas tran vdout1_275ck1390 FIND v(dout1_275) AT=700.025n

.meas tran vdout1_276ck1390 FIND v(dout1_276) AT=700.025n

.meas tran vdout1_277ck1390 FIND v(dout1_277) AT=700.025n

.meas tran vdout1_278ck1390 FIND v(dout1_278) AT=700.025n

.meas tran vdout1_279ck1390 FIND v(dout1_279) AT=700.025n

.meas tran vdout1_280ck1390 FIND v(dout1_280) AT=700.025n

.meas tran vdout1_281ck1390 FIND v(dout1_281) AT=700.025n

.meas tran vdout1_282ck1390 FIND v(dout1_282) AT=700.025n

.meas tran vdout1_283ck1390 FIND v(dout1_283) AT=700.025n

.meas tran vdout1_284ck1390 FIND v(dout1_284) AT=700.025n

.meas tran vdout1_285ck1390 FIND v(dout1_285) AT=700.025n

.meas tran vdout1_286ck1390 FIND v(dout1_286) AT=700.025n

.meas tran vdout1_287ck1390 FIND v(dout1_287) AT=700.025n

.meas tran vdout1_288ck1390 FIND v(dout1_288) AT=700.025n

.meas tran vdout1_289ck1390 FIND v(dout1_289) AT=700.025n

.meas tran vdout1_290ck1390 FIND v(dout1_290) AT=700.025n

.meas tran vdout1_291ck1390 FIND v(dout1_291) AT=700.025n

.meas tran vdout1_292ck1390 FIND v(dout1_292) AT=700.025n

.meas tran vdout1_293ck1390 FIND v(dout1_293) AT=700.025n

.meas tran vdout1_294ck1390 FIND v(dout1_294) AT=700.025n

.meas tran vdout1_295ck1390 FIND v(dout1_295) AT=700.025n

.meas tran vdout1_296ck1390 FIND v(dout1_296) AT=700.025n

.meas tran vdout1_297ck1390 FIND v(dout1_297) AT=700.025n

.meas tran vdout1_298ck1390 FIND v(dout1_298) AT=700.025n

.meas tran vdout1_299ck1390 FIND v(dout1_299) AT=700.025n

.meas tran vdout1_300ck1390 FIND v(dout1_300) AT=700.025n

.meas tran vdout1_301ck1390 FIND v(dout1_301) AT=700.025n

.meas tran vdout1_302ck1390 FIND v(dout1_302) AT=700.025n

.meas tran vdout1_303ck1390 FIND v(dout1_303) AT=700.025n

.meas tran vdout1_304ck1390 FIND v(dout1_304) AT=700.025n

.meas tran vdout1_305ck1390 FIND v(dout1_305) AT=700.025n

.meas tran vdout1_306ck1390 FIND v(dout1_306) AT=700.025n

.meas tran vdout1_307ck1390 FIND v(dout1_307) AT=700.025n

.meas tran vdout1_308ck1390 FIND v(dout1_308) AT=700.025n

.meas tran vdout1_309ck1390 FIND v(dout1_309) AT=700.025n

.meas tran vdout1_310ck1390 FIND v(dout1_310) AT=700.025n

.meas tran vdout1_311ck1390 FIND v(dout1_311) AT=700.025n

.meas tran vdout1_312ck1390 FIND v(dout1_312) AT=700.025n

.meas tran vdout1_313ck1390 FIND v(dout1_313) AT=700.025n

.meas tran vdout1_314ck1390 FIND v(dout1_314) AT=700.025n

.meas tran vdout1_315ck1390 FIND v(dout1_315) AT=700.025n

.meas tran vdout1_316ck1390 FIND v(dout1_316) AT=700.025n

.meas tran vdout1_317ck1390 FIND v(dout1_317) AT=700.025n

.meas tran vdout1_318ck1390 FIND v(dout1_318) AT=700.025n

.meas tran vdout1_319ck1390 FIND v(dout1_319) AT=700.025n

.meas tran vdout1_320ck1390 FIND v(dout1_320) AT=700.025n

.meas tran vdout1_321ck1390 FIND v(dout1_321) AT=700.025n

.meas tran vdout1_322ck1390 FIND v(dout1_322) AT=700.025n

.meas tran vdout1_323ck1390 FIND v(dout1_323) AT=700.025n

.meas tran vdout1_324ck1390 FIND v(dout1_324) AT=700.025n

.meas tran vdout1_325ck1390 FIND v(dout1_325) AT=700.025n

.meas tran vdout1_326ck1390 FIND v(dout1_326) AT=700.025n

.meas tran vdout1_327ck1390 FIND v(dout1_327) AT=700.025n

.meas tran vdout1_328ck1390 FIND v(dout1_328) AT=700.025n

.meas tran vdout1_329ck1390 FIND v(dout1_329) AT=700.025n

.meas tran vdout1_330ck1390 FIND v(dout1_330) AT=700.025n

.meas tran vdout1_331ck1390 FIND v(dout1_331) AT=700.025n

.meas tran vdout1_332ck1390 FIND v(dout1_332) AT=700.025n

.meas tran vdout1_333ck1390 FIND v(dout1_333) AT=700.025n

.meas tran vdout1_334ck1390 FIND v(dout1_334) AT=700.025n

.meas tran vdout1_335ck1390 FIND v(dout1_335) AT=700.025n

.meas tran vdout1_336ck1390 FIND v(dout1_336) AT=700.025n

.meas tran vdout1_337ck1390 FIND v(dout1_337) AT=700.025n

.meas tran vdout1_338ck1390 FIND v(dout1_338) AT=700.025n

.meas tran vdout1_339ck1390 FIND v(dout1_339) AT=700.025n

.meas tran vdout1_340ck1390 FIND v(dout1_340) AT=700.025n

.meas tran vdout1_341ck1390 FIND v(dout1_341) AT=700.025n

.meas tran vdout1_342ck1390 FIND v(dout1_342) AT=700.025n

.meas tran vdout1_343ck1390 FIND v(dout1_343) AT=700.025n

.meas tran vdout1_344ck1390 FIND v(dout1_344) AT=700.025n

.meas tran vdout1_345ck1390 FIND v(dout1_345) AT=700.025n

.meas tran vdout1_346ck1390 FIND v(dout1_346) AT=700.025n

.meas tran vdout1_347ck1390 FIND v(dout1_347) AT=700.025n

.meas tran vdout1_348ck1390 FIND v(dout1_348) AT=700.025n

.meas tran vdout1_349ck1390 FIND v(dout1_349) AT=700.025n

.meas tran vdout1_350ck1390 FIND v(dout1_350) AT=700.025n

.meas tran vdout1_351ck1390 FIND v(dout1_351) AT=700.025n

.meas tran vdout1_352ck1390 FIND v(dout1_352) AT=700.025n

.meas tran vdout1_353ck1390 FIND v(dout1_353) AT=700.025n

.meas tran vdout1_354ck1390 FIND v(dout1_354) AT=700.025n

.meas tran vdout1_355ck1390 FIND v(dout1_355) AT=700.025n

.meas tran vdout1_356ck1390 FIND v(dout1_356) AT=700.025n

.meas tran vdout1_357ck1390 FIND v(dout1_357) AT=700.025n

.meas tran vdout1_358ck1390 FIND v(dout1_358) AT=700.025n

.meas tran vdout1_359ck1390 FIND v(dout1_359) AT=700.025n

.meas tran vdout1_360ck1390 FIND v(dout1_360) AT=700.025n

.meas tran vdout1_361ck1390 FIND v(dout1_361) AT=700.025n

.meas tran vdout1_362ck1390 FIND v(dout1_362) AT=700.025n

.meas tran vdout1_363ck1390 FIND v(dout1_363) AT=700.025n

.meas tran vdout1_364ck1390 FIND v(dout1_364) AT=700.025n

.meas tran vdout1_365ck1390 FIND v(dout1_365) AT=700.025n

.meas tran vdout1_366ck1390 FIND v(dout1_366) AT=700.025n

.meas tran vdout1_367ck1390 FIND v(dout1_367) AT=700.025n

.meas tran vdout1_368ck1390 FIND v(dout1_368) AT=700.025n

.meas tran vdout1_369ck1390 FIND v(dout1_369) AT=700.025n

.meas tran vdout1_370ck1390 FIND v(dout1_370) AT=700.025n

.meas tran vdout1_371ck1390 FIND v(dout1_371) AT=700.025n

.meas tran vdout1_372ck1390 FIND v(dout1_372) AT=700.025n

.meas tran vdout1_373ck1390 FIND v(dout1_373) AT=700.025n

.meas tran vdout1_374ck1390 FIND v(dout1_374) AT=700.025n

.meas tran vdout1_375ck1390 FIND v(dout1_375) AT=700.025n

.meas tran vdout1_376ck1390 FIND v(dout1_376) AT=700.025n

.meas tran vdout1_377ck1390 FIND v(dout1_377) AT=700.025n

.meas tran vdout1_378ck1390 FIND v(dout1_378) AT=700.025n

.meas tran vdout1_379ck1390 FIND v(dout1_379) AT=700.025n

.meas tran vdout1_380ck1390 FIND v(dout1_380) AT=700.025n

.meas tran vdout1_381ck1390 FIND v(dout1_381) AT=700.025n

.meas tran vdout1_382ck1390 FIND v(dout1_382) AT=700.025n

.meas tran vdout1_383ck1390 FIND v(dout1_383) AT=700.025n

.meas tran vdout1_384ck1390 FIND v(dout1_384) AT=700.025n

.meas tran vdout1_385ck1390 FIND v(dout1_385) AT=700.025n

.meas tran vdout1_386ck1390 FIND v(dout1_386) AT=700.025n

.meas tran vdout1_387ck1390 FIND v(dout1_387) AT=700.025n

.meas tran vdout1_388ck1390 FIND v(dout1_388) AT=700.025n

.meas tran vdout1_389ck1390 FIND v(dout1_389) AT=700.025n

.meas tran vdout1_390ck1390 FIND v(dout1_390) AT=700.025n

.meas tran vdout1_391ck1390 FIND v(dout1_391) AT=700.025n

.meas tran vdout1_392ck1390 FIND v(dout1_392) AT=700.025n

.meas tran vdout1_393ck1390 FIND v(dout1_393) AT=700.025n

.meas tran vdout1_394ck1390 FIND v(dout1_394) AT=700.025n

.meas tran vdout1_395ck1390 FIND v(dout1_395) AT=700.025n

.meas tran vdout1_396ck1390 FIND v(dout1_396) AT=700.025n

.meas tran vdout1_397ck1390 FIND v(dout1_397) AT=700.025n

.meas tran vdout1_398ck1390 FIND v(dout1_398) AT=700.025n

.meas tran vdout1_399ck1390 FIND v(dout1_399) AT=700.025n

.meas tran vdout1_400ck1390 FIND v(dout1_400) AT=700.025n

.meas tran vdout1_401ck1390 FIND v(dout1_401) AT=700.025n

.meas tran vdout1_402ck1390 FIND v(dout1_402) AT=700.025n

.meas tran vdout1_403ck1390 FIND v(dout1_403) AT=700.025n

.meas tran vdout1_404ck1390 FIND v(dout1_404) AT=700.025n

.meas tran vdout1_405ck1390 FIND v(dout1_405) AT=700.025n

.meas tran vdout1_406ck1390 FIND v(dout1_406) AT=700.025n

.meas tran vdout1_407ck1390 FIND v(dout1_407) AT=700.025n

.meas tran vdout1_408ck1390 FIND v(dout1_408) AT=700.025n

.meas tran vdout1_409ck1390 FIND v(dout1_409) AT=700.025n

.meas tran vdout1_410ck1390 FIND v(dout1_410) AT=700.025n

.meas tran vdout1_411ck1390 FIND v(dout1_411) AT=700.025n

.meas tran vdout1_412ck1390 FIND v(dout1_412) AT=700.025n

.meas tran vdout1_413ck1390 FIND v(dout1_413) AT=700.025n

.meas tran vdout1_414ck1390 FIND v(dout1_414) AT=700.025n

.meas tran vdout1_415ck1390 FIND v(dout1_415) AT=700.025n

.meas tran vdout1_416ck1390 FIND v(dout1_416) AT=700.025n

.meas tran vdout1_417ck1390 FIND v(dout1_417) AT=700.025n

.meas tran vdout1_418ck1390 FIND v(dout1_418) AT=700.025n

.meas tran vdout1_419ck1390 FIND v(dout1_419) AT=700.025n

.meas tran vdout1_420ck1390 FIND v(dout1_420) AT=700.025n

.meas tran vdout1_421ck1390 FIND v(dout1_421) AT=700.025n

.meas tran vdout1_422ck1390 FIND v(dout1_422) AT=700.025n

.meas tran vdout1_423ck1390 FIND v(dout1_423) AT=700.025n

.meas tran vdout1_424ck1390 FIND v(dout1_424) AT=700.025n

.meas tran vdout1_425ck1390 FIND v(dout1_425) AT=700.025n

.meas tran vdout1_426ck1390 FIND v(dout1_426) AT=700.025n

.meas tran vdout1_427ck1390 FIND v(dout1_427) AT=700.025n

.meas tran vdout1_428ck1390 FIND v(dout1_428) AT=700.025n

.meas tran vdout1_429ck1390 FIND v(dout1_429) AT=700.025n

.meas tran vdout1_430ck1390 FIND v(dout1_430) AT=700.025n

.meas tran vdout1_431ck1390 FIND v(dout1_431) AT=700.025n

.meas tran vdout1_432ck1390 FIND v(dout1_432) AT=700.025n

.meas tran vdout1_433ck1390 FIND v(dout1_433) AT=700.025n

.meas tran vdout1_434ck1390 FIND v(dout1_434) AT=700.025n

.meas tran vdout1_435ck1390 FIND v(dout1_435) AT=700.025n

.meas tran vdout1_436ck1390 FIND v(dout1_436) AT=700.025n

.meas tran vdout1_437ck1390 FIND v(dout1_437) AT=700.025n

.meas tran vdout1_438ck1390 FIND v(dout1_438) AT=700.025n

.meas tran vdout1_439ck1390 FIND v(dout1_439) AT=700.025n

.meas tran vdout1_440ck1390 FIND v(dout1_440) AT=700.025n

.meas tran vdout1_441ck1390 FIND v(dout1_441) AT=700.025n

.meas tran vdout1_442ck1390 FIND v(dout1_442) AT=700.025n

.meas tran vdout1_443ck1390 FIND v(dout1_443) AT=700.025n

.meas tran vdout1_444ck1390 FIND v(dout1_444) AT=700.025n

.meas tran vdout1_445ck1390 FIND v(dout1_445) AT=700.025n

.meas tran vdout1_446ck1390 FIND v(dout1_446) AT=700.025n

.meas tran vdout1_447ck1390 FIND v(dout1_447) AT=700.025n

.meas tran vdout1_448ck1390 FIND v(dout1_448) AT=700.025n

.meas tran vdout1_449ck1390 FIND v(dout1_449) AT=700.025n

.meas tran vdout1_450ck1390 FIND v(dout1_450) AT=700.025n

.meas tran vdout1_451ck1390 FIND v(dout1_451) AT=700.025n

.meas tran vdout1_452ck1390 FIND v(dout1_452) AT=700.025n

.meas tran vdout1_453ck1390 FIND v(dout1_453) AT=700.025n

.meas tran vdout1_454ck1390 FIND v(dout1_454) AT=700.025n

.meas tran vdout1_455ck1390 FIND v(dout1_455) AT=700.025n

.meas tran vdout1_456ck1390 FIND v(dout1_456) AT=700.025n

.meas tran vdout1_457ck1390 FIND v(dout1_457) AT=700.025n

.meas tran vdout1_458ck1390 FIND v(dout1_458) AT=700.025n

.meas tran vdout1_459ck1390 FIND v(dout1_459) AT=700.025n

.meas tran vdout1_460ck1390 FIND v(dout1_460) AT=700.025n

.meas tran vdout1_461ck1390 FIND v(dout1_461) AT=700.025n

.meas tran vdout1_462ck1390 FIND v(dout1_462) AT=700.025n

.meas tran vdout1_463ck1390 FIND v(dout1_463) AT=700.025n

.meas tran vdout1_464ck1390 FIND v(dout1_464) AT=700.025n

.meas tran vdout1_465ck1390 FIND v(dout1_465) AT=700.025n

.meas tran vdout1_466ck1390 FIND v(dout1_466) AT=700.025n

.meas tran vdout1_467ck1390 FIND v(dout1_467) AT=700.025n

.meas tran vdout1_468ck1390 FIND v(dout1_468) AT=700.025n

.meas tran vdout1_469ck1390 FIND v(dout1_469) AT=700.025n

.meas tran vdout1_470ck1390 FIND v(dout1_470) AT=700.025n

.meas tran vdout1_471ck1390 FIND v(dout1_471) AT=700.025n

.meas tran vdout1_472ck1390 FIND v(dout1_472) AT=700.025n

.meas tran vdout1_473ck1390 FIND v(dout1_473) AT=700.025n

.meas tran vdout1_474ck1390 FIND v(dout1_474) AT=700.025n

.meas tran vdout1_475ck1390 FIND v(dout1_475) AT=700.025n

.meas tran vdout1_476ck1390 FIND v(dout1_476) AT=700.025n

.meas tran vdout1_477ck1390 FIND v(dout1_477) AT=700.025n

.meas tran vdout1_478ck1390 FIND v(dout1_478) AT=700.025n

.meas tran vdout1_479ck1390 FIND v(dout1_479) AT=700.025n

.meas tran vdout1_480ck1390 FIND v(dout1_480) AT=700.025n

.meas tran vdout1_481ck1390 FIND v(dout1_481) AT=700.025n

.meas tran vdout1_482ck1390 FIND v(dout1_482) AT=700.025n

.meas tran vdout1_483ck1390 FIND v(dout1_483) AT=700.025n

.meas tran vdout1_484ck1390 FIND v(dout1_484) AT=700.025n

.meas tran vdout1_485ck1390 FIND v(dout1_485) AT=700.025n

.meas tran vdout1_486ck1390 FIND v(dout1_486) AT=700.025n

.meas tran vdout1_487ck1390 FIND v(dout1_487) AT=700.025n

.meas tran vdout1_488ck1390 FIND v(dout1_488) AT=700.025n

.meas tran vdout1_489ck1390 FIND v(dout1_489) AT=700.025n

.meas tran vdout1_490ck1390 FIND v(dout1_490) AT=700.025n

.meas tran vdout1_491ck1390 FIND v(dout1_491) AT=700.025n

.meas tran vdout1_492ck1390 FIND v(dout1_492) AT=700.025n

.meas tran vdout1_493ck1390 FIND v(dout1_493) AT=700.025n

.meas tran vdout1_494ck1390 FIND v(dout1_494) AT=700.025n

.meas tran vdout1_495ck1390 FIND v(dout1_495) AT=700.025n

.meas tran vdout1_496ck1390 FIND v(dout1_496) AT=700.025n

.meas tran vdout1_497ck1390 FIND v(dout1_497) AT=700.025n

.meas tran vdout1_498ck1390 FIND v(dout1_498) AT=700.025n

.meas tran vdout1_499ck1390 FIND v(dout1_499) AT=700.025n

.meas tran vdout1_500ck1390 FIND v(dout1_500) AT=700.025n

.meas tran vdout1_501ck1390 FIND v(dout1_501) AT=700.025n

.meas tran vdout1_502ck1390 FIND v(dout1_502) AT=700.025n

.meas tran vdout1_503ck1390 FIND v(dout1_503) AT=700.025n

.meas tran vdout1_504ck1390 FIND v(dout1_504) AT=700.025n

.meas tran vdout1_505ck1390 FIND v(dout1_505) AT=700.025n

.meas tran vdout1_506ck1390 FIND v(dout1_506) AT=700.025n

.meas tran vdout1_507ck1390 FIND v(dout1_507) AT=700.025n

.meas tran vdout1_508ck1390 FIND v(dout1_508) AT=700.025n

.meas tran vdout1_509ck1390 FIND v(dout1_509) AT=700.025n

.meas tran vdout1_510ck1390 FIND v(dout1_510) AT=700.025n

.meas tran vdout1_511ck1390 FIND v(dout1_511) AT=700.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_32ck1400 FIND v(dout1_32) AT=705.025n

.meas tran vdout1_33ck1400 FIND v(dout1_33) AT=705.025n

.meas tran vdout1_34ck1400 FIND v(dout1_34) AT=705.025n

.meas tran vdout1_35ck1400 FIND v(dout1_35) AT=705.025n

.meas tran vdout1_36ck1400 FIND v(dout1_36) AT=705.025n

.meas tran vdout1_37ck1400 FIND v(dout1_37) AT=705.025n

.meas tran vdout1_38ck1400 FIND v(dout1_38) AT=705.025n

.meas tran vdout1_39ck1400 FIND v(dout1_39) AT=705.025n

.meas tran vdout1_40ck1400 FIND v(dout1_40) AT=705.025n

.meas tran vdout1_41ck1400 FIND v(dout1_41) AT=705.025n

.meas tran vdout1_42ck1400 FIND v(dout1_42) AT=705.025n

.meas tran vdout1_43ck1400 FIND v(dout1_43) AT=705.025n

.meas tran vdout1_44ck1400 FIND v(dout1_44) AT=705.025n

.meas tran vdout1_45ck1400 FIND v(dout1_45) AT=705.025n

.meas tran vdout1_46ck1400 FIND v(dout1_46) AT=705.025n

.meas tran vdout1_47ck1400 FIND v(dout1_47) AT=705.025n

.meas tran vdout1_48ck1400 FIND v(dout1_48) AT=705.025n

.meas tran vdout1_49ck1400 FIND v(dout1_49) AT=705.025n

.meas tran vdout1_50ck1400 FIND v(dout1_50) AT=705.025n

.meas tran vdout1_51ck1400 FIND v(dout1_51) AT=705.025n

.meas tran vdout1_52ck1400 FIND v(dout1_52) AT=705.025n

.meas tran vdout1_53ck1400 FIND v(dout1_53) AT=705.025n

.meas tran vdout1_54ck1400 FIND v(dout1_54) AT=705.025n

.meas tran vdout1_55ck1400 FIND v(dout1_55) AT=705.025n

.meas tran vdout1_56ck1400 FIND v(dout1_56) AT=705.025n

.meas tran vdout1_57ck1400 FIND v(dout1_57) AT=705.025n

.meas tran vdout1_58ck1400 FIND v(dout1_58) AT=705.025n

.meas tran vdout1_59ck1400 FIND v(dout1_59) AT=705.025n

.meas tran vdout1_60ck1400 FIND v(dout1_60) AT=705.025n

.meas tran vdout1_61ck1400 FIND v(dout1_61) AT=705.025n

.meas tran vdout1_62ck1400 FIND v(dout1_62) AT=705.025n

.meas tran vdout1_63ck1400 FIND v(dout1_63) AT=705.025n

.meas tran vdout1_64ck1400 FIND v(dout1_64) AT=705.025n

.meas tran vdout1_65ck1400 FIND v(dout1_65) AT=705.025n

.meas tran vdout1_66ck1400 FIND v(dout1_66) AT=705.025n

.meas tran vdout1_67ck1400 FIND v(dout1_67) AT=705.025n

.meas tran vdout1_68ck1400 FIND v(dout1_68) AT=705.025n

.meas tran vdout1_69ck1400 FIND v(dout1_69) AT=705.025n

.meas tran vdout1_70ck1400 FIND v(dout1_70) AT=705.025n

.meas tran vdout1_71ck1400 FIND v(dout1_71) AT=705.025n

.meas tran vdout1_72ck1400 FIND v(dout1_72) AT=705.025n

.meas tran vdout1_73ck1400 FIND v(dout1_73) AT=705.025n

.meas tran vdout1_74ck1400 FIND v(dout1_74) AT=705.025n

.meas tran vdout1_75ck1400 FIND v(dout1_75) AT=705.025n

.meas tran vdout1_76ck1400 FIND v(dout1_76) AT=705.025n

.meas tran vdout1_77ck1400 FIND v(dout1_77) AT=705.025n

.meas tran vdout1_78ck1400 FIND v(dout1_78) AT=705.025n

.meas tran vdout1_79ck1400 FIND v(dout1_79) AT=705.025n

.meas tran vdout1_80ck1400 FIND v(dout1_80) AT=705.025n

.meas tran vdout1_81ck1400 FIND v(dout1_81) AT=705.025n

.meas tran vdout1_82ck1400 FIND v(dout1_82) AT=705.025n

.meas tran vdout1_83ck1400 FIND v(dout1_83) AT=705.025n

.meas tran vdout1_84ck1400 FIND v(dout1_84) AT=705.025n

.meas tran vdout1_85ck1400 FIND v(dout1_85) AT=705.025n

.meas tran vdout1_86ck1400 FIND v(dout1_86) AT=705.025n

.meas tran vdout1_87ck1400 FIND v(dout1_87) AT=705.025n

.meas tran vdout1_88ck1400 FIND v(dout1_88) AT=705.025n

.meas tran vdout1_89ck1400 FIND v(dout1_89) AT=705.025n

.meas tran vdout1_90ck1400 FIND v(dout1_90) AT=705.025n

.meas tran vdout1_91ck1400 FIND v(dout1_91) AT=705.025n

.meas tran vdout1_92ck1400 FIND v(dout1_92) AT=705.025n

.meas tran vdout1_93ck1400 FIND v(dout1_93) AT=705.025n

.meas tran vdout1_94ck1400 FIND v(dout1_94) AT=705.025n

.meas tran vdout1_95ck1400 FIND v(dout1_95) AT=705.025n

.meas tran vdout1_96ck1400 FIND v(dout1_96) AT=705.025n

.meas tran vdout1_97ck1400 FIND v(dout1_97) AT=705.025n

.meas tran vdout1_98ck1400 FIND v(dout1_98) AT=705.025n

.meas tran vdout1_99ck1400 FIND v(dout1_99) AT=705.025n

.meas tran vdout1_100ck1400 FIND v(dout1_100) AT=705.025n

.meas tran vdout1_101ck1400 FIND v(dout1_101) AT=705.025n

.meas tran vdout1_102ck1400 FIND v(dout1_102) AT=705.025n

.meas tran vdout1_103ck1400 FIND v(dout1_103) AT=705.025n

.meas tran vdout1_104ck1400 FIND v(dout1_104) AT=705.025n

.meas tran vdout1_105ck1400 FIND v(dout1_105) AT=705.025n

.meas tran vdout1_106ck1400 FIND v(dout1_106) AT=705.025n

.meas tran vdout1_107ck1400 FIND v(dout1_107) AT=705.025n

.meas tran vdout1_108ck1400 FIND v(dout1_108) AT=705.025n

.meas tran vdout1_109ck1400 FIND v(dout1_109) AT=705.025n

.meas tran vdout1_110ck1400 FIND v(dout1_110) AT=705.025n

.meas tran vdout1_111ck1400 FIND v(dout1_111) AT=705.025n

.meas tran vdout1_112ck1400 FIND v(dout1_112) AT=705.025n

.meas tran vdout1_113ck1400 FIND v(dout1_113) AT=705.025n

.meas tran vdout1_114ck1400 FIND v(dout1_114) AT=705.025n

.meas tran vdout1_115ck1400 FIND v(dout1_115) AT=705.025n

.meas tran vdout1_116ck1400 FIND v(dout1_116) AT=705.025n

.meas tran vdout1_117ck1400 FIND v(dout1_117) AT=705.025n

.meas tran vdout1_118ck1400 FIND v(dout1_118) AT=705.025n

.meas tran vdout1_119ck1400 FIND v(dout1_119) AT=705.025n

.meas tran vdout1_120ck1400 FIND v(dout1_120) AT=705.025n

.meas tran vdout1_121ck1400 FIND v(dout1_121) AT=705.025n

.meas tran vdout1_122ck1400 FIND v(dout1_122) AT=705.025n

.meas tran vdout1_123ck1400 FIND v(dout1_123) AT=705.025n

.meas tran vdout1_124ck1400 FIND v(dout1_124) AT=705.025n

.meas tran vdout1_125ck1400 FIND v(dout1_125) AT=705.025n

.meas tran vdout1_126ck1400 FIND v(dout1_126) AT=705.025n

.meas tran vdout1_127ck1400 FIND v(dout1_127) AT=705.025n

.meas tran vdout1_128ck1400 FIND v(dout1_128) AT=705.025n

.meas tran vdout1_129ck1400 FIND v(dout1_129) AT=705.025n

.meas tran vdout1_130ck1400 FIND v(dout1_130) AT=705.025n

.meas tran vdout1_131ck1400 FIND v(dout1_131) AT=705.025n

.meas tran vdout1_132ck1400 FIND v(dout1_132) AT=705.025n

.meas tran vdout1_133ck1400 FIND v(dout1_133) AT=705.025n

.meas tran vdout1_134ck1400 FIND v(dout1_134) AT=705.025n

.meas tran vdout1_135ck1400 FIND v(dout1_135) AT=705.025n

.meas tran vdout1_136ck1400 FIND v(dout1_136) AT=705.025n

.meas tran vdout1_137ck1400 FIND v(dout1_137) AT=705.025n

.meas tran vdout1_138ck1400 FIND v(dout1_138) AT=705.025n

.meas tran vdout1_139ck1400 FIND v(dout1_139) AT=705.025n

.meas tran vdout1_140ck1400 FIND v(dout1_140) AT=705.025n

.meas tran vdout1_141ck1400 FIND v(dout1_141) AT=705.025n

.meas tran vdout1_142ck1400 FIND v(dout1_142) AT=705.025n

.meas tran vdout1_143ck1400 FIND v(dout1_143) AT=705.025n

.meas tran vdout1_144ck1400 FIND v(dout1_144) AT=705.025n

.meas tran vdout1_145ck1400 FIND v(dout1_145) AT=705.025n

.meas tran vdout1_146ck1400 FIND v(dout1_146) AT=705.025n

.meas tran vdout1_147ck1400 FIND v(dout1_147) AT=705.025n

.meas tran vdout1_148ck1400 FIND v(dout1_148) AT=705.025n

.meas tran vdout1_149ck1400 FIND v(dout1_149) AT=705.025n

.meas tran vdout1_150ck1400 FIND v(dout1_150) AT=705.025n

.meas tran vdout1_151ck1400 FIND v(dout1_151) AT=705.025n

.meas tran vdout1_152ck1400 FIND v(dout1_152) AT=705.025n

.meas tran vdout1_153ck1400 FIND v(dout1_153) AT=705.025n

.meas tran vdout1_154ck1400 FIND v(dout1_154) AT=705.025n

.meas tran vdout1_155ck1400 FIND v(dout1_155) AT=705.025n

.meas tran vdout1_156ck1400 FIND v(dout1_156) AT=705.025n

.meas tran vdout1_157ck1400 FIND v(dout1_157) AT=705.025n

.meas tran vdout1_158ck1400 FIND v(dout1_158) AT=705.025n

.meas tran vdout1_159ck1400 FIND v(dout1_159) AT=705.025n

.meas tran vdout1_160ck1400 FIND v(dout1_160) AT=705.025n

.meas tran vdout1_161ck1400 FIND v(dout1_161) AT=705.025n

.meas tran vdout1_162ck1400 FIND v(dout1_162) AT=705.025n

.meas tran vdout1_163ck1400 FIND v(dout1_163) AT=705.025n

.meas tran vdout1_164ck1400 FIND v(dout1_164) AT=705.025n

.meas tran vdout1_165ck1400 FIND v(dout1_165) AT=705.025n

.meas tran vdout1_166ck1400 FIND v(dout1_166) AT=705.025n

.meas tran vdout1_167ck1400 FIND v(dout1_167) AT=705.025n

.meas tran vdout1_168ck1400 FIND v(dout1_168) AT=705.025n

.meas tran vdout1_169ck1400 FIND v(dout1_169) AT=705.025n

.meas tran vdout1_170ck1400 FIND v(dout1_170) AT=705.025n

.meas tran vdout1_171ck1400 FIND v(dout1_171) AT=705.025n

.meas tran vdout1_172ck1400 FIND v(dout1_172) AT=705.025n

.meas tran vdout1_173ck1400 FIND v(dout1_173) AT=705.025n

.meas tran vdout1_174ck1400 FIND v(dout1_174) AT=705.025n

.meas tran vdout1_175ck1400 FIND v(dout1_175) AT=705.025n

.meas tran vdout1_176ck1400 FIND v(dout1_176) AT=705.025n

.meas tran vdout1_177ck1400 FIND v(dout1_177) AT=705.025n

.meas tran vdout1_178ck1400 FIND v(dout1_178) AT=705.025n

.meas tran vdout1_179ck1400 FIND v(dout1_179) AT=705.025n

.meas tran vdout1_180ck1400 FIND v(dout1_180) AT=705.025n

.meas tran vdout1_181ck1400 FIND v(dout1_181) AT=705.025n

.meas tran vdout1_182ck1400 FIND v(dout1_182) AT=705.025n

.meas tran vdout1_183ck1400 FIND v(dout1_183) AT=705.025n

.meas tran vdout1_184ck1400 FIND v(dout1_184) AT=705.025n

.meas tran vdout1_185ck1400 FIND v(dout1_185) AT=705.025n

.meas tran vdout1_186ck1400 FIND v(dout1_186) AT=705.025n

.meas tran vdout1_187ck1400 FIND v(dout1_187) AT=705.025n

.meas tran vdout1_188ck1400 FIND v(dout1_188) AT=705.025n

.meas tran vdout1_189ck1400 FIND v(dout1_189) AT=705.025n

.meas tran vdout1_190ck1400 FIND v(dout1_190) AT=705.025n

.meas tran vdout1_191ck1400 FIND v(dout1_191) AT=705.025n

.meas tran vdout1_192ck1400 FIND v(dout1_192) AT=705.025n

.meas tran vdout1_193ck1400 FIND v(dout1_193) AT=705.025n

.meas tran vdout1_194ck1400 FIND v(dout1_194) AT=705.025n

.meas tran vdout1_195ck1400 FIND v(dout1_195) AT=705.025n

.meas tran vdout1_196ck1400 FIND v(dout1_196) AT=705.025n

.meas tran vdout1_197ck1400 FIND v(dout1_197) AT=705.025n

.meas tran vdout1_198ck1400 FIND v(dout1_198) AT=705.025n

.meas tran vdout1_199ck1400 FIND v(dout1_199) AT=705.025n

.meas tran vdout1_200ck1400 FIND v(dout1_200) AT=705.025n

.meas tran vdout1_201ck1400 FIND v(dout1_201) AT=705.025n

.meas tran vdout1_202ck1400 FIND v(dout1_202) AT=705.025n

.meas tran vdout1_203ck1400 FIND v(dout1_203) AT=705.025n

.meas tran vdout1_204ck1400 FIND v(dout1_204) AT=705.025n

.meas tran vdout1_205ck1400 FIND v(dout1_205) AT=705.025n

.meas tran vdout1_206ck1400 FIND v(dout1_206) AT=705.025n

.meas tran vdout1_207ck1400 FIND v(dout1_207) AT=705.025n

.meas tran vdout1_208ck1400 FIND v(dout1_208) AT=705.025n

.meas tran vdout1_209ck1400 FIND v(dout1_209) AT=705.025n

.meas tran vdout1_210ck1400 FIND v(dout1_210) AT=705.025n

.meas tran vdout1_211ck1400 FIND v(dout1_211) AT=705.025n

.meas tran vdout1_212ck1400 FIND v(dout1_212) AT=705.025n

.meas tran vdout1_213ck1400 FIND v(dout1_213) AT=705.025n

.meas tran vdout1_214ck1400 FIND v(dout1_214) AT=705.025n

.meas tran vdout1_215ck1400 FIND v(dout1_215) AT=705.025n

.meas tran vdout1_216ck1400 FIND v(dout1_216) AT=705.025n

.meas tran vdout1_217ck1400 FIND v(dout1_217) AT=705.025n

.meas tran vdout1_218ck1400 FIND v(dout1_218) AT=705.025n

.meas tran vdout1_219ck1400 FIND v(dout1_219) AT=705.025n

.meas tran vdout1_220ck1400 FIND v(dout1_220) AT=705.025n

.meas tran vdout1_221ck1400 FIND v(dout1_221) AT=705.025n

.meas tran vdout1_222ck1400 FIND v(dout1_222) AT=705.025n

.meas tran vdout1_223ck1400 FIND v(dout1_223) AT=705.025n

.meas tran vdout1_224ck1400 FIND v(dout1_224) AT=705.025n

.meas tran vdout1_225ck1400 FIND v(dout1_225) AT=705.025n

.meas tran vdout1_226ck1400 FIND v(dout1_226) AT=705.025n

.meas tran vdout1_227ck1400 FIND v(dout1_227) AT=705.025n

.meas tran vdout1_228ck1400 FIND v(dout1_228) AT=705.025n

.meas tran vdout1_229ck1400 FIND v(dout1_229) AT=705.025n

.meas tran vdout1_230ck1400 FIND v(dout1_230) AT=705.025n

.meas tran vdout1_231ck1400 FIND v(dout1_231) AT=705.025n

.meas tran vdout1_232ck1400 FIND v(dout1_232) AT=705.025n

.meas tran vdout1_233ck1400 FIND v(dout1_233) AT=705.025n

.meas tran vdout1_234ck1400 FIND v(dout1_234) AT=705.025n

.meas tran vdout1_235ck1400 FIND v(dout1_235) AT=705.025n

.meas tran vdout1_236ck1400 FIND v(dout1_236) AT=705.025n

.meas tran vdout1_237ck1400 FIND v(dout1_237) AT=705.025n

.meas tran vdout1_238ck1400 FIND v(dout1_238) AT=705.025n

.meas tran vdout1_239ck1400 FIND v(dout1_239) AT=705.025n

.meas tran vdout1_240ck1400 FIND v(dout1_240) AT=705.025n

.meas tran vdout1_241ck1400 FIND v(dout1_241) AT=705.025n

.meas tran vdout1_242ck1400 FIND v(dout1_242) AT=705.025n

.meas tran vdout1_243ck1400 FIND v(dout1_243) AT=705.025n

.meas tran vdout1_244ck1400 FIND v(dout1_244) AT=705.025n

.meas tran vdout1_245ck1400 FIND v(dout1_245) AT=705.025n

.meas tran vdout1_246ck1400 FIND v(dout1_246) AT=705.025n

.meas tran vdout1_247ck1400 FIND v(dout1_247) AT=705.025n

.meas tran vdout1_248ck1400 FIND v(dout1_248) AT=705.025n

.meas tran vdout1_249ck1400 FIND v(dout1_249) AT=705.025n

.meas tran vdout1_250ck1400 FIND v(dout1_250) AT=705.025n

.meas tran vdout1_251ck1400 FIND v(dout1_251) AT=705.025n

.meas tran vdout1_252ck1400 FIND v(dout1_252) AT=705.025n

.meas tran vdout1_253ck1400 FIND v(dout1_253) AT=705.025n

.meas tran vdout1_254ck1400 FIND v(dout1_254) AT=705.025n

.meas tran vdout1_255ck1400 FIND v(dout1_255) AT=705.025n

.meas tran vdout1_256ck1400 FIND v(dout1_256) AT=705.025n

.meas tran vdout1_257ck1400 FIND v(dout1_257) AT=705.025n

.meas tran vdout1_258ck1400 FIND v(dout1_258) AT=705.025n

.meas tran vdout1_259ck1400 FIND v(dout1_259) AT=705.025n

.meas tran vdout1_260ck1400 FIND v(dout1_260) AT=705.025n

.meas tran vdout1_261ck1400 FIND v(dout1_261) AT=705.025n

.meas tran vdout1_262ck1400 FIND v(dout1_262) AT=705.025n

.meas tran vdout1_263ck1400 FIND v(dout1_263) AT=705.025n

.meas tran vdout1_264ck1400 FIND v(dout1_264) AT=705.025n

.meas tran vdout1_265ck1400 FIND v(dout1_265) AT=705.025n

.meas tran vdout1_266ck1400 FIND v(dout1_266) AT=705.025n

.meas tran vdout1_267ck1400 FIND v(dout1_267) AT=705.025n

.meas tran vdout1_268ck1400 FIND v(dout1_268) AT=705.025n

.meas tran vdout1_269ck1400 FIND v(dout1_269) AT=705.025n

.meas tran vdout1_270ck1400 FIND v(dout1_270) AT=705.025n

.meas tran vdout1_271ck1400 FIND v(dout1_271) AT=705.025n

.meas tran vdout1_272ck1400 FIND v(dout1_272) AT=705.025n

.meas tran vdout1_273ck1400 FIND v(dout1_273) AT=705.025n

.meas tran vdout1_274ck1400 FIND v(dout1_274) AT=705.025n

.meas tran vdout1_275ck1400 FIND v(dout1_275) AT=705.025n

.meas tran vdout1_276ck1400 FIND v(dout1_276) AT=705.025n

.meas tran vdout1_277ck1400 FIND v(dout1_277) AT=705.025n

.meas tran vdout1_278ck1400 FIND v(dout1_278) AT=705.025n

.meas tran vdout1_279ck1400 FIND v(dout1_279) AT=705.025n

.meas tran vdout1_280ck1400 FIND v(dout1_280) AT=705.025n

.meas tran vdout1_281ck1400 FIND v(dout1_281) AT=705.025n

.meas tran vdout1_282ck1400 FIND v(dout1_282) AT=705.025n

.meas tran vdout1_283ck1400 FIND v(dout1_283) AT=705.025n

.meas tran vdout1_284ck1400 FIND v(dout1_284) AT=705.025n

.meas tran vdout1_285ck1400 FIND v(dout1_285) AT=705.025n

.meas tran vdout1_286ck1400 FIND v(dout1_286) AT=705.025n

.meas tran vdout1_287ck1400 FIND v(dout1_287) AT=705.025n

.meas tran vdout1_288ck1400 FIND v(dout1_288) AT=705.025n

.meas tran vdout1_289ck1400 FIND v(dout1_289) AT=705.025n

.meas tran vdout1_290ck1400 FIND v(dout1_290) AT=705.025n

.meas tran vdout1_291ck1400 FIND v(dout1_291) AT=705.025n

.meas tran vdout1_292ck1400 FIND v(dout1_292) AT=705.025n

.meas tran vdout1_293ck1400 FIND v(dout1_293) AT=705.025n

.meas tran vdout1_294ck1400 FIND v(dout1_294) AT=705.025n

.meas tran vdout1_295ck1400 FIND v(dout1_295) AT=705.025n

.meas tran vdout1_296ck1400 FIND v(dout1_296) AT=705.025n

.meas tran vdout1_297ck1400 FIND v(dout1_297) AT=705.025n

.meas tran vdout1_298ck1400 FIND v(dout1_298) AT=705.025n

.meas tran vdout1_299ck1400 FIND v(dout1_299) AT=705.025n

.meas tran vdout1_300ck1400 FIND v(dout1_300) AT=705.025n

.meas tran vdout1_301ck1400 FIND v(dout1_301) AT=705.025n

.meas tran vdout1_302ck1400 FIND v(dout1_302) AT=705.025n

.meas tran vdout1_303ck1400 FIND v(dout1_303) AT=705.025n

.meas tran vdout1_304ck1400 FIND v(dout1_304) AT=705.025n

.meas tran vdout1_305ck1400 FIND v(dout1_305) AT=705.025n

.meas tran vdout1_306ck1400 FIND v(dout1_306) AT=705.025n

.meas tran vdout1_307ck1400 FIND v(dout1_307) AT=705.025n

.meas tran vdout1_308ck1400 FIND v(dout1_308) AT=705.025n

.meas tran vdout1_309ck1400 FIND v(dout1_309) AT=705.025n

.meas tran vdout1_310ck1400 FIND v(dout1_310) AT=705.025n

.meas tran vdout1_311ck1400 FIND v(dout1_311) AT=705.025n

.meas tran vdout1_312ck1400 FIND v(dout1_312) AT=705.025n

.meas tran vdout1_313ck1400 FIND v(dout1_313) AT=705.025n

.meas tran vdout1_314ck1400 FIND v(dout1_314) AT=705.025n

.meas tran vdout1_315ck1400 FIND v(dout1_315) AT=705.025n

.meas tran vdout1_316ck1400 FIND v(dout1_316) AT=705.025n

.meas tran vdout1_317ck1400 FIND v(dout1_317) AT=705.025n

.meas tran vdout1_318ck1400 FIND v(dout1_318) AT=705.025n

.meas tran vdout1_319ck1400 FIND v(dout1_319) AT=705.025n

.meas tran vdout1_320ck1400 FIND v(dout1_320) AT=705.025n

.meas tran vdout1_321ck1400 FIND v(dout1_321) AT=705.025n

.meas tran vdout1_322ck1400 FIND v(dout1_322) AT=705.025n

.meas tran vdout1_323ck1400 FIND v(dout1_323) AT=705.025n

.meas tran vdout1_324ck1400 FIND v(dout1_324) AT=705.025n

.meas tran vdout1_325ck1400 FIND v(dout1_325) AT=705.025n

.meas tran vdout1_326ck1400 FIND v(dout1_326) AT=705.025n

.meas tran vdout1_327ck1400 FIND v(dout1_327) AT=705.025n

.meas tran vdout1_328ck1400 FIND v(dout1_328) AT=705.025n

.meas tran vdout1_329ck1400 FIND v(dout1_329) AT=705.025n

.meas tran vdout1_330ck1400 FIND v(dout1_330) AT=705.025n

.meas tran vdout1_331ck1400 FIND v(dout1_331) AT=705.025n

.meas tran vdout1_332ck1400 FIND v(dout1_332) AT=705.025n

.meas tran vdout1_333ck1400 FIND v(dout1_333) AT=705.025n

.meas tran vdout1_334ck1400 FIND v(dout1_334) AT=705.025n

.meas tran vdout1_335ck1400 FIND v(dout1_335) AT=705.025n

.meas tran vdout1_336ck1400 FIND v(dout1_336) AT=705.025n

.meas tran vdout1_337ck1400 FIND v(dout1_337) AT=705.025n

.meas tran vdout1_338ck1400 FIND v(dout1_338) AT=705.025n

.meas tran vdout1_339ck1400 FIND v(dout1_339) AT=705.025n

.meas tran vdout1_340ck1400 FIND v(dout1_340) AT=705.025n

.meas tran vdout1_341ck1400 FIND v(dout1_341) AT=705.025n

.meas tran vdout1_342ck1400 FIND v(dout1_342) AT=705.025n

.meas tran vdout1_343ck1400 FIND v(dout1_343) AT=705.025n

.meas tran vdout1_344ck1400 FIND v(dout1_344) AT=705.025n

.meas tran vdout1_345ck1400 FIND v(dout1_345) AT=705.025n

.meas tran vdout1_346ck1400 FIND v(dout1_346) AT=705.025n

.meas tran vdout1_347ck1400 FIND v(dout1_347) AT=705.025n

.meas tran vdout1_348ck1400 FIND v(dout1_348) AT=705.025n

.meas tran vdout1_349ck1400 FIND v(dout1_349) AT=705.025n

.meas tran vdout1_350ck1400 FIND v(dout1_350) AT=705.025n

.meas tran vdout1_351ck1400 FIND v(dout1_351) AT=705.025n

.meas tran vdout1_352ck1400 FIND v(dout1_352) AT=705.025n

.meas tran vdout1_353ck1400 FIND v(dout1_353) AT=705.025n

.meas tran vdout1_354ck1400 FIND v(dout1_354) AT=705.025n

.meas tran vdout1_355ck1400 FIND v(dout1_355) AT=705.025n

.meas tran vdout1_356ck1400 FIND v(dout1_356) AT=705.025n

.meas tran vdout1_357ck1400 FIND v(dout1_357) AT=705.025n

.meas tran vdout1_358ck1400 FIND v(dout1_358) AT=705.025n

.meas tran vdout1_359ck1400 FIND v(dout1_359) AT=705.025n

.meas tran vdout1_360ck1400 FIND v(dout1_360) AT=705.025n

.meas tran vdout1_361ck1400 FIND v(dout1_361) AT=705.025n

.meas tran vdout1_362ck1400 FIND v(dout1_362) AT=705.025n

.meas tran vdout1_363ck1400 FIND v(dout1_363) AT=705.025n

.meas tran vdout1_364ck1400 FIND v(dout1_364) AT=705.025n

.meas tran vdout1_365ck1400 FIND v(dout1_365) AT=705.025n

.meas tran vdout1_366ck1400 FIND v(dout1_366) AT=705.025n

.meas tran vdout1_367ck1400 FIND v(dout1_367) AT=705.025n

.meas tran vdout1_368ck1400 FIND v(dout1_368) AT=705.025n

.meas tran vdout1_369ck1400 FIND v(dout1_369) AT=705.025n

.meas tran vdout1_370ck1400 FIND v(dout1_370) AT=705.025n

.meas tran vdout1_371ck1400 FIND v(dout1_371) AT=705.025n

.meas tran vdout1_372ck1400 FIND v(dout1_372) AT=705.025n

.meas tran vdout1_373ck1400 FIND v(dout1_373) AT=705.025n

.meas tran vdout1_374ck1400 FIND v(dout1_374) AT=705.025n

.meas tran vdout1_375ck1400 FIND v(dout1_375) AT=705.025n

.meas tran vdout1_376ck1400 FIND v(dout1_376) AT=705.025n

.meas tran vdout1_377ck1400 FIND v(dout1_377) AT=705.025n

.meas tran vdout1_378ck1400 FIND v(dout1_378) AT=705.025n

.meas tran vdout1_379ck1400 FIND v(dout1_379) AT=705.025n

.meas tran vdout1_380ck1400 FIND v(dout1_380) AT=705.025n

.meas tran vdout1_381ck1400 FIND v(dout1_381) AT=705.025n

.meas tran vdout1_382ck1400 FIND v(dout1_382) AT=705.025n

.meas tran vdout1_383ck1400 FIND v(dout1_383) AT=705.025n

.meas tran vdout1_384ck1400 FIND v(dout1_384) AT=705.025n

.meas tran vdout1_385ck1400 FIND v(dout1_385) AT=705.025n

.meas tran vdout1_386ck1400 FIND v(dout1_386) AT=705.025n

.meas tran vdout1_387ck1400 FIND v(dout1_387) AT=705.025n

.meas tran vdout1_388ck1400 FIND v(dout1_388) AT=705.025n

.meas tran vdout1_389ck1400 FIND v(dout1_389) AT=705.025n

.meas tran vdout1_390ck1400 FIND v(dout1_390) AT=705.025n

.meas tran vdout1_391ck1400 FIND v(dout1_391) AT=705.025n

.meas tran vdout1_392ck1400 FIND v(dout1_392) AT=705.025n

.meas tran vdout1_393ck1400 FIND v(dout1_393) AT=705.025n

.meas tran vdout1_394ck1400 FIND v(dout1_394) AT=705.025n

.meas tran vdout1_395ck1400 FIND v(dout1_395) AT=705.025n

.meas tran vdout1_396ck1400 FIND v(dout1_396) AT=705.025n

.meas tran vdout1_397ck1400 FIND v(dout1_397) AT=705.025n

.meas tran vdout1_398ck1400 FIND v(dout1_398) AT=705.025n

.meas tran vdout1_399ck1400 FIND v(dout1_399) AT=705.025n

.meas tran vdout1_400ck1400 FIND v(dout1_400) AT=705.025n

.meas tran vdout1_401ck1400 FIND v(dout1_401) AT=705.025n

.meas tran vdout1_402ck1400 FIND v(dout1_402) AT=705.025n

.meas tran vdout1_403ck1400 FIND v(dout1_403) AT=705.025n

.meas tran vdout1_404ck1400 FIND v(dout1_404) AT=705.025n

.meas tran vdout1_405ck1400 FIND v(dout1_405) AT=705.025n

.meas tran vdout1_406ck1400 FIND v(dout1_406) AT=705.025n

.meas tran vdout1_407ck1400 FIND v(dout1_407) AT=705.025n

.meas tran vdout1_408ck1400 FIND v(dout1_408) AT=705.025n

.meas tran vdout1_409ck1400 FIND v(dout1_409) AT=705.025n

.meas tran vdout1_410ck1400 FIND v(dout1_410) AT=705.025n

.meas tran vdout1_411ck1400 FIND v(dout1_411) AT=705.025n

.meas tran vdout1_412ck1400 FIND v(dout1_412) AT=705.025n

.meas tran vdout1_413ck1400 FIND v(dout1_413) AT=705.025n

.meas tran vdout1_414ck1400 FIND v(dout1_414) AT=705.025n

.meas tran vdout1_415ck1400 FIND v(dout1_415) AT=705.025n

.meas tran vdout1_416ck1400 FIND v(dout1_416) AT=705.025n

.meas tran vdout1_417ck1400 FIND v(dout1_417) AT=705.025n

.meas tran vdout1_418ck1400 FIND v(dout1_418) AT=705.025n

.meas tran vdout1_419ck1400 FIND v(dout1_419) AT=705.025n

.meas tran vdout1_420ck1400 FIND v(dout1_420) AT=705.025n

.meas tran vdout1_421ck1400 FIND v(dout1_421) AT=705.025n

.meas tran vdout1_422ck1400 FIND v(dout1_422) AT=705.025n

.meas tran vdout1_423ck1400 FIND v(dout1_423) AT=705.025n

.meas tran vdout1_424ck1400 FIND v(dout1_424) AT=705.025n

.meas tran vdout1_425ck1400 FIND v(dout1_425) AT=705.025n

.meas tran vdout1_426ck1400 FIND v(dout1_426) AT=705.025n

.meas tran vdout1_427ck1400 FIND v(dout1_427) AT=705.025n

.meas tran vdout1_428ck1400 FIND v(dout1_428) AT=705.025n

.meas tran vdout1_429ck1400 FIND v(dout1_429) AT=705.025n

.meas tran vdout1_430ck1400 FIND v(dout1_430) AT=705.025n

.meas tran vdout1_431ck1400 FIND v(dout1_431) AT=705.025n

.meas tran vdout1_432ck1400 FIND v(dout1_432) AT=705.025n

.meas tran vdout1_433ck1400 FIND v(dout1_433) AT=705.025n

.meas tran vdout1_434ck1400 FIND v(dout1_434) AT=705.025n

.meas tran vdout1_435ck1400 FIND v(dout1_435) AT=705.025n

.meas tran vdout1_436ck1400 FIND v(dout1_436) AT=705.025n

.meas tran vdout1_437ck1400 FIND v(dout1_437) AT=705.025n

.meas tran vdout1_438ck1400 FIND v(dout1_438) AT=705.025n

.meas tran vdout1_439ck1400 FIND v(dout1_439) AT=705.025n

.meas tran vdout1_440ck1400 FIND v(dout1_440) AT=705.025n

.meas tran vdout1_441ck1400 FIND v(dout1_441) AT=705.025n

.meas tran vdout1_442ck1400 FIND v(dout1_442) AT=705.025n

.meas tran vdout1_443ck1400 FIND v(dout1_443) AT=705.025n

.meas tran vdout1_444ck1400 FIND v(dout1_444) AT=705.025n

.meas tran vdout1_445ck1400 FIND v(dout1_445) AT=705.025n

.meas tran vdout1_446ck1400 FIND v(dout1_446) AT=705.025n

.meas tran vdout1_447ck1400 FIND v(dout1_447) AT=705.025n

.meas tran vdout1_448ck1400 FIND v(dout1_448) AT=705.025n

.meas tran vdout1_449ck1400 FIND v(dout1_449) AT=705.025n

.meas tran vdout1_450ck1400 FIND v(dout1_450) AT=705.025n

.meas tran vdout1_451ck1400 FIND v(dout1_451) AT=705.025n

.meas tran vdout1_452ck1400 FIND v(dout1_452) AT=705.025n

.meas tran vdout1_453ck1400 FIND v(dout1_453) AT=705.025n

.meas tran vdout1_454ck1400 FIND v(dout1_454) AT=705.025n

.meas tran vdout1_455ck1400 FIND v(dout1_455) AT=705.025n

.meas tran vdout1_456ck1400 FIND v(dout1_456) AT=705.025n

.meas tran vdout1_457ck1400 FIND v(dout1_457) AT=705.025n

.meas tran vdout1_458ck1400 FIND v(dout1_458) AT=705.025n

.meas tran vdout1_459ck1400 FIND v(dout1_459) AT=705.025n

.meas tran vdout1_460ck1400 FIND v(dout1_460) AT=705.025n

.meas tran vdout1_461ck1400 FIND v(dout1_461) AT=705.025n

.meas tran vdout1_462ck1400 FIND v(dout1_462) AT=705.025n

.meas tran vdout1_463ck1400 FIND v(dout1_463) AT=705.025n

.meas tran vdout1_464ck1400 FIND v(dout1_464) AT=705.025n

.meas tran vdout1_465ck1400 FIND v(dout1_465) AT=705.025n

.meas tran vdout1_466ck1400 FIND v(dout1_466) AT=705.025n

.meas tran vdout1_467ck1400 FIND v(dout1_467) AT=705.025n

.meas tran vdout1_468ck1400 FIND v(dout1_468) AT=705.025n

.meas tran vdout1_469ck1400 FIND v(dout1_469) AT=705.025n

.meas tran vdout1_470ck1400 FIND v(dout1_470) AT=705.025n

.meas tran vdout1_471ck1400 FIND v(dout1_471) AT=705.025n

.meas tran vdout1_472ck1400 FIND v(dout1_472) AT=705.025n

.meas tran vdout1_473ck1400 FIND v(dout1_473) AT=705.025n

.meas tran vdout1_474ck1400 FIND v(dout1_474) AT=705.025n

.meas tran vdout1_475ck1400 FIND v(dout1_475) AT=705.025n

.meas tran vdout1_476ck1400 FIND v(dout1_476) AT=705.025n

.meas tran vdout1_477ck1400 FIND v(dout1_477) AT=705.025n

.meas tran vdout1_478ck1400 FIND v(dout1_478) AT=705.025n

.meas tran vdout1_479ck1400 FIND v(dout1_479) AT=705.025n

.meas tran vdout1_480ck1400 FIND v(dout1_480) AT=705.025n

.meas tran vdout1_481ck1400 FIND v(dout1_481) AT=705.025n

.meas tran vdout1_482ck1400 FIND v(dout1_482) AT=705.025n

.meas tran vdout1_483ck1400 FIND v(dout1_483) AT=705.025n

.meas tran vdout1_484ck1400 FIND v(dout1_484) AT=705.025n

.meas tran vdout1_485ck1400 FIND v(dout1_485) AT=705.025n

.meas tran vdout1_486ck1400 FIND v(dout1_486) AT=705.025n

.meas tran vdout1_487ck1400 FIND v(dout1_487) AT=705.025n

.meas tran vdout1_488ck1400 FIND v(dout1_488) AT=705.025n

.meas tran vdout1_489ck1400 FIND v(dout1_489) AT=705.025n

.meas tran vdout1_490ck1400 FIND v(dout1_490) AT=705.025n

.meas tran vdout1_491ck1400 FIND v(dout1_491) AT=705.025n

.meas tran vdout1_492ck1400 FIND v(dout1_492) AT=705.025n

.meas tran vdout1_493ck1400 FIND v(dout1_493) AT=705.025n

.meas tran vdout1_494ck1400 FIND v(dout1_494) AT=705.025n

.meas tran vdout1_495ck1400 FIND v(dout1_495) AT=705.025n

.meas tran vdout1_496ck1400 FIND v(dout1_496) AT=705.025n

.meas tran vdout1_497ck1400 FIND v(dout1_497) AT=705.025n

.meas tran vdout1_498ck1400 FIND v(dout1_498) AT=705.025n

.meas tran vdout1_499ck1400 FIND v(dout1_499) AT=705.025n

.meas tran vdout1_500ck1400 FIND v(dout1_500) AT=705.025n

.meas tran vdout1_501ck1400 FIND v(dout1_501) AT=705.025n

.meas tran vdout1_502ck1400 FIND v(dout1_502) AT=705.025n

.meas tran vdout1_503ck1400 FIND v(dout1_503) AT=705.025n

.meas tran vdout1_504ck1400 FIND v(dout1_504) AT=705.025n

.meas tran vdout1_505ck1400 FIND v(dout1_505) AT=705.025n

.meas tran vdout1_506ck1400 FIND v(dout1_506) AT=705.025n

.meas tran vdout1_507ck1400 FIND v(dout1_507) AT=705.025n

.meas tran vdout1_508ck1400 FIND v(dout1_508) AT=705.025n

.meas tran vdout1_509ck1400 FIND v(dout1_509) AT=705.025n

.meas tran vdout1_510ck1400 FIND v(dout1_510) AT=705.025n

.meas tran vdout1_511ck1400 FIND v(dout1_511) AT=705.025n

.meas tran vdout1_0ck1450 FIND v(dout1_0) AT=730.025n

.meas tran vdout1_1ck1450 FIND v(dout1_1) AT=730.025n

.meas tran vdout1_2ck1450 FIND v(dout1_2) AT=730.025n

.meas tran vdout1_3ck1450 FIND v(dout1_3) AT=730.025n

.meas tran vdout1_4ck1450 FIND v(dout1_4) AT=730.025n

.meas tran vdout1_5ck1450 FIND v(dout1_5) AT=730.025n

.meas tran vdout1_6ck1450 FIND v(dout1_6) AT=730.025n

.meas tran vdout1_7ck1450 FIND v(dout1_7) AT=730.025n

.meas tran vdout1_8ck1450 FIND v(dout1_8) AT=730.025n

.meas tran vdout1_9ck1450 FIND v(dout1_9) AT=730.025n

.meas tran vdout1_10ck1450 FIND v(dout1_10) AT=730.025n

.meas tran vdout1_11ck1450 FIND v(dout1_11) AT=730.025n

.meas tran vdout1_12ck1450 FIND v(dout1_12) AT=730.025n

.meas tran vdout1_13ck1450 FIND v(dout1_13) AT=730.025n

.meas tran vdout1_14ck1450 FIND v(dout1_14) AT=730.025n

.meas tran vdout1_15ck1450 FIND v(dout1_15) AT=730.025n

.meas tran vdout1_16ck1450 FIND v(dout1_16) AT=730.025n

.meas tran vdout1_17ck1450 FIND v(dout1_17) AT=730.025n

.meas tran vdout1_18ck1450 FIND v(dout1_18) AT=730.025n

.meas tran vdout1_19ck1450 FIND v(dout1_19) AT=730.025n

.meas tran vdout1_20ck1450 FIND v(dout1_20) AT=730.025n

.meas tran vdout1_21ck1450 FIND v(dout1_21) AT=730.025n

.meas tran vdout1_22ck1450 FIND v(dout1_22) AT=730.025n

.meas tran vdout1_23ck1450 FIND v(dout1_23) AT=730.025n

.meas tran vdout1_24ck1450 FIND v(dout1_24) AT=730.025n

.meas tran vdout1_25ck1450 FIND v(dout1_25) AT=730.025n

.meas tran vdout1_26ck1450 FIND v(dout1_26) AT=730.025n

.meas tran vdout1_27ck1450 FIND v(dout1_27) AT=730.025n

.meas tran vdout1_28ck1450 FIND v(dout1_28) AT=730.025n

.meas tran vdout1_29ck1450 FIND v(dout1_29) AT=730.025n

.meas tran vdout1_30ck1450 FIND v(dout1_30) AT=730.025n

.meas tran vdout1_31ck1450 FIND v(dout1_31) AT=730.025n

.meas tran vdout1_32ck1450 FIND v(dout1_32) AT=730.025n

.meas tran vdout1_33ck1450 FIND v(dout1_33) AT=730.025n

.meas tran vdout1_34ck1450 FIND v(dout1_34) AT=730.025n

.meas tran vdout1_35ck1450 FIND v(dout1_35) AT=730.025n

.meas tran vdout1_36ck1450 FIND v(dout1_36) AT=730.025n

.meas tran vdout1_37ck1450 FIND v(dout1_37) AT=730.025n

.meas tran vdout1_38ck1450 FIND v(dout1_38) AT=730.025n

.meas tran vdout1_39ck1450 FIND v(dout1_39) AT=730.025n

.meas tran vdout1_40ck1450 FIND v(dout1_40) AT=730.025n

.meas tran vdout1_41ck1450 FIND v(dout1_41) AT=730.025n

.meas tran vdout1_42ck1450 FIND v(dout1_42) AT=730.025n

.meas tran vdout1_43ck1450 FIND v(dout1_43) AT=730.025n

.meas tran vdout1_44ck1450 FIND v(dout1_44) AT=730.025n

.meas tran vdout1_45ck1450 FIND v(dout1_45) AT=730.025n

.meas tran vdout1_46ck1450 FIND v(dout1_46) AT=730.025n

.meas tran vdout1_47ck1450 FIND v(dout1_47) AT=730.025n

.meas tran vdout1_48ck1450 FIND v(dout1_48) AT=730.025n

.meas tran vdout1_49ck1450 FIND v(dout1_49) AT=730.025n

.meas tran vdout1_50ck1450 FIND v(dout1_50) AT=730.025n

.meas tran vdout1_51ck1450 FIND v(dout1_51) AT=730.025n

.meas tran vdout1_52ck1450 FIND v(dout1_52) AT=730.025n

.meas tran vdout1_53ck1450 FIND v(dout1_53) AT=730.025n

.meas tran vdout1_54ck1450 FIND v(dout1_54) AT=730.025n

.meas tran vdout1_55ck1450 FIND v(dout1_55) AT=730.025n

.meas tran vdout1_56ck1450 FIND v(dout1_56) AT=730.025n

.meas tran vdout1_57ck1450 FIND v(dout1_57) AT=730.025n

.meas tran vdout1_58ck1450 FIND v(dout1_58) AT=730.025n

.meas tran vdout1_59ck1450 FIND v(dout1_59) AT=730.025n

.meas tran vdout1_60ck1450 FIND v(dout1_60) AT=730.025n

.meas tran vdout1_61ck1450 FIND v(dout1_61) AT=730.025n

.meas tran vdout1_62ck1450 FIND v(dout1_62) AT=730.025n

.meas tran vdout1_63ck1450 FIND v(dout1_63) AT=730.025n

.meas tran vdout1_64ck1450 FIND v(dout1_64) AT=730.025n

.meas tran vdout1_65ck1450 FIND v(dout1_65) AT=730.025n

.meas tran vdout1_66ck1450 FIND v(dout1_66) AT=730.025n

.meas tran vdout1_67ck1450 FIND v(dout1_67) AT=730.025n

.meas tran vdout1_68ck1450 FIND v(dout1_68) AT=730.025n

.meas tran vdout1_69ck1450 FIND v(dout1_69) AT=730.025n

.meas tran vdout1_70ck1450 FIND v(dout1_70) AT=730.025n

.meas tran vdout1_71ck1450 FIND v(dout1_71) AT=730.025n

.meas tran vdout1_72ck1450 FIND v(dout1_72) AT=730.025n

.meas tran vdout1_73ck1450 FIND v(dout1_73) AT=730.025n

.meas tran vdout1_74ck1450 FIND v(dout1_74) AT=730.025n

.meas tran vdout1_75ck1450 FIND v(dout1_75) AT=730.025n

.meas tran vdout1_76ck1450 FIND v(dout1_76) AT=730.025n

.meas tran vdout1_77ck1450 FIND v(dout1_77) AT=730.025n

.meas tran vdout1_78ck1450 FIND v(dout1_78) AT=730.025n

.meas tran vdout1_79ck1450 FIND v(dout1_79) AT=730.025n

.meas tran vdout1_80ck1450 FIND v(dout1_80) AT=730.025n

.meas tran vdout1_81ck1450 FIND v(dout1_81) AT=730.025n

.meas tran vdout1_82ck1450 FIND v(dout1_82) AT=730.025n

.meas tran vdout1_83ck1450 FIND v(dout1_83) AT=730.025n

.meas tran vdout1_84ck1450 FIND v(dout1_84) AT=730.025n

.meas tran vdout1_85ck1450 FIND v(dout1_85) AT=730.025n

.meas tran vdout1_86ck1450 FIND v(dout1_86) AT=730.025n

.meas tran vdout1_87ck1450 FIND v(dout1_87) AT=730.025n

.meas tran vdout1_88ck1450 FIND v(dout1_88) AT=730.025n

.meas tran vdout1_89ck1450 FIND v(dout1_89) AT=730.025n

.meas tran vdout1_90ck1450 FIND v(dout1_90) AT=730.025n

.meas tran vdout1_91ck1450 FIND v(dout1_91) AT=730.025n

.meas tran vdout1_92ck1450 FIND v(dout1_92) AT=730.025n

.meas tran vdout1_93ck1450 FIND v(dout1_93) AT=730.025n

.meas tran vdout1_94ck1450 FIND v(dout1_94) AT=730.025n

.meas tran vdout1_95ck1450 FIND v(dout1_95) AT=730.025n

.meas tran vdout1_96ck1450 FIND v(dout1_96) AT=730.025n

.meas tran vdout1_97ck1450 FIND v(dout1_97) AT=730.025n

.meas tran vdout1_98ck1450 FIND v(dout1_98) AT=730.025n

.meas tran vdout1_99ck1450 FIND v(dout1_99) AT=730.025n

.meas tran vdout1_100ck1450 FIND v(dout1_100) AT=730.025n

.meas tran vdout1_101ck1450 FIND v(dout1_101) AT=730.025n

.meas tran vdout1_102ck1450 FIND v(dout1_102) AT=730.025n

.meas tran vdout1_103ck1450 FIND v(dout1_103) AT=730.025n

.meas tran vdout1_104ck1450 FIND v(dout1_104) AT=730.025n

.meas tran vdout1_105ck1450 FIND v(dout1_105) AT=730.025n

.meas tran vdout1_106ck1450 FIND v(dout1_106) AT=730.025n

.meas tran vdout1_107ck1450 FIND v(dout1_107) AT=730.025n

.meas tran vdout1_108ck1450 FIND v(dout1_108) AT=730.025n

.meas tran vdout1_109ck1450 FIND v(dout1_109) AT=730.025n

.meas tran vdout1_110ck1450 FIND v(dout1_110) AT=730.025n

.meas tran vdout1_111ck1450 FIND v(dout1_111) AT=730.025n

.meas tran vdout1_112ck1450 FIND v(dout1_112) AT=730.025n

.meas tran vdout1_113ck1450 FIND v(dout1_113) AT=730.025n

.meas tran vdout1_114ck1450 FIND v(dout1_114) AT=730.025n

.meas tran vdout1_115ck1450 FIND v(dout1_115) AT=730.025n

.meas tran vdout1_116ck1450 FIND v(dout1_116) AT=730.025n

.meas tran vdout1_117ck1450 FIND v(dout1_117) AT=730.025n

.meas tran vdout1_118ck1450 FIND v(dout1_118) AT=730.025n

.meas tran vdout1_119ck1450 FIND v(dout1_119) AT=730.025n

.meas tran vdout1_120ck1450 FIND v(dout1_120) AT=730.025n

.meas tran vdout1_121ck1450 FIND v(dout1_121) AT=730.025n

.meas tran vdout1_122ck1450 FIND v(dout1_122) AT=730.025n

.meas tran vdout1_123ck1450 FIND v(dout1_123) AT=730.025n

.meas tran vdout1_124ck1450 FIND v(dout1_124) AT=730.025n

.meas tran vdout1_125ck1450 FIND v(dout1_125) AT=730.025n

.meas tran vdout1_126ck1450 FIND v(dout1_126) AT=730.025n

.meas tran vdout1_127ck1450 FIND v(dout1_127) AT=730.025n

.meas tran vdout1_128ck1450 FIND v(dout1_128) AT=730.025n

.meas tran vdout1_129ck1450 FIND v(dout1_129) AT=730.025n

.meas tran vdout1_130ck1450 FIND v(dout1_130) AT=730.025n

.meas tran vdout1_131ck1450 FIND v(dout1_131) AT=730.025n

.meas tran vdout1_132ck1450 FIND v(dout1_132) AT=730.025n

.meas tran vdout1_133ck1450 FIND v(dout1_133) AT=730.025n

.meas tran vdout1_134ck1450 FIND v(dout1_134) AT=730.025n

.meas tran vdout1_135ck1450 FIND v(dout1_135) AT=730.025n

.meas tran vdout1_136ck1450 FIND v(dout1_136) AT=730.025n

.meas tran vdout1_137ck1450 FIND v(dout1_137) AT=730.025n

.meas tran vdout1_138ck1450 FIND v(dout1_138) AT=730.025n

.meas tran vdout1_139ck1450 FIND v(dout1_139) AT=730.025n

.meas tran vdout1_140ck1450 FIND v(dout1_140) AT=730.025n

.meas tran vdout1_141ck1450 FIND v(dout1_141) AT=730.025n

.meas tran vdout1_142ck1450 FIND v(dout1_142) AT=730.025n

.meas tran vdout1_143ck1450 FIND v(dout1_143) AT=730.025n

.meas tran vdout1_144ck1450 FIND v(dout1_144) AT=730.025n

.meas tran vdout1_145ck1450 FIND v(dout1_145) AT=730.025n

.meas tran vdout1_146ck1450 FIND v(dout1_146) AT=730.025n

.meas tran vdout1_147ck1450 FIND v(dout1_147) AT=730.025n

.meas tran vdout1_148ck1450 FIND v(dout1_148) AT=730.025n

.meas tran vdout1_149ck1450 FIND v(dout1_149) AT=730.025n

.meas tran vdout1_150ck1450 FIND v(dout1_150) AT=730.025n

.meas tran vdout1_151ck1450 FIND v(dout1_151) AT=730.025n

.meas tran vdout1_152ck1450 FIND v(dout1_152) AT=730.025n

.meas tran vdout1_153ck1450 FIND v(dout1_153) AT=730.025n

.meas tran vdout1_154ck1450 FIND v(dout1_154) AT=730.025n

.meas tran vdout1_155ck1450 FIND v(dout1_155) AT=730.025n

.meas tran vdout1_156ck1450 FIND v(dout1_156) AT=730.025n

.meas tran vdout1_157ck1450 FIND v(dout1_157) AT=730.025n

.meas tran vdout1_158ck1450 FIND v(dout1_158) AT=730.025n

.meas tran vdout1_159ck1450 FIND v(dout1_159) AT=730.025n

.meas tran vdout1_160ck1450 FIND v(dout1_160) AT=730.025n

.meas tran vdout1_161ck1450 FIND v(dout1_161) AT=730.025n

.meas tran vdout1_162ck1450 FIND v(dout1_162) AT=730.025n

.meas tran vdout1_163ck1450 FIND v(dout1_163) AT=730.025n

.meas tran vdout1_164ck1450 FIND v(dout1_164) AT=730.025n

.meas tran vdout1_165ck1450 FIND v(dout1_165) AT=730.025n

.meas tran vdout1_166ck1450 FIND v(dout1_166) AT=730.025n

.meas tran vdout1_167ck1450 FIND v(dout1_167) AT=730.025n

.meas tran vdout1_168ck1450 FIND v(dout1_168) AT=730.025n

.meas tran vdout1_169ck1450 FIND v(dout1_169) AT=730.025n

.meas tran vdout1_170ck1450 FIND v(dout1_170) AT=730.025n

.meas tran vdout1_171ck1450 FIND v(dout1_171) AT=730.025n

.meas tran vdout1_172ck1450 FIND v(dout1_172) AT=730.025n

.meas tran vdout1_173ck1450 FIND v(dout1_173) AT=730.025n

.meas tran vdout1_174ck1450 FIND v(dout1_174) AT=730.025n

.meas tran vdout1_175ck1450 FIND v(dout1_175) AT=730.025n

.meas tran vdout1_176ck1450 FIND v(dout1_176) AT=730.025n

.meas tran vdout1_177ck1450 FIND v(dout1_177) AT=730.025n

.meas tran vdout1_178ck1450 FIND v(dout1_178) AT=730.025n

.meas tran vdout1_179ck1450 FIND v(dout1_179) AT=730.025n

.meas tran vdout1_180ck1450 FIND v(dout1_180) AT=730.025n

.meas tran vdout1_181ck1450 FIND v(dout1_181) AT=730.025n

.meas tran vdout1_182ck1450 FIND v(dout1_182) AT=730.025n

.meas tran vdout1_183ck1450 FIND v(dout1_183) AT=730.025n

.meas tran vdout1_184ck1450 FIND v(dout1_184) AT=730.025n

.meas tran vdout1_185ck1450 FIND v(dout1_185) AT=730.025n

.meas tran vdout1_186ck1450 FIND v(dout1_186) AT=730.025n

.meas tran vdout1_187ck1450 FIND v(dout1_187) AT=730.025n

.meas tran vdout1_188ck1450 FIND v(dout1_188) AT=730.025n

.meas tran vdout1_189ck1450 FIND v(dout1_189) AT=730.025n

.meas tran vdout1_190ck1450 FIND v(dout1_190) AT=730.025n

.meas tran vdout1_191ck1450 FIND v(dout1_191) AT=730.025n

.meas tran vdout1_192ck1450 FIND v(dout1_192) AT=730.025n

.meas tran vdout1_193ck1450 FIND v(dout1_193) AT=730.025n

.meas tran vdout1_194ck1450 FIND v(dout1_194) AT=730.025n

.meas tran vdout1_195ck1450 FIND v(dout1_195) AT=730.025n

.meas tran vdout1_196ck1450 FIND v(dout1_196) AT=730.025n

.meas tran vdout1_197ck1450 FIND v(dout1_197) AT=730.025n

.meas tran vdout1_198ck1450 FIND v(dout1_198) AT=730.025n

.meas tran vdout1_199ck1450 FIND v(dout1_199) AT=730.025n

.meas tran vdout1_200ck1450 FIND v(dout1_200) AT=730.025n

.meas tran vdout1_201ck1450 FIND v(dout1_201) AT=730.025n

.meas tran vdout1_202ck1450 FIND v(dout1_202) AT=730.025n

.meas tran vdout1_203ck1450 FIND v(dout1_203) AT=730.025n

.meas tran vdout1_204ck1450 FIND v(dout1_204) AT=730.025n

.meas tran vdout1_205ck1450 FIND v(dout1_205) AT=730.025n

.meas tran vdout1_206ck1450 FIND v(dout1_206) AT=730.025n

.meas tran vdout1_207ck1450 FIND v(dout1_207) AT=730.025n

.meas tran vdout1_208ck1450 FIND v(dout1_208) AT=730.025n

.meas tran vdout1_209ck1450 FIND v(dout1_209) AT=730.025n

.meas tran vdout1_210ck1450 FIND v(dout1_210) AT=730.025n

.meas tran vdout1_211ck1450 FIND v(dout1_211) AT=730.025n

.meas tran vdout1_212ck1450 FIND v(dout1_212) AT=730.025n

.meas tran vdout1_213ck1450 FIND v(dout1_213) AT=730.025n

.meas tran vdout1_214ck1450 FIND v(dout1_214) AT=730.025n

.meas tran vdout1_215ck1450 FIND v(dout1_215) AT=730.025n

.meas tran vdout1_216ck1450 FIND v(dout1_216) AT=730.025n

.meas tran vdout1_217ck1450 FIND v(dout1_217) AT=730.025n

.meas tran vdout1_218ck1450 FIND v(dout1_218) AT=730.025n

.meas tran vdout1_219ck1450 FIND v(dout1_219) AT=730.025n

.meas tran vdout1_220ck1450 FIND v(dout1_220) AT=730.025n

.meas tran vdout1_221ck1450 FIND v(dout1_221) AT=730.025n

.meas tran vdout1_222ck1450 FIND v(dout1_222) AT=730.025n

.meas tran vdout1_223ck1450 FIND v(dout1_223) AT=730.025n

.meas tran vdout1_224ck1450 FIND v(dout1_224) AT=730.025n

.meas tran vdout1_225ck1450 FIND v(dout1_225) AT=730.025n

.meas tran vdout1_226ck1450 FIND v(dout1_226) AT=730.025n

.meas tran vdout1_227ck1450 FIND v(dout1_227) AT=730.025n

.meas tran vdout1_228ck1450 FIND v(dout1_228) AT=730.025n

.meas tran vdout1_229ck1450 FIND v(dout1_229) AT=730.025n

.meas tran vdout1_230ck1450 FIND v(dout1_230) AT=730.025n

.meas tran vdout1_231ck1450 FIND v(dout1_231) AT=730.025n

.meas tran vdout1_232ck1450 FIND v(dout1_232) AT=730.025n

.meas tran vdout1_233ck1450 FIND v(dout1_233) AT=730.025n

.meas tran vdout1_234ck1450 FIND v(dout1_234) AT=730.025n

.meas tran vdout1_235ck1450 FIND v(dout1_235) AT=730.025n

.meas tran vdout1_236ck1450 FIND v(dout1_236) AT=730.025n

.meas tran vdout1_237ck1450 FIND v(dout1_237) AT=730.025n

.meas tran vdout1_238ck1450 FIND v(dout1_238) AT=730.025n

.meas tran vdout1_239ck1450 FIND v(dout1_239) AT=730.025n

.meas tran vdout1_240ck1450 FIND v(dout1_240) AT=730.025n

.meas tran vdout1_241ck1450 FIND v(dout1_241) AT=730.025n

.meas tran vdout1_242ck1450 FIND v(dout1_242) AT=730.025n

.meas tran vdout1_243ck1450 FIND v(dout1_243) AT=730.025n

.meas tran vdout1_244ck1450 FIND v(dout1_244) AT=730.025n

.meas tran vdout1_245ck1450 FIND v(dout1_245) AT=730.025n

.meas tran vdout1_246ck1450 FIND v(dout1_246) AT=730.025n

.meas tran vdout1_247ck1450 FIND v(dout1_247) AT=730.025n

.meas tran vdout1_248ck1450 FIND v(dout1_248) AT=730.025n

.meas tran vdout1_249ck1450 FIND v(dout1_249) AT=730.025n

.meas tran vdout1_250ck1450 FIND v(dout1_250) AT=730.025n

.meas tran vdout1_251ck1450 FIND v(dout1_251) AT=730.025n

.meas tran vdout1_252ck1450 FIND v(dout1_252) AT=730.025n

.meas tran vdout1_253ck1450 FIND v(dout1_253) AT=730.025n

.meas tran vdout1_254ck1450 FIND v(dout1_254) AT=730.025n

.meas tran vdout1_255ck1450 FIND v(dout1_255) AT=730.025n

.meas tran vdout1_256ck1450 FIND v(dout1_256) AT=730.025n

.meas tran vdout1_257ck1450 FIND v(dout1_257) AT=730.025n

.meas tran vdout1_258ck1450 FIND v(dout1_258) AT=730.025n

.meas tran vdout1_259ck1450 FIND v(dout1_259) AT=730.025n

.meas tran vdout1_260ck1450 FIND v(dout1_260) AT=730.025n

.meas tran vdout1_261ck1450 FIND v(dout1_261) AT=730.025n

.meas tran vdout1_262ck1450 FIND v(dout1_262) AT=730.025n

.meas tran vdout1_263ck1450 FIND v(dout1_263) AT=730.025n

.meas tran vdout1_264ck1450 FIND v(dout1_264) AT=730.025n

.meas tran vdout1_265ck1450 FIND v(dout1_265) AT=730.025n

.meas tran vdout1_266ck1450 FIND v(dout1_266) AT=730.025n

.meas tran vdout1_267ck1450 FIND v(dout1_267) AT=730.025n

.meas tran vdout1_268ck1450 FIND v(dout1_268) AT=730.025n

.meas tran vdout1_269ck1450 FIND v(dout1_269) AT=730.025n

.meas tran vdout1_270ck1450 FIND v(dout1_270) AT=730.025n

.meas tran vdout1_271ck1450 FIND v(dout1_271) AT=730.025n

.meas tran vdout1_272ck1450 FIND v(dout1_272) AT=730.025n

.meas tran vdout1_273ck1450 FIND v(dout1_273) AT=730.025n

.meas tran vdout1_274ck1450 FIND v(dout1_274) AT=730.025n

.meas tran vdout1_275ck1450 FIND v(dout1_275) AT=730.025n

.meas tran vdout1_276ck1450 FIND v(dout1_276) AT=730.025n

.meas tran vdout1_277ck1450 FIND v(dout1_277) AT=730.025n

.meas tran vdout1_278ck1450 FIND v(dout1_278) AT=730.025n

.meas tran vdout1_279ck1450 FIND v(dout1_279) AT=730.025n

.meas tran vdout1_280ck1450 FIND v(dout1_280) AT=730.025n

.meas tran vdout1_281ck1450 FIND v(dout1_281) AT=730.025n

.meas tran vdout1_282ck1450 FIND v(dout1_282) AT=730.025n

.meas tran vdout1_283ck1450 FIND v(dout1_283) AT=730.025n

.meas tran vdout1_284ck1450 FIND v(dout1_284) AT=730.025n

.meas tran vdout1_285ck1450 FIND v(dout1_285) AT=730.025n

.meas tran vdout1_286ck1450 FIND v(dout1_286) AT=730.025n

.meas tran vdout1_287ck1450 FIND v(dout1_287) AT=730.025n

.meas tran vdout1_288ck1450 FIND v(dout1_288) AT=730.025n

.meas tran vdout1_289ck1450 FIND v(dout1_289) AT=730.025n

.meas tran vdout1_290ck1450 FIND v(dout1_290) AT=730.025n

.meas tran vdout1_291ck1450 FIND v(dout1_291) AT=730.025n

.meas tran vdout1_292ck1450 FIND v(dout1_292) AT=730.025n

.meas tran vdout1_293ck1450 FIND v(dout1_293) AT=730.025n

.meas tran vdout1_294ck1450 FIND v(dout1_294) AT=730.025n

.meas tran vdout1_295ck1450 FIND v(dout1_295) AT=730.025n

.meas tran vdout1_296ck1450 FIND v(dout1_296) AT=730.025n

.meas tran vdout1_297ck1450 FIND v(dout1_297) AT=730.025n

.meas tran vdout1_298ck1450 FIND v(dout1_298) AT=730.025n

.meas tran vdout1_299ck1450 FIND v(dout1_299) AT=730.025n

.meas tran vdout1_300ck1450 FIND v(dout1_300) AT=730.025n

.meas tran vdout1_301ck1450 FIND v(dout1_301) AT=730.025n

.meas tran vdout1_302ck1450 FIND v(dout1_302) AT=730.025n

.meas tran vdout1_303ck1450 FIND v(dout1_303) AT=730.025n

.meas tran vdout1_304ck1450 FIND v(dout1_304) AT=730.025n

.meas tran vdout1_305ck1450 FIND v(dout1_305) AT=730.025n

.meas tran vdout1_306ck1450 FIND v(dout1_306) AT=730.025n

.meas tran vdout1_307ck1450 FIND v(dout1_307) AT=730.025n

.meas tran vdout1_308ck1450 FIND v(dout1_308) AT=730.025n

.meas tran vdout1_309ck1450 FIND v(dout1_309) AT=730.025n

.meas tran vdout1_310ck1450 FIND v(dout1_310) AT=730.025n

.meas tran vdout1_311ck1450 FIND v(dout1_311) AT=730.025n

.meas tran vdout1_312ck1450 FIND v(dout1_312) AT=730.025n

.meas tran vdout1_313ck1450 FIND v(dout1_313) AT=730.025n

.meas tran vdout1_314ck1450 FIND v(dout1_314) AT=730.025n

.meas tran vdout1_315ck1450 FIND v(dout1_315) AT=730.025n

.meas tran vdout1_316ck1450 FIND v(dout1_316) AT=730.025n

.meas tran vdout1_317ck1450 FIND v(dout1_317) AT=730.025n

.meas tran vdout1_318ck1450 FIND v(dout1_318) AT=730.025n

.meas tran vdout1_319ck1450 FIND v(dout1_319) AT=730.025n

.meas tran vdout1_320ck1450 FIND v(dout1_320) AT=730.025n

.meas tran vdout1_321ck1450 FIND v(dout1_321) AT=730.025n

.meas tran vdout1_322ck1450 FIND v(dout1_322) AT=730.025n

.meas tran vdout1_323ck1450 FIND v(dout1_323) AT=730.025n

.meas tran vdout1_324ck1450 FIND v(dout1_324) AT=730.025n

.meas tran vdout1_325ck1450 FIND v(dout1_325) AT=730.025n

.meas tran vdout1_326ck1450 FIND v(dout1_326) AT=730.025n

.meas tran vdout1_327ck1450 FIND v(dout1_327) AT=730.025n

.meas tran vdout1_328ck1450 FIND v(dout1_328) AT=730.025n

.meas tran vdout1_329ck1450 FIND v(dout1_329) AT=730.025n

.meas tran vdout1_330ck1450 FIND v(dout1_330) AT=730.025n

.meas tran vdout1_331ck1450 FIND v(dout1_331) AT=730.025n

.meas tran vdout1_332ck1450 FIND v(dout1_332) AT=730.025n

.meas tran vdout1_333ck1450 FIND v(dout1_333) AT=730.025n

.meas tran vdout1_334ck1450 FIND v(dout1_334) AT=730.025n

.meas tran vdout1_335ck1450 FIND v(dout1_335) AT=730.025n

.meas tran vdout1_336ck1450 FIND v(dout1_336) AT=730.025n

.meas tran vdout1_337ck1450 FIND v(dout1_337) AT=730.025n

.meas tran vdout1_338ck1450 FIND v(dout1_338) AT=730.025n

.meas tran vdout1_339ck1450 FIND v(dout1_339) AT=730.025n

.meas tran vdout1_340ck1450 FIND v(dout1_340) AT=730.025n

.meas tran vdout1_341ck1450 FIND v(dout1_341) AT=730.025n

.meas tran vdout1_342ck1450 FIND v(dout1_342) AT=730.025n

.meas tran vdout1_343ck1450 FIND v(dout1_343) AT=730.025n

.meas tran vdout1_344ck1450 FIND v(dout1_344) AT=730.025n

.meas tran vdout1_345ck1450 FIND v(dout1_345) AT=730.025n

.meas tran vdout1_346ck1450 FIND v(dout1_346) AT=730.025n

.meas tran vdout1_347ck1450 FIND v(dout1_347) AT=730.025n

.meas tran vdout1_348ck1450 FIND v(dout1_348) AT=730.025n

.meas tran vdout1_349ck1450 FIND v(dout1_349) AT=730.025n

.meas tran vdout1_350ck1450 FIND v(dout1_350) AT=730.025n

.meas tran vdout1_351ck1450 FIND v(dout1_351) AT=730.025n

.meas tran vdout1_352ck1450 FIND v(dout1_352) AT=730.025n

.meas tran vdout1_353ck1450 FIND v(dout1_353) AT=730.025n

.meas tran vdout1_354ck1450 FIND v(dout1_354) AT=730.025n

.meas tran vdout1_355ck1450 FIND v(dout1_355) AT=730.025n

.meas tran vdout1_356ck1450 FIND v(dout1_356) AT=730.025n

.meas tran vdout1_357ck1450 FIND v(dout1_357) AT=730.025n

.meas tran vdout1_358ck1450 FIND v(dout1_358) AT=730.025n

.meas tran vdout1_359ck1450 FIND v(dout1_359) AT=730.025n

.meas tran vdout1_360ck1450 FIND v(dout1_360) AT=730.025n

.meas tran vdout1_361ck1450 FIND v(dout1_361) AT=730.025n

.meas tran vdout1_362ck1450 FIND v(dout1_362) AT=730.025n

.meas tran vdout1_363ck1450 FIND v(dout1_363) AT=730.025n

.meas tran vdout1_364ck1450 FIND v(dout1_364) AT=730.025n

.meas tran vdout1_365ck1450 FIND v(dout1_365) AT=730.025n

.meas tran vdout1_366ck1450 FIND v(dout1_366) AT=730.025n

.meas tran vdout1_367ck1450 FIND v(dout1_367) AT=730.025n

.meas tran vdout1_368ck1450 FIND v(dout1_368) AT=730.025n

.meas tran vdout1_369ck1450 FIND v(dout1_369) AT=730.025n

.meas tran vdout1_370ck1450 FIND v(dout1_370) AT=730.025n

.meas tran vdout1_371ck1450 FIND v(dout1_371) AT=730.025n

.meas tran vdout1_372ck1450 FIND v(dout1_372) AT=730.025n

.meas tran vdout1_373ck1450 FIND v(dout1_373) AT=730.025n

.meas tran vdout1_374ck1450 FIND v(dout1_374) AT=730.025n

.meas tran vdout1_375ck1450 FIND v(dout1_375) AT=730.025n

.meas tran vdout1_376ck1450 FIND v(dout1_376) AT=730.025n

.meas tran vdout1_377ck1450 FIND v(dout1_377) AT=730.025n

.meas tran vdout1_378ck1450 FIND v(dout1_378) AT=730.025n

.meas tran vdout1_379ck1450 FIND v(dout1_379) AT=730.025n

.meas tran vdout1_380ck1450 FIND v(dout1_380) AT=730.025n

.meas tran vdout1_381ck1450 FIND v(dout1_381) AT=730.025n

.meas tran vdout1_382ck1450 FIND v(dout1_382) AT=730.025n

.meas tran vdout1_383ck1450 FIND v(dout1_383) AT=730.025n

.meas tran vdout1_384ck1450 FIND v(dout1_384) AT=730.025n

.meas tran vdout1_385ck1450 FIND v(dout1_385) AT=730.025n

.meas tran vdout1_386ck1450 FIND v(dout1_386) AT=730.025n

.meas tran vdout1_387ck1450 FIND v(dout1_387) AT=730.025n

.meas tran vdout1_388ck1450 FIND v(dout1_388) AT=730.025n

.meas tran vdout1_389ck1450 FIND v(dout1_389) AT=730.025n

.meas tran vdout1_390ck1450 FIND v(dout1_390) AT=730.025n

.meas tran vdout1_391ck1450 FIND v(dout1_391) AT=730.025n

.meas tran vdout1_392ck1450 FIND v(dout1_392) AT=730.025n

.meas tran vdout1_393ck1450 FIND v(dout1_393) AT=730.025n

.meas tran vdout1_394ck1450 FIND v(dout1_394) AT=730.025n

.meas tran vdout1_395ck1450 FIND v(dout1_395) AT=730.025n

.meas tran vdout1_396ck1450 FIND v(dout1_396) AT=730.025n

.meas tran vdout1_397ck1450 FIND v(dout1_397) AT=730.025n

.meas tran vdout1_398ck1450 FIND v(dout1_398) AT=730.025n

.meas tran vdout1_399ck1450 FIND v(dout1_399) AT=730.025n

.meas tran vdout1_400ck1450 FIND v(dout1_400) AT=730.025n

.meas tran vdout1_401ck1450 FIND v(dout1_401) AT=730.025n

.meas tran vdout1_402ck1450 FIND v(dout1_402) AT=730.025n

.meas tran vdout1_403ck1450 FIND v(dout1_403) AT=730.025n

.meas tran vdout1_404ck1450 FIND v(dout1_404) AT=730.025n

.meas tran vdout1_405ck1450 FIND v(dout1_405) AT=730.025n

.meas tran vdout1_406ck1450 FIND v(dout1_406) AT=730.025n

.meas tran vdout1_407ck1450 FIND v(dout1_407) AT=730.025n

.meas tran vdout1_408ck1450 FIND v(dout1_408) AT=730.025n

.meas tran vdout1_409ck1450 FIND v(dout1_409) AT=730.025n

.meas tran vdout1_410ck1450 FIND v(dout1_410) AT=730.025n

.meas tran vdout1_411ck1450 FIND v(dout1_411) AT=730.025n

.meas tran vdout1_412ck1450 FIND v(dout1_412) AT=730.025n

.meas tran vdout1_413ck1450 FIND v(dout1_413) AT=730.025n

.meas tran vdout1_414ck1450 FIND v(dout1_414) AT=730.025n

.meas tran vdout1_415ck1450 FIND v(dout1_415) AT=730.025n

.meas tran vdout1_416ck1450 FIND v(dout1_416) AT=730.025n

.meas tran vdout1_417ck1450 FIND v(dout1_417) AT=730.025n

.meas tran vdout1_418ck1450 FIND v(dout1_418) AT=730.025n

.meas tran vdout1_419ck1450 FIND v(dout1_419) AT=730.025n

.meas tran vdout1_420ck1450 FIND v(dout1_420) AT=730.025n

.meas tran vdout1_421ck1450 FIND v(dout1_421) AT=730.025n

.meas tran vdout1_422ck1450 FIND v(dout1_422) AT=730.025n

.meas tran vdout1_423ck1450 FIND v(dout1_423) AT=730.025n

.meas tran vdout1_424ck1450 FIND v(dout1_424) AT=730.025n

.meas tran vdout1_425ck1450 FIND v(dout1_425) AT=730.025n

.meas tran vdout1_426ck1450 FIND v(dout1_426) AT=730.025n

.meas tran vdout1_427ck1450 FIND v(dout1_427) AT=730.025n

.meas tran vdout1_428ck1450 FIND v(dout1_428) AT=730.025n

.meas tran vdout1_429ck1450 FIND v(dout1_429) AT=730.025n

.meas tran vdout1_430ck1450 FIND v(dout1_430) AT=730.025n

.meas tran vdout1_431ck1450 FIND v(dout1_431) AT=730.025n

.meas tran vdout1_432ck1450 FIND v(dout1_432) AT=730.025n

.meas tran vdout1_433ck1450 FIND v(dout1_433) AT=730.025n

.meas tran vdout1_434ck1450 FIND v(dout1_434) AT=730.025n

.meas tran vdout1_435ck1450 FIND v(dout1_435) AT=730.025n

.meas tran vdout1_436ck1450 FIND v(dout1_436) AT=730.025n

.meas tran vdout1_437ck1450 FIND v(dout1_437) AT=730.025n

.meas tran vdout1_438ck1450 FIND v(dout1_438) AT=730.025n

.meas tran vdout1_439ck1450 FIND v(dout1_439) AT=730.025n

.meas tran vdout1_440ck1450 FIND v(dout1_440) AT=730.025n

.meas tran vdout1_441ck1450 FIND v(dout1_441) AT=730.025n

.meas tran vdout1_442ck1450 FIND v(dout1_442) AT=730.025n

.meas tran vdout1_443ck1450 FIND v(dout1_443) AT=730.025n

.meas tran vdout1_444ck1450 FIND v(dout1_444) AT=730.025n

.meas tran vdout1_445ck1450 FIND v(dout1_445) AT=730.025n

.meas tran vdout1_446ck1450 FIND v(dout1_446) AT=730.025n

.meas tran vdout1_447ck1450 FIND v(dout1_447) AT=730.025n

.meas tran vdout1_448ck1450 FIND v(dout1_448) AT=730.025n

.meas tran vdout1_449ck1450 FIND v(dout1_449) AT=730.025n

.meas tran vdout1_450ck1450 FIND v(dout1_450) AT=730.025n

.meas tran vdout1_451ck1450 FIND v(dout1_451) AT=730.025n

.meas tran vdout1_452ck1450 FIND v(dout1_452) AT=730.025n

.meas tran vdout1_453ck1450 FIND v(dout1_453) AT=730.025n

.meas tran vdout1_454ck1450 FIND v(dout1_454) AT=730.025n

.meas tran vdout1_455ck1450 FIND v(dout1_455) AT=730.025n

.meas tran vdout1_456ck1450 FIND v(dout1_456) AT=730.025n

.meas tran vdout1_457ck1450 FIND v(dout1_457) AT=730.025n

.meas tran vdout1_458ck1450 FIND v(dout1_458) AT=730.025n

.meas tran vdout1_459ck1450 FIND v(dout1_459) AT=730.025n

.meas tran vdout1_460ck1450 FIND v(dout1_460) AT=730.025n

.meas tran vdout1_461ck1450 FIND v(dout1_461) AT=730.025n

.meas tran vdout1_462ck1450 FIND v(dout1_462) AT=730.025n

.meas tran vdout1_463ck1450 FIND v(dout1_463) AT=730.025n

.meas tran vdout1_464ck1450 FIND v(dout1_464) AT=730.025n

.meas tran vdout1_465ck1450 FIND v(dout1_465) AT=730.025n

.meas tran vdout1_466ck1450 FIND v(dout1_466) AT=730.025n

.meas tran vdout1_467ck1450 FIND v(dout1_467) AT=730.025n

.meas tran vdout1_468ck1450 FIND v(dout1_468) AT=730.025n

.meas tran vdout1_469ck1450 FIND v(dout1_469) AT=730.025n

.meas tran vdout1_470ck1450 FIND v(dout1_470) AT=730.025n

.meas tran vdout1_471ck1450 FIND v(dout1_471) AT=730.025n

.meas tran vdout1_472ck1450 FIND v(dout1_472) AT=730.025n

.meas tran vdout1_473ck1450 FIND v(dout1_473) AT=730.025n

.meas tran vdout1_474ck1450 FIND v(dout1_474) AT=730.025n

.meas tran vdout1_475ck1450 FIND v(dout1_475) AT=730.025n

.meas tran vdout1_476ck1450 FIND v(dout1_476) AT=730.025n

.meas tran vdout1_477ck1450 FIND v(dout1_477) AT=730.025n

.meas tran vdout1_478ck1450 FIND v(dout1_478) AT=730.025n

.meas tran vdout1_479ck1450 FIND v(dout1_479) AT=730.025n

.meas tran vdout1_480ck1450 FIND v(dout1_480) AT=730.025n

.meas tran vdout1_481ck1450 FIND v(dout1_481) AT=730.025n

.meas tran vdout1_482ck1450 FIND v(dout1_482) AT=730.025n

.meas tran vdout1_483ck1450 FIND v(dout1_483) AT=730.025n

.meas tran vdout1_484ck1450 FIND v(dout1_484) AT=730.025n

.meas tran vdout1_485ck1450 FIND v(dout1_485) AT=730.025n

.meas tran vdout1_486ck1450 FIND v(dout1_486) AT=730.025n

.meas tran vdout1_487ck1450 FIND v(dout1_487) AT=730.025n

.meas tran vdout1_488ck1450 FIND v(dout1_488) AT=730.025n

.meas tran vdout1_489ck1450 FIND v(dout1_489) AT=730.025n

.meas tran vdout1_490ck1450 FIND v(dout1_490) AT=730.025n

.meas tran vdout1_491ck1450 FIND v(dout1_491) AT=730.025n

.meas tran vdout1_492ck1450 FIND v(dout1_492) AT=730.025n

.meas tran vdout1_493ck1450 FIND v(dout1_493) AT=730.025n

.meas tran vdout1_494ck1450 FIND v(dout1_494) AT=730.025n

.meas tran vdout1_495ck1450 FIND v(dout1_495) AT=730.025n

.meas tran vdout1_496ck1450 FIND v(dout1_496) AT=730.025n

.meas tran vdout1_497ck1450 FIND v(dout1_497) AT=730.025n

.meas tran vdout1_498ck1450 FIND v(dout1_498) AT=730.025n

.meas tran vdout1_499ck1450 FIND v(dout1_499) AT=730.025n

.meas tran vdout1_500ck1450 FIND v(dout1_500) AT=730.025n

.meas tran vdout1_501ck1450 FIND v(dout1_501) AT=730.025n

.meas tran vdout1_502ck1450 FIND v(dout1_502) AT=730.025n

.meas tran vdout1_503ck1450 FIND v(dout1_503) AT=730.025n

.meas tran vdout1_504ck1450 FIND v(dout1_504) AT=730.025n

.meas tran vdout1_505ck1450 FIND v(dout1_505) AT=730.025n

.meas tran vdout1_506ck1450 FIND v(dout1_506) AT=730.025n

.meas tran vdout1_507ck1450 FIND v(dout1_507) AT=730.025n

.meas tran vdout1_508ck1450 FIND v(dout1_508) AT=730.025n

.meas tran vdout1_509ck1450 FIND v(dout1_509) AT=730.025n

.meas tran vdout1_510ck1450 FIND v(dout1_510) AT=730.025n

.meas tran vdout1_511ck1450 FIND v(dout1_511) AT=730.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_16ck1480 FIND v(dout1_16) AT=745.025n

.meas tran vdout1_17ck1480 FIND v(dout1_17) AT=745.025n

.meas tran vdout1_18ck1480 FIND v(dout1_18) AT=745.025n

.meas tran vdout1_19ck1480 FIND v(dout1_19) AT=745.025n

.meas tran vdout1_20ck1480 FIND v(dout1_20) AT=745.025n

.meas tran vdout1_21ck1480 FIND v(dout1_21) AT=745.025n

.meas tran vdout1_22ck1480 FIND v(dout1_22) AT=745.025n

.meas tran vdout1_23ck1480 FIND v(dout1_23) AT=745.025n

.meas tran vdout1_24ck1480 FIND v(dout1_24) AT=745.025n

.meas tran vdout1_25ck1480 FIND v(dout1_25) AT=745.025n

.meas tran vdout1_26ck1480 FIND v(dout1_26) AT=745.025n

.meas tran vdout1_27ck1480 FIND v(dout1_27) AT=745.025n

.meas tran vdout1_28ck1480 FIND v(dout1_28) AT=745.025n

.meas tran vdout1_29ck1480 FIND v(dout1_29) AT=745.025n

.meas tran vdout1_30ck1480 FIND v(dout1_30) AT=745.025n

.meas tran vdout1_31ck1480 FIND v(dout1_31) AT=745.025n

.meas tran vdout1_32ck1480 FIND v(dout1_32) AT=745.025n

.meas tran vdout1_33ck1480 FIND v(dout1_33) AT=745.025n

.meas tran vdout1_34ck1480 FIND v(dout1_34) AT=745.025n

.meas tran vdout1_35ck1480 FIND v(dout1_35) AT=745.025n

.meas tran vdout1_36ck1480 FIND v(dout1_36) AT=745.025n

.meas tran vdout1_37ck1480 FIND v(dout1_37) AT=745.025n

.meas tran vdout1_38ck1480 FIND v(dout1_38) AT=745.025n

.meas tran vdout1_39ck1480 FIND v(dout1_39) AT=745.025n

.meas tran vdout1_40ck1480 FIND v(dout1_40) AT=745.025n

.meas tran vdout1_41ck1480 FIND v(dout1_41) AT=745.025n

.meas tran vdout1_42ck1480 FIND v(dout1_42) AT=745.025n

.meas tran vdout1_43ck1480 FIND v(dout1_43) AT=745.025n

.meas tran vdout1_44ck1480 FIND v(dout1_44) AT=745.025n

.meas tran vdout1_45ck1480 FIND v(dout1_45) AT=745.025n

.meas tran vdout1_46ck1480 FIND v(dout1_46) AT=745.025n

.meas tran vdout1_47ck1480 FIND v(dout1_47) AT=745.025n

.meas tran vdout1_48ck1480 FIND v(dout1_48) AT=745.025n

.meas tran vdout1_49ck1480 FIND v(dout1_49) AT=745.025n

.meas tran vdout1_50ck1480 FIND v(dout1_50) AT=745.025n

.meas tran vdout1_51ck1480 FIND v(dout1_51) AT=745.025n

.meas tran vdout1_52ck1480 FIND v(dout1_52) AT=745.025n

.meas tran vdout1_53ck1480 FIND v(dout1_53) AT=745.025n

.meas tran vdout1_54ck1480 FIND v(dout1_54) AT=745.025n

.meas tran vdout1_55ck1480 FIND v(dout1_55) AT=745.025n

.meas tran vdout1_56ck1480 FIND v(dout1_56) AT=745.025n

.meas tran vdout1_57ck1480 FIND v(dout1_57) AT=745.025n

.meas tran vdout1_58ck1480 FIND v(dout1_58) AT=745.025n

.meas tran vdout1_59ck1480 FIND v(dout1_59) AT=745.025n

.meas tran vdout1_60ck1480 FIND v(dout1_60) AT=745.025n

.meas tran vdout1_61ck1480 FIND v(dout1_61) AT=745.025n

.meas tran vdout1_62ck1480 FIND v(dout1_62) AT=745.025n

.meas tran vdout1_63ck1480 FIND v(dout1_63) AT=745.025n

.meas tran vdout1_64ck1480 FIND v(dout1_64) AT=745.025n

.meas tran vdout1_65ck1480 FIND v(dout1_65) AT=745.025n

.meas tran vdout1_66ck1480 FIND v(dout1_66) AT=745.025n

.meas tran vdout1_67ck1480 FIND v(dout1_67) AT=745.025n

.meas tran vdout1_68ck1480 FIND v(dout1_68) AT=745.025n

.meas tran vdout1_69ck1480 FIND v(dout1_69) AT=745.025n

.meas tran vdout1_70ck1480 FIND v(dout1_70) AT=745.025n

.meas tran vdout1_71ck1480 FIND v(dout1_71) AT=745.025n

.meas tran vdout1_72ck1480 FIND v(dout1_72) AT=745.025n

.meas tran vdout1_73ck1480 FIND v(dout1_73) AT=745.025n

.meas tran vdout1_74ck1480 FIND v(dout1_74) AT=745.025n

.meas tran vdout1_75ck1480 FIND v(dout1_75) AT=745.025n

.meas tran vdout1_76ck1480 FIND v(dout1_76) AT=745.025n

.meas tran vdout1_77ck1480 FIND v(dout1_77) AT=745.025n

.meas tran vdout1_78ck1480 FIND v(dout1_78) AT=745.025n

.meas tran vdout1_79ck1480 FIND v(dout1_79) AT=745.025n

.meas tran vdout1_80ck1480 FIND v(dout1_80) AT=745.025n

.meas tran vdout1_81ck1480 FIND v(dout1_81) AT=745.025n

.meas tran vdout1_82ck1480 FIND v(dout1_82) AT=745.025n

.meas tran vdout1_83ck1480 FIND v(dout1_83) AT=745.025n

.meas tran vdout1_84ck1480 FIND v(dout1_84) AT=745.025n

.meas tran vdout1_85ck1480 FIND v(dout1_85) AT=745.025n

.meas tran vdout1_86ck1480 FIND v(dout1_86) AT=745.025n

.meas tran vdout1_87ck1480 FIND v(dout1_87) AT=745.025n

.meas tran vdout1_88ck1480 FIND v(dout1_88) AT=745.025n

.meas tran vdout1_89ck1480 FIND v(dout1_89) AT=745.025n

.meas tran vdout1_90ck1480 FIND v(dout1_90) AT=745.025n

.meas tran vdout1_91ck1480 FIND v(dout1_91) AT=745.025n

.meas tran vdout1_92ck1480 FIND v(dout1_92) AT=745.025n

.meas tran vdout1_93ck1480 FIND v(dout1_93) AT=745.025n

.meas tran vdout1_94ck1480 FIND v(dout1_94) AT=745.025n

.meas tran vdout1_95ck1480 FIND v(dout1_95) AT=745.025n

.meas tran vdout1_96ck1480 FIND v(dout1_96) AT=745.025n

.meas tran vdout1_97ck1480 FIND v(dout1_97) AT=745.025n

.meas tran vdout1_98ck1480 FIND v(dout1_98) AT=745.025n

.meas tran vdout1_99ck1480 FIND v(dout1_99) AT=745.025n

.meas tran vdout1_100ck1480 FIND v(dout1_100) AT=745.025n

.meas tran vdout1_101ck1480 FIND v(dout1_101) AT=745.025n

.meas tran vdout1_102ck1480 FIND v(dout1_102) AT=745.025n

.meas tran vdout1_103ck1480 FIND v(dout1_103) AT=745.025n

.meas tran vdout1_104ck1480 FIND v(dout1_104) AT=745.025n

.meas tran vdout1_105ck1480 FIND v(dout1_105) AT=745.025n

.meas tran vdout1_106ck1480 FIND v(dout1_106) AT=745.025n

.meas tran vdout1_107ck1480 FIND v(dout1_107) AT=745.025n

.meas tran vdout1_108ck1480 FIND v(dout1_108) AT=745.025n

.meas tran vdout1_109ck1480 FIND v(dout1_109) AT=745.025n

.meas tran vdout1_110ck1480 FIND v(dout1_110) AT=745.025n

.meas tran vdout1_111ck1480 FIND v(dout1_111) AT=745.025n

.meas tran vdout1_112ck1480 FIND v(dout1_112) AT=745.025n

.meas tran vdout1_113ck1480 FIND v(dout1_113) AT=745.025n

.meas tran vdout1_114ck1480 FIND v(dout1_114) AT=745.025n

.meas tran vdout1_115ck1480 FIND v(dout1_115) AT=745.025n

.meas tran vdout1_116ck1480 FIND v(dout1_116) AT=745.025n

.meas tran vdout1_117ck1480 FIND v(dout1_117) AT=745.025n

.meas tran vdout1_118ck1480 FIND v(dout1_118) AT=745.025n

.meas tran vdout1_119ck1480 FIND v(dout1_119) AT=745.025n

.meas tran vdout1_120ck1480 FIND v(dout1_120) AT=745.025n

.meas tran vdout1_121ck1480 FIND v(dout1_121) AT=745.025n

.meas tran vdout1_122ck1480 FIND v(dout1_122) AT=745.025n

.meas tran vdout1_123ck1480 FIND v(dout1_123) AT=745.025n

.meas tran vdout1_124ck1480 FIND v(dout1_124) AT=745.025n

.meas tran vdout1_125ck1480 FIND v(dout1_125) AT=745.025n

.meas tran vdout1_126ck1480 FIND v(dout1_126) AT=745.025n

.meas tran vdout1_127ck1480 FIND v(dout1_127) AT=745.025n

.meas tran vdout1_128ck1480 FIND v(dout1_128) AT=745.025n

.meas tran vdout1_129ck1480 FIND v(dout1_129) AT=745.025n

.meas tran vdout1_130ck1480 FIND v(dout1_130) AT=745.025n

.meas tran vdout1_131ck1480 FIND v(dout1_131) AT=745.025n

.meas tran vdout1_132ck1480 FIND v(dout1_132) AT=745.025n

.meas tran vdout1_133ck1480 FIND v(dout1_133) AT=745.025n

.meas tran vdout1_134ck1480 FIND v(dout1_134) AT=745.025n

.meas tran vdout1_135ck1480 FIND v(dout1_135) AT=745.025n

.meas tran vdout1_136ck1480 FIND v(dout1_136) AT=745.025n

.meas tran vdout1_137ck1480 FIND v(dout1_137) AT=745.025n

.meas tran vdout1_138ck1480 FIND v(dout1_138) AT=745.025n

.meas tran vdout1_139ck1480 FIND v(dout1_139) AT=745.025n

.meas tran vdout1_140ck1480 FIND v(dout1_140) AT=745.025n

.meas tran vdout1_141ck1480 FIND v(dout1_141) AT=745.025n

.meas tran vdout1_142ck1480 FIND v(dout1_142) AT=745.025n

.meas tran vdout1_143ck1480 FIND v(dout1_143) AT=745.025n

.meas tran vdout1_144ck1480 FIND v(dout1_144) AT=745.025n

.meas tran vdout1_145ck1480 FIND v(dout1_145) AT=745.025n

.meas tran vdout1_146ck1480 FIND v(dout1_146) AT=745.025n

.meas tran vdout1_147ck1480 FIND v(dout1_147) AT=745.025n

.meas tran vdout1_148ck1480 FIND v(dout1_148) AT=745.025n

.meas tran vdout1_149ck1480 FIND v(dout1_149) AT=745.025n

.meas tran vdout1_150ck1480 FIND v(dout1_150) AT=745.025n

.meas tran vdout1_151ck1480 FIND v(dout1_151) AT=745.025n

.meas tran vdout1_152ck1480 FIND v(dout1_152) AT=745.025n

.meas tran vdout1_153ck1480 FIND v(dout1_153) AT=745.025n

.meas tran vdout1_154ck1480 FIND v(dout1_154) AT=745.025n

.meas tran vdout1_155ck1480 FIND v(dout1_155) AT=745.025n

.meas tran vdout1_156ck1480 FIND v(dout1_156) AT=745.025n

.meas tran vdout1_157ck1480 FIND v(dout1_157) AT=745.025n

.meas tran vdout1_158ck1480 FIND v(dout1_158) AT=745.025n

.meas tran vdout1_159ck1480 FIND v(dout1_159) AT=745.025n

.meas tran vdout1_160ck1480 FIND v(dout1_160) AT=745.025n

.meas tran vdout1_161ck1480 FIND v(dout1_161) AT=745.025n

.meas tran vdout1_162ck1480 FIND v(dout1_162) AT=745.025n

.meas tran vdout1_163ck1480 FIND v(dout1_163) AT=745.025n

.meas tran vdout1_164ck1480 FIND v(dout1_164) AT=745.025n

.meas tran vdout1_165ck1480 FIND v(dout1_165) AT=745.025n

.meas tran vdout1_166ck1480 FIND v(dout1_166) AT=745.025n

.meas tran vdout1_167ck1480 FIND v(dout1_167) AT=745.025n

.meas tran vdout1_168ck1480 FIND v(dout1_168) AT=745.025n

.meas tran vdout1_169ck1480 FIND v(dout1_169) AT=745.025n

.meas tran vdout1_170ck1480 FIND v(dout1_170) AT=745.025n

.meas tran vdout1_171ck1480 FIND v(dout1_171) AT=745.025n

.meas tran vdout1_172ck1480 FIND v(dout1_172) AT=745.025n

.meas tran vdout1_173ck1480 FIND v(dout1_173) AT=745.025n

.meas tran vdout1_174ck1480 FIND v(dout1_174) AT=745.025n

.meas tran vdout1_175ck1480 FIND v(dout1_175) AT=745.025n

.meas tran vdout1_176ck1480 FIND v(dout1_176) AT=745.025n

.meas tran vdout1_177ck1480 FIND v(dout1_177) AT=745.025n

.meas tran vdout1_178ck1480 FIND v(dout1_178) AT=745.025n

.meas tran vdout1_179ck1480 FIND v(dout1_179) AT=745.025n

.meas tran vdout1_180ck1480 FIND v(dout1_180) AT=745.025n

.meas tran vdout1_181ck1480 FIND v(dout1_181) AT=745.025n

.meas tran vdout1_182ck1480 FIND v(dout1_182) AT=745.025n

.meas tran vdout1_183ck1480 FIND v(dout1_183) AT=745.025n

.meas tran vdout1_184ck1480 FIND v(dout1_184) AT=745.025n

.meas tran vdout1_185ck1480 FIND v(dout1_185) AT=745.025n

.meas tran vdout1_186ck1480 FIND v(dout1_186) AT=745.025n

.meas tran vdout1_187ck1480 FIND v(dout1_187) AT=745.025n

.meas tran vdout1_188ck1480 FIND v(dout1_188) AT=745.025n

.meas tran vdout1_189ck1480 FIND v(dout1_189) AT=745.025n

.meas tran vdout1_190ck1480 FIND v(dout1_190) AT=745.025n

.meas tran vdout1_191ck1480 FIND v(dout1_191) AT=745.025n

.meas tran vdout1_192ck1480 FIND v(dout1_192) AT=745.025n

.meas tran vdout1_193ck1480 FIND v(dout1_193) AT=745.025n

.meas tran vdout1_194ck1480 FIND v(dout1_194) AT=745.025n

.meas tran vdout1_195ck1480 FIND v(dout1_195) AT=745.025n

.meas tran vdout1_196ck1480 FIND v(dout1_196) AT=745.025n

.meas tran vdout1_197ck1480 FIND v(dout1_197) AT=745.025n

.meas tran vdout1_198ck1480 FIND v(dout1_198) AT=745.025n

.meas tran vdout1_199ck1480 FIND v(dout1_199) AT=745.025n

.meas tran vdout1_200ck1480 FIND v(dout1_200) AT=745.025n

.meas tran vdout1_201ck1480 FIND v(dout1_201) AT=745.025n

.meas tran vdout1_202ck1480 FIND v(dout1_202) AT=745.025n

.meas tran vdout1_203ck1480 FIND v(dout1_203) AT=745.025n

.meas tran vdout1_204ck1480 FIND v(dout1_204) AT=745.025n

.meas tran vdout1_205ck1480 FIND v(dout1_205) AT=745.025n

.meas tran vdout1_206ck1480 FIND v(dout1_206) AT=745.025n

.meas tran vdout1_207ck1480 FIND v(dout1_207) AT=745.025n

.meas tran vdout1_208ck1480 FIND v(dout1_208) AT=745.025n

.meas tran vdout1_209ck1480 FIND v(dout1_209) AT=745.025n

.meas tran vdout1_210ck1480 FIND v(dout1_210) AT=745.025n

.meas tran vdout1_211ck1480 FIND v(dout1_211) AT=745.025n

.meas tran vdout1_212ck1480 FIND v(dout1_212) AT=745.025n

.meas tran vdout1_213ck1480 FIND v(dout1_213) AT=745.025n

.meas tran vdout1_214ck1480 FIND v(dout1_214) AT=745.025n

.meas tran vdout1_215ck1480 FIND v(dout1_215) AT=745.025n

.meas tran vdout1_216ck1480 FIND v(dout1_216) AT=745.025n

.meas tran vdout1_217ck1480 FIND v(dout1_217) AT=745.025n

.meas tran vdout1_218ck1480 FIND v(dout1_218) AT=745.025n

.meas tran vdout1_219ck1480 FIND v(dout1_219) AT=745.025n

.meas tran vdout1_220ck1480 FIND v(dout1_220) AT=745.025n

.meas tran vdout1_221ck1480 FIND v(dout1_221) AT=745.025n

.meas tran vdout1_222ck1480 FIND v(dout1_222) AT=745.025n

.meas tran vdout1_223ck1480 FIND v(dout1_223) AT=745.025n

.meas tran vdout1_224ck1480 FIND v(dout1_224) AT=745.025n

.meas tran vdout1_225ck1480 FIND v(dout1_225) AT=745.025n

.meas tran vdout1_226ck1480 FIND v(dout1_226) AT=745.025n

.meas tran vdout1_227ck1480 FIND v(dout1_227) AT=745.025n

.meas tran vdout1_228ck1480 FIND v(dout1_228) AT=745.025n

.meas tran vdout1_229ck1480 FIND v(dout1_229) AT=745.025n

.meas tran vdout1_230ck1480 FIND v(dout1_230) AT=745.025n

.meas tran vdout1_231ck1480 FIND v(dout1_231) AT=745.025n

.meas tran vdout1_232ck1480 FIND v(dout1_232) AT=745.025n

.meas tran vdout1_233ck1480 FIND v(dout1_233) AT=745.025n

.meas tran vdout1_234ck1480 FIND v(dout1_234) AT=745.025n

.meas tran vdout1_235ck1480 FIND v(dout1_235) AT=745.025n

.meas tran vdout1_236ck1480 FIND v(dout1_236) AT=745.025n

.meas tran vdout1_237ck1480 FIND v(dout1_237) AT=745.025n

.meas tran vdout1_238ck1480 FIND v(dout1_238) AT=745.025n

.meas tran vdout1_239ck1480 FIND v(dout1_239) AT=745.025n

.meas tran vdout1_240ck1480 FIND v(dout1_240) AT=745.025n

.meas tran vdout1_241ck1480 FIND v(dout1_241) AT=745.025n

.meas tran vdout1_242ck1480 FIND v(dout1_242) AT=745.025n

.meas tran vdout1_243ck1480 FIND v(dout1_243) AT=745.025n

.meas tran vdout1_244ck1480 FIND v(dout1_244) AT=745.025n

.meas tran vdout1_245ck1480 FIND v(dout1_245) AT=745.025n

.meas tran vdout1_246ck1480 FIND v(dout1_246) AT=745.025n

.meas tran vdout1_247ck1480 FIND v(dout1_247) AT=745.025n

.meas tran vdout1_248ck1480 FIND v(dout1_248) AT=745.025n

.meas tran vdout1_249ck1480 FIND v(dout1_249) AT=745.025n

.meas tran vdout1_250ck1480 FIND v(dout1_250) AT=745.025n

.meas tran vdout1_251ck1480 FIND v(dout1_251) AT=745.025n

.meas tran vdout1_252ck1480 FIND v(dout1_252) AT=745.025n

.meas tran vdout1_253ck1480 FIND v(dout1_253) AT=745.025n

.meas tran vdout1_254ck1480 FIND v(dout1_254) AT=745.025n

.meas tran vdout1_255ck1480 FIND v(dout1_255) AT=745.025n

.meas tran vdout1_256ck1480 FIND v(dout1_256) AT=745.025n

.meas tran vdout1_257ck1480 FIND v(dout1_257) AT=745.025n

.meas tran vdout1_258ck1480 FIND v(dout1_258) AT=745.025n

.meas tran vdout1_259ck1480 FIND v(dout1_259) AT=745.025n

.meas tran vdout1_260ck1480 FIND v(dout1_260) AT=745.025n

.meas tran vdout1_261ck1480 FIND v(dout1_261) AT=745.025n

.meas tran vdout1_262ck1480 FIND v(dout1_262) AT=745.025n

.meas tran vdout1_263ck1480 FIND v(dout1_263) AT=745.025n

.meas tran vdout1_264ck1480 FIND v(dout1_264) AT=745.025n

.meas tran vdout1_265ck1480 FIND v(dout1_265) AT=745.025n

.meas tran vdout1_266ck1480 FIND v(dout1_266) AT=745.025n

.meas tran vdout1_267ck1480 FIND v(dout1_267) AT=745.025n

.meas tran vdout1_268ck1480 FIND v(dout1_268) AT=745.025n

.meas tran vdout1_269ck1480 FIND v(dout1_269) AT=745.025n

.meas tran vdout1_270ck1480 FIND v(dout1_270) AT=745.025n

.meas tran vdout1_271ck1480 FIND v(dout1_271) AT=745.025n

.meas tran vdout1_272ck1480 FIND v(dout1_272) AT=745.025n

.meas tran vdout1_273ck1480 FIND v(dout1_273) AT=745.025n

.meas tran vdout1_274ck1480 FIND v(dout1_274) AT=745.025n

.meas tran vdout1_275ck1480 FIND v(dout1_275) AT=745.025n

.meas tran vdout1_276ck1480 FIND v(dout1_276) AT=745.025n

.meas tran vdout1_277ck1480 FIND v(dout1_277) AT=745.025n

.meas tran vdout1_278ck1480 FIND v(dout1_278) AT=745.025n

.meas tran vdout1_279ck1480 FIND v(dout1_279) AT=745.025n

.meas tran vdout1_280ck1480 FIND v(dout1_280) AT=745.025n

.meas tran vdout1_281ck1480 FIND v(dout1_281) AT=745.025n

.meas tran vdout1_282ck1480 FIND v(dout1_282) AT=745.025n

.meas tran vdout1_283ck1480 FIND v(dout1_283) AT=745.025n

.meas tran vdout1_284ck1480 FIND v(dout1_284) AT=745.025n

.meas tran vdout1_285ck1480 FIND v(dout1_285) AT=745.025n

.meas tran vdout1_286ck1480 FIND v(dout1_286) AT=745.025n

.meas tran vdout1_287ck1480 FIND v(dout1_287) AT=745.025n

.meas tran vdout1_288ck1480 FIND v(dout1_288) AT=745.025n

.meas tran vdout1_289ck1480 FIND v(dout1_289) AT=745.025n

.meas tran vdout1_290ck1480 FIND v(dout1_290) AT=745.025n

.meas tran vdout1_291ck1480 FIND v(dout1_291) AT=745.025n

.meas tran vdout1_292ck1480 FIND v(dout1_292) AT=745.025n

.meas tran vdout1_293ck1480 FIND v(dout1_293) AT=745.025n

.meas tran vdout1_294ck1480 FIND v(dout1_294) AT=745.025n

.meas tran vdout1_295ck1480 FIND v(dout1_295) AT=745.025n

.meas tran vdout1_296ck1480 FIND v(dout1_296) AT=745.025n

.meas tran vdout1_297ck1480 FIND v(dout1_297) AT=745.025n

.meas tran vdout1_298ck1480 FIND v(dout1_298) AT=745.025n

.meas tran vdout1_299ck1480 FIND v(dout1_299) AT=745.025n

.meas tran vdout1_300ck1480 FIND v(dout1_300) AT=745.025n

.meas tran vdout1_301ck1480 FIND v(dout1_301) AT=745.025n

.meas tran vdout1_302ck1480 FIND v(dout1_302) AT=745.025n

.meas tran vdout1_303ck1480 FIND v(dout1_303) AT=745.025n

.meas tran vdout1_304ck1480 FIND v(dout1_304) AT=745.025n

.meas tran vdout1_305ck1480 FIND v(dout1_305) AT=745.025n

.meas tran vdout1_306ck1480 FIND v(dout1_306) AT=745.025n

.meas tran vdout1_307ck1480 FIND v(dout1_307) AT=745.025n

.meas tran vdout1_308ck1480 FIND v(dout1_308) AT=745.025n

.meas tran vdout1_309ck1480 FIND v(dout1_309) AT=745.025n

.meas tran vdout1_310ck1480 FIND v(dout1_310) AT=745.025n

.meas tran vdout1_311ck1480 FIND v(dout1_311) AT=745.025n

.meas tran vdout1_312ck1480 FIND v(dout1_312) AT=745.025n

.meas tran vdout1_313ck1480 FIND v(dout1_313) AT=745.025n

.meas tran vdout1_314ck1480 FIND v(dout1_314) AT=745.025n

.meas tran vdout1_315ck1480 FIND v(dout1_315) AT=745.025n

.meas tran vdout1_316ck1480 FIND v(dout1_316) AT=745.025n

.meas tran vdout1_317ck1480 FIND v(dout1_317) AT=745.025n

.meas tran vdout1_318ck1480 FIND v(dout1_318) AT=745.025n

.meas tran vdout1_319ck1480 FIND v(dout1_319) AT=745.025n

.meas tran vdout1_320ck1480 FIND v(dout1_320) AT=745.025n

.meas tran vdout1_321ck1480 FIND v(dout1_321) AT=745.025n

.meas tran vdout1_322ck1480 FIND v(dout1_322) AT=745.025n

.meas tran vdout1_323ck1480 FIND v(dout1_323) AT=745.025n

.meas tran vdout1_324ck1480 FIND v(dout1_324) AT=745.025n

.meas tran vdout1_325ck1480 FIND v(dout1_325) AT=745.025n

.meas tran vdout1_326ck1480 FIND v(dout1_326) AT=745.025n

.meas tran vdout1_327ck1480 FIND v(dout1_327) AT=745.025n

.meas tran vdout1_328ck1480 FIND v(dout1_328) AT=745.025n

.meas tran vdout1_329ck1480 FIND v(dout1_329) AT=745.025n

.meas tran vdout1_330ck1480 FIND v(dout1_330) AT=745.025n

.meas tran vdout1_331ck1480 FIND v(dout1_331) AT=745.025n

.meas tran vdout1_332ck1480 FIND v(dout1_332) AT=745.025n

.meas tran vdout1_333ck1480 FIND v(dout1_333) AT=745.025n

.meas tran vdout1_334ck1480 FIND v(dout1_334) AT=745.025n

.meas tran vdout1_335ck1480 FIND v(dout1_335) AT=745.025n

.meas tran vdout1_336ck1480 FIND v(dout1_336) AT=745.025n

.meas tran vdout1_337ck1480 FIND v(dout1_337) AT=745.025n

.meas tran vdout1_338ck1480 FIND v(dout1_338) AT=745.025n

.meas tran vdout1_339ck1480 FIND v(dout1_339) AT=745.025n

.meas tran vdout1_340ck1480 FIND v(dout1_340) AT=745.025n

.meas tran vdout1_341ck1480 FIND v(dout1_341) AT=745.025n

.meas tran vdout1_342ck1480 FIND v(dout1_342) AT=745.025n

.meas tran vdout1_343ck1480 FIND v(dout1_343) AT=745.025n

.meas tran vdout1_344ck1480 FIND v(dout1_344) AT=745.025n

.meas tran vdout1_345ck1480 FIND v(dout1_345) AT=745.025n

.meas tran vdout1_346ck1480 FIND v(dout1_346) AT=745.025n

.meas tran vdout1_347ck1480 FIND v(dout1_347) AT=745.025n

.meas tran vdout1_348ck1480 FIND v(dout1_348) AT=745.025n

.meas tran vdout1_349ck1480 FIND v(dout1_349) AT=745.025n

.meas tran vdout1_350ck1480 FIND v(dout1_350) AT=745.025n

.meas tran vdout1_351ck1480 FIND v(dout1_351) AT=745.025n

.meas tran vdout1_352ck1480 FIND v(dout1_352) AT=745.025n

.meas tran vdout1_353ck1480 FIND v(dout1_353) AT=745.025n

.meas tran vdout1_354ck1480 FIND v(dout1_354) AT=745.025n

.meas tran vdout1_355ck1480 FIND v(dout1_355) AT=745.025n

.meas tran vdout1_356ck1480 FIND v(dout1_356) AT=745.025n

.meas tran vdout1_357ck1480 FIND v(dout1_357) AT=745.025n

.meas tran vdout1_358ck1480 FIND v(dout1_358) AT=745.025n

.meas tran vdout1_359ck1480 FIND v(dout1_359) AT=745.025n

.meas tran vdout1_360ck1480 FIND v(dout1_360) AT=745.025n

.meas tran vdout1_361ck1480 FIND v(dout1_361) AT=745.025n

.meas tran vdout1_362ck1480 FIND v(dout1_362) AT=745.025n

.meas tran vdout1_363ck1480 FIND v(dout1_363) AT=745.025n

.meas tran vdout1_364ck1480 FIND v(dout1_364) AT=745.025n

.meas tran vdout1_365ck1480 FIND v(dout1_365) AT=745.025n

.meas tran vdout1_366ck1480 FIND v(dout1_366) AT=745.025n

.meas tran vdout1_367ck1480 FIND v(dout1_367) AT=745.025n

.meas tran vdout1_368ck1480 FIND v(dout1_368) AT=745.025n

.meas tran vdout1_369ck1480 FIND v(dout1_369) AT=745.025n

.meas tran vdout1_370ck1480 FIND v(dout1_370) AT=745.025n

.meas tran vdout1_371ck1480 FIND v(dout1_371) AT=745.025n

.meas tran vdout1_372ck1480 FIND v(dout1_372) AT=745.025n

.meas tran vdout1_373ck1480 FIND v(dout1_373) AT=745.025n

.meas tran vdout1_374ck1480 FIND v(dout1_374) AT=745.025n

.meas tran vdout1_375ck1480 FIND v(dout1_375) AT=745.025n

.meas tran vdout1_376ck1480 FIND v(dout1_376) AT=745.025n

.meas tran vdout1_377ck1480 FIND v(dout1_377) AT=745.025n

.meas tran vdout1_378ck1480 FIND v(dout1_378) AT=745.025n

.meas tran vdout1_379ck1480 FIND v(dout1_379) AT=745.025n

.meas tran vdout1_380ck1480 FIND v(dout1_380) AT=745.025n

.meas tran vdout1_381ck1480 FIND v(dout1_381) AT=745.025n

.meas tran vdout1_382ck1480 FIND v(dout1_382) AT=745.025n

.meas tran vdout1_383ck1480 FIND v(dout1_383) AT=745.025n

.meas tran vdout1_384ck1480 FIND v(dout1_384) AT=745.025n

.meas tran vdout1_385ck1480 FIND v(dout1_385) AT=745.025n

.meas tran vdout1_386ck1480 FIND v(dout1_386) AT=745.025n

.meas tran vdout1_387ck1480 FIND v(dout1_387) AT=745.025n

.meas tran vdout1_388ck1480 FIND v(dout1_388) AT=745.025n

.meas tran vdout1_389ck1480 FIND v(dout1_389) AT=745.025n

.meas tran vdout1_390ck1480 FIND v(dout1_390) AT=745.025n

.meas tran vdout1_391ck1480 FIND v(dout1_391) AT=745.025n

.meas tran vdout1_392ck1480 FIND v(dout1_392) AT=745.025n

.meas tran vdout1_393ck1480 FIND v(dout1_393) AT=745.025n

.meas tran vdout1_394ck1480 FIND v(dout1_394) AT=745.025n

.meas tran vdout1_395ck1480 FIND v(dout1_395) AT=745.025n

.meas tran vdout1_396ck1480 FIND v(dout1_396) AT=745.025n

.meas tran vdout1_397ck1480 FIND v(dout1_397) AT=745.025n

.meas tran vdout1_398ck1480 FIND v(dout1_398) AT=745.025n

.meas tran vdout1_399ck1480 FIND v(dout1_399) AT=745.025n

.meas tran vdout1_400ck1480 FIND v(dout1_400) AT=745.025n

.meas tran vdout1_401ck1480 FIND v(dout1_401) AT=745.025n

.meas tran vdout1_402ck1480 FIND v(dout1_402) AT=745.025n

.meas tran vdout1_403ck1480 FIND v(dout1_403) AT=745.025n

.meas tran vdout1_404ck1480 FIND v(dout1_404) AT=745.025n

.meas tran vdout1_405ck1480 FIND v(dout1_405) AT=745.025n

.meas tran vdout1_406ck1480 FIND v(dout1_406) AT=745.025n

.meas tran vdout1_407ck1480 FIND v(dout1_407) AT=745.025n

.meas tran vdout1_408ck1480 FIND v(dout1_408) AT=745.025n

.meas tran vdout1_409ck1480 FIND v(dout1_409) AT=745.025n

.meas tran vdout1_410ck1480 FIND v(dout1_410) AT=745.025n

.meas tran vdout1_411ck1480 FIND v(dout1_411) AT=745.025n

.meas tran vdout1_412ck1480 FIND v(dout1_412) AT=745.025n

.meas tran vdout1_413ck1480 FIND v(dout1_413) AT=745.025n

.meas tran vdout1_414ck1480 FIND v(dout1_414) AT=745.025n

.meas tran vdout1_415ck1480 FIND v(dout1_415) AT=745.025n

.meas tran vdout1_416ck1480 FIND v(dout1_416) AT=745.025n

.meas tran vdout1_417ck1480 FIND v(dout1_417) AT=745.025n

.meas tran vdout1_418ck1480 FIND v(dout1_418) AT=745.025n

.meas tran vdout1_419ck1480 FIND v(dout1_419) AT=745.025n

.meas tran vdout1_420ck1480 FIND v(dout1_420) AT=745.025n

.meas tran vdout1_421ck1480 FIND v(dout1_421) AT=745.025n

.meas tran vdout1_422ck1480 FIND v(dout1_422) AT=745.025n

.meas tran vdout1_423ck1480 FIND v(dout1_423) AT=745.025n

.meas tran vdout1_424ck1480 FIND v(dout1_424) AT=745.025n

.meas tran vdout1_425ck1480 FIND v(dout1_425) AT=745.025n

.meas tran vdout1_426ck1480 FIND v(dout1_426) AT=745.025n

.meas tran vdout1_427ck1480 FIND v(dout1_427) AT=745.025n

.meas tran vdout1_428ck1480 FIND v(dout1_428) AT=745.025n

.meas tran vdout1_429ck1480 FIND v(dout1_429) AT=745.025n

.meas tran vdout1_430ck1480 FIND v(dout1_430) AT=745.025n

.meas tran vdout1_431ck1480 FIND v(dout1_431) AT=745.025n

.meas tran vdout1_432ck1480 FIND v(dout1_432) AT=745.025n

.meas tran vdout1_433ck1480 FIND v(dout1_433) AT=745.025n

.meas tran vdout1_434ck1480 FIND v(dout1_434) AT=745.025n

.meas tran vdout1_435ck1480 FIND v(dout1_435) AT=745.025n

.meas tran vdout1_436ck1480 FIND v(dout1_436) AT=745.025n

.meas tran vdout1_437ck1480 FIND v(dout1_437) AT=745.025n

.meas tran vdout1_438ck1480 FIND v(dout1_438) AT=745.025n

.meas tran vdout1_439ck1480 FIND v(dout1_439) AT=745.025n

.meas tran vdout1_440ck1480 FIND v(dout1_440) AT=745.025n

.meas tran vdout1_441ck1480 FIND v(dout1_441) AT=745.025n

.meas tran vdout1_442ck1480 FIND v(dout1_442) AT=745.025n

.meas tran vdout1_443ck1480 FIND v(dout1_443) AT=745.025n

.meas tran vdout1_444ck1480 FIND v(dout1_444) AT=745.025n

.meas tran vdout1_445ck1480 FIND v(dout1_445) AT=745.025n

.meas tran vdout1_446ck1480 FIND v(dout1_446) AT=745.025n

.meas tran vdout1_447ck1480 FIND v(dout1_447) AT=745.025n

.meas tran vdout1_448ck1480 FIND v(dout1_448) AT=745.025n

.meas tran vdout1_449ck1480 FIND v(dout1_449) AT=745.025n

.meas tran vdout1_450ck1480 FIND v(dout1_450) AT=745.025n

.meas tran vdout1_451ck1480 FIND v(dout1_451) AT=745.025n

.meas tran vdout1_452ck1480 FIND v(dout1_452) AT=745.025n

.meas tran vdout1_453ck1480 FIND v(dout1_453) AT=745.025n

.meas tran vdout1_454ck1480 FIND v(dout1_454) AT=745.025n

.meas tran vdout1_455ck1480 FIND v(dout1_455) AT=745.025n

.meas tran vdout1_456ck1480 FIND v(dout1_456) AT=745.025n

.meas tran vdout1_457ck1480 FIND v(dout1_457) AT=745.025n

.meas tran vdout1_458ck1480 FIND v(dout1_458) AT=745.025n

.meas tran vdout1_459ck1480 FIND v(dout1_459) AT=745.025n

.meas tran vdout1_460ck1480 FIND v(dout1_460) AT=745.025n

.meas tran vdout1_461ck1480 FIND v(dout1_461) AT=745.025n

.meas tran vdout1_462ck1480 FIND v(dout1_462) AT=745.025n

.meas tran vdout1_463ck1480 FIND v(dout1_463) AT=745.025n

.meas tran vdout1_464ck1480 FIND v(dout1_464) AT=745.025n

.meas tran vdout1_465ck1480 FIND v(dout1_465) AT=745.025n

.meas tran vdout1_466ck1480 FIND v(dout1_466) AT=745.025n

.meas tran vdout1_467ck1480 FIND v(dout1_467) AT=745.025n

.meas tran vdout1_468ck1480 FIND v(dout1_468) AT=745.025n

.meas tran vdout1_469ck1480 FIND v(dout1_469) AT=745.025n

.meas tran vdout1_470ck1480 FIND v(dout1_470) AT=745.025n

.meas tran vdout1_471ck1480 FIND v(dout1_471) AT=745.025n

.meas tran vdout1_472ck1480 FIND v(dout1_472) AT=745.025n

.meas tran vdout1_473ck1480 FIND v(dout1_473) AT=745.025n

.meas tran vdout1_474ck1480 FIND v(dout1_474) AT=745.025n

.meas tran vdout1_475ck1480 FIND v(dout1_475) AT=745.025n

.meas tran vdout1_476ck1480 FIND v(dout1_476) AT=745.025n

.meas tran vdout1_477ck1480 FIND v(dout1_477) AT=745.025n

.meas tran vdout1_478ck1480 FIND v(dout1_478) AT=745.025n

.meas tran vdout1_479ck1480 FIND v(dout1_479) AT=745.025n

.meas tran vdout1_480ck1480 FIND v(dout1_480) AT=745.025n

.meas tran vdout1_481ck1480 FIND v(dout1_481) AT=745.025n

.meas tran vdout1_482ck1480 FIND v(dout1_482) AT=745.025n

.meas tran vdout1_483ck1480 FIND v(dout1_483) AT=745.025n

.meas tran vdout1_484ck1480 FIND v(dout1_484) AT=745.025n

.meas tran vdout1_485ck1480 FIND v(dout1_485) AT=745.025n

.meas tran vdout1_486ck1480 FIND v(dout1_486) AT=745.025n

.meas tran vdout1_487ck1480 FIND v(dout1_487) AT=745.025n

.meas tran vdout1_488ck1480 FIND v(dout1_488) AT=745.025n

.meas tran vdout1_489ck1480 FIND v(dout1_489) AT=745.025n

.meas tran vdout1_490ck1480 FIND v(dout1_490) AT=745.025n

.meas tran vdout1_491ck1480 FIND v(dout1_491) AT=745.025n

.meas tran vdout1_492ck1480 FIND v(dout1_492) AT=745.025n

.meas tran vdout1_493ck1480 FIND v(dout1_493) AT=745.025n

.meas tran vdout1_494ck1480 FIND v(dout1_494) AT=745.025n

.meas tran vdout1_495ck1480 FIND v(dout1_495) AT=745.025n

.meas tran vdout1_496ck1480 FIND v(dout1_496) AT=745.025n

.meas tran vdout1_497ck1480 FIND v(dout1_497) AT=745.025n

.meas tran vdout1_498ck1480 FIND v(dout1_498) AT=745.025n

.meas tran vdout1_499ck1480 FIND v(dout1_499) AT=745.025n

.meas tran vdout1_500ck1480 FIND v(dout1_500) AT=745.025n

.meas tran vdout1_501ck1480 FIND v(dout1_501) AT=745.025n

.meas tran vdout1_502ck1480 FIND v(dout1_502) AT=745.025n

.meas tran vdout1_503ck1480 FIND v(dout1_503) AT=745.025n

.meas tran vdout1_504ck1480 FIND v(dout1_504) AT=745.025n

.meas tran vdout1_505ck1480 FIND v(dout1_505) AT=745.025n

.meas tran vdout1_506ck1480 FIND v(dout1_506) AT=745.025n

.meas tran vdout1_507ck1480 FIND v(dout1_507) AT=745.025n

.meas tran vdout1_508ck1480 FIND v(dout1_508) AT=745.025n

.meas tran vdout1_509ck1480 FIND v(dout1_509) AT=745.025n

.meas tran vdout1_510ck1480 FIND v(dout1_510) AT=745.025n

.meas tran vdout1_511ck1480 FIND v(dout1_511) AT=745.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_16ck1520 FIND v(dout1_16) AT=765.025n

.meas tran vdout1_17ck1520 FIND v(dout1_17) AT=765.025n

.meas tran vdout1_18ck1520 FIND v(dout1_18) AT=765.025n

.meas tran vdout1_19ck1520 FIND v(dout1_19) AT=765.025n

.meas tran vdout1_20ck1520 FIND v(dout1_20) AT=765.025n

.meas tran vdout1_21ck1520 FIND v(dout1_21) AT=765.025n

.meas tran vdout1_22ck1520 FIND v(dout1_22) AT=765.025n

.meas tran vdout1_23ck1520 FIND v(dout1_23) AT=765.025n

.meas tran vdout1_24ck1520 FIND v(dout1_24) AT=765.025n

.meas tran vdout1_25ck1520 FIND v(dout1_25) AT=765.025n

.meas tran vdout1_26ck1520 FIND v(dout1_26) AT=765.025n

.meas tran vdout1_27ck1520 FIND v(dout1_27) AT=765.025n

.meas tran vdout1_28ck1520 FIND v(dout1_28) AT=765.025n

.meas tran vdout1_29ck1520 FIND v(dout1_29) AT=765.025n

.meas tran vdout1_30ck1520 FIND v(dout1_30) AT=765.025n

.meas tran vdout1_31ck1520 FIND v(dout1_31) AT=765.025n

.meas tran vdout1_32ck1520 FIND v(dout1_32) AT=765.025n

.meas tran vdout1_33ck1520 FIND v(dout1_33) AT=765.025n

.meas tran vdout1_34ck1520 FIND v(dout1_34) AT=765.025n

.meas tran vdout1_35ck1520 FIND v(dout1_35) AT=765.025n

.meas tran vdout1_36ck1520 FIND v(dout1_36) AT=765.025n

.meas tran vdout1_37ck1520 FIND v(dout1_37) AT=765.025n

.meas tran vdout1_38ck1520 FIND v(dout1_38) AT=765.025n

.meas tran vdout1_39ck1520 FIND v(dout1_39) AT=765.025n

.meas tran vdout1_40ck1520 FIND v(dout1_40) AT=765.025n

.meas tran vdout1_41ck1520 FIND v(dout1_41) AT=765.025n

.meas tran vdout1_42ck1520 FIND v(dout1_42) AT=765.025n

.meas tran vdout1_43ck1520 FIND v(dout1_43) AT=765.025n

.meas tran vdout1_44ck1520 FIND v(dout1_44) AT=765.025n

.meas tran vdout1_45ck1520 FIND v(dout1_45) AT=765.025n

.meas tran vdout1_46ck1520 FIND v(dout1_46) AT=765.025n

.meas tran vdout1_47ck1520 FIND v(dout1_47) AT=765.025n

.meas tran vdout1_48ck1520 FIND v(dout1_48) AT=765.025n

.meas tran vdout1_49ck1520 FIND v(dout1_49) AT=765.025n

.meas tran vdout1_50ck1520 FIND v(dout1_50) AT=765.025n

.meas tran vdout1_51ck1520 FIND v(dout1_51) AT=765.025n

.meas tran vdout1_52ck1520 FIND v(dout1_52) AT=765.025n

.meas tran vdout1_53ck1520 FIND v(dout1_53) AT=765.025n

.meas tran vdout1_54ck1520 FIND v(dout1_54) AT=765.025n

.meas tran vdout1_55ck1520 FIND v(dout1_55) AT=765.025n

.meas tran vdout1_56ck1520 FIND v(dout1_56) AT=765.025n

.meas tran vdout1_57ck1520 FIND v(dout1_57) AT=765.025n

.meas tran vdout1_58ck1520 FIND v(dout1_58) AT=765.025n

.meas tran vdout1_59ck1520 FIND v(dout1_59) AT=765.025n

.meas tran vdout1_60ck1520 FIND v(dout1_60) AT=765.025n

.meas tran vdout1_61ck1520 FIND v(dout1_61) AT=765.025n

.meas tran vdout1_62ck1520 FIND v(dout1_62) AT=765.025n

.meas tran vdout1_63ck1520 FIND v(dout1_63) AT=765.025n

.meas tran vdout1_64ck1520 FIND v(dout1_64) AT=765.025n

.meas tran vdout1_65ck1520 FIND v(dout1_65) AT=765.025n

.meas tran vdout1_66ck1520 FIND v(dout1_66) AT=765.025n

.meas tran vdout1_67ck1520 FIND v(dout1_67) AT=765.025n

.meas tran vdout1_68ck1520 FIND v(dout1_68) AT=765.025n

.meas tran vdout1_69ck1520 FIND v(dout1_69) AT=765.025n

.meas tran vdout1_70ck1520 FIND v(dout1_70) AT=765.025n

.meas tran vdout1_71ck1520 FIND v(dout1_71) AT=765.025n

.meas tran vdout1_72ck1520 FIND v(dout1_72) AT=765.025n

.meas tran vdout1_73ck1520 FIND v(dout1_73) AT=765.025n

.meas tran vdout1_74ck1520 FIND v(dout1_74) AT=765.025n

.meas tran vdout1_75ck1520 FIND v(dout1_75) AT=765.025n

.meas tran vdout1_76ck1520 FIND v(dout1_76) AT=765.025n

.meas tran vdout1_77ck1520 FIND v(dout1_77) AT=765.025n

.meas tran vdout1_78ck1520 FIND v(dout1_78) AT=765.025n

.meas tran vdout1_79ck1520 FIND v(dout1_79) AT=765.025n

.meas tran vdout1_80ck1520 FIND v(dout1_80) AT=765.025n

.meas tran vdout1_81ck1520 FIND v(dout1_81) AT=765.025n

.meas tran vdout1_82ck1520 FIND v(dout1_82) AT=765.025n

.meas tran vdout1_83ck1520 FIND v(dout1_83) AT=765.025n

.meas tran vdout1_84ck1520 FIND v(dout1_84) AT=765.025n

.meas tran vdout1_85ck1520 FIND v(dout1_85) AT=765.025n

.meas tran vdout1_86ck1520 FIND v(dout1_86) AT=765.025n

.meas tran vdout1_87ck1520 FIND v(dout1_87) AT=765.025n

.meas tran vdout1_88ck1520 FIND v(dout1_88) AT=765.025n

.meas tran vdout1_89ck1520 FIND v(dout1_89) AT=765.025n

.meas tran vdout1_90ck1520 FIND v(dout1_90) AT=765.025n

.meas tran vdout1_91ck1520 FIND v(dout1_91) AT=765.025n

.meas tran vdout1_92ck1520 FIND v(dout1_92) AT=765.025n

.meas tran vdout1_93ck1520 FIND v(dout1_93) AT=765.025n

.meas tran vdout1_94ck1520 FIND v(dout1_94) AT=765.025n

.meas tran vdout1_95ck1520 FIND v(dout1_95) AT=765.025n

.meas tran vdout1_96ck1520 FIND v(dout1_96) AT=765.025n

.meas tran vdout1_97ck1520 FIND v(dout1_97) AT=765.025n

.meas tran vdout1_98ck1520 FIND v(dout1_98) AT=765.025n

.meas tran vdout1_99ck1520 FIND v(dout1_99) AT=765.025n

.meas tran vdout1_100ck1520 FIND v(dout1_100) AT=765.025n

.meas tran vdout1_101ck1520 FIND v(dout1_101) AT=765.025n

.meas tran vdout1_102ck1520 FIND v(dout1_102) AT=765.025n

.meas tran vdout1_103ck1520 FIND v(dout1_103) AT=765.025n

.meas tran vdout1_104ck1520 FIND v(dout1_104) AT=765.025n

.meas tran vdout1_105ck1520 FIND v(dout1_105) AT=765.025n

.meas tran vdout1_106ck1520 FIND v(dout1_106) AT=765.025n

.meas tran vdout1_107ck1520 FIND v(dout1_107) AT=765.025n

.meas tran vdout1_108ck1520 FIND v(dout1_108) AT=765.025n

.meas tran vdout1_109ck1520 FIND v(dout1_109) AT=765.025n

.meas tran vdout1_110ck1520 FIND v(dout1_110) AT=765.025n

.meas tran vdout1_111ck1520 FIND v(dout1_111) AT=765.025n

.meas tran vdout1_112ck1520 FIND v(dout1_112) AT=765.025n

.meas tran vdout1_113ck1520 FIND v(dout1_113) AT=765.025n

.meas tran vdout1_114ck1520 FIND v(dout1_114) AT=765.025n

.meas tran vdout1_115ck1520 FIND v(dout1_115) AT=765.025n

.meas tran vdout1_116ck1520 FIND v(dout1_116) AT=765.025n

.meas tran vdout1_117ck1520 FIND v(dout1_117) AT=765.025n

.meas tran vdout1_118ck1520 FIND v(dout1_118) AT=765.025n

.meas tran vdout1_119ck1520 FIND v(dout1_119) AT=765.025n

.meas tran vdout1_120ck1520 FIND v(dout1_120) AT=765.025n

.meas tran vdout1_121ck1520 FIND v(dout1_121) AT=765.025n

.meas tran vdout1_122ck1520 FIND v(dout1_122) AT=765.025n

.meas tran vdout1_123ck1520 FIND v(dout1_123) AT=765.025n

.meas tran vdout1_124ck1520 FIND v(dout1_124) AT=765.025n

.meas tran vdout1_125ck1520 FIND v(dout1_125) AT=765.025n

.meas tran vdout1_126ck1520 FIND v(dout1_126) AT=765.025n

.meas tran vdout1_127ck1520 FIND v(dout1_127) AT=765.025n

.meas tran vdout1_128ck1520 FIND v(dout1_128) AT=765.025n

.meas tran vdout1_129ck1520 FIND v(dout1_129) AT=765.025n

.meas tran vdout1_130ck1520 FIND v(dout1_130) AT=765.025n

.meas tran vdout1_131ck1520 FIND v(dout1_131) AT=765.025n

.meas tran vdout1_132ck1520 FIND v(dout1_132) AT=765.025n

.meas tran vdout1_133ck1520 FIND v(dout1_133) AT=765.025n

.meas tran vdout1_134ck1520 FIND v(dout1_134) AT=765.025n

.meas tran vdout1_135ck1520 FIND v(dout1_135) AT=765.025n

.meas tran vdout1_136ck1520 FIND v(dout1_136) AT=765.025n

.meas tran vdout1_137ck1520 FIND v(dout1_137) AT=765.025n

.meas tran vdout1_138ck1520 FIND v(dout1_138) AT=765.025n

.meas tran vdout1_139ck1520 FIND v(dout1_139) AT=765.025n

.meas tran vdout1_140ck1520 FIND v(dout1_140) AT=765.025n

.meas tran vdout1_141ck1520 FIND v(dout1_141) AT=765.025n

.meas tran vdout1_142ck1520 FIND v(dout1_142) AT=765.025n

.meas tran vdout1_143ck1520 FIND v(dout1_143) AT=765.025n

.meas tran vdout1_144ck1520 FIND v(dout1_144) AT=765.025n

.meas tran vdout1_145ck1520 FIND v(dout1_145) AT=765.025n

.meas tran vdout1_146ck1520 FIND v(dout1_146) AT=765.025n

.meas tran vdout1_147ck1520 FIND v(dout1_147) AT=765.025n

.meas tran vdout1_148ck1520 FIND v(dout1_148) AT=765.025n

.meas tran vdout1_149ck1520 FIND v(dout1_149) AT=765.025n

.meas tran vdout1_150ck1520 FIND v(dout1_150) AT=765.025n

.meas tran vdout1_151ck1520 FIND v(dout1_151) AT=765.025n

.meas tran vdout1_152ck1520 FIND v(dout1_152) AT=765.025n

.meas tran vdout1_153ck1520 FIND v(dout1_153) AT=765.025n

.meas tran vdout1_154ck1520 FIND v(dout1_154) AT=765.025n

.meas tran vdout1_155ck1520 FIND v(dout1_155) AT=765.025n

.meas tran vdout1_156ck1520 FIND v(dout1_156) AT=765.025n

.meas tran vdout1_157ck1520 FIND v(dout1_157) AT=765.025n

.meas tran vdout1_158ck1520 FIND v(dout1_158) AT=765.025n

.meas tran vdout1_159ck1520 FIND v(dout1_159) AT=765.025n

.meas tran vdout1_160ck1520 FIND v(dout1_160) AT=765.025n

.meas tran vdout1_161ck1520 FIND v(dout1_161) AT=765.025n

.meas tran vdout1_162ck1520 FIND v(dout1_162) AT=765.025n

.meas tran vdout1_163ck1520 FIND v(dout1_163) AT=765.025n

.meas tran vdout1_164ck1520 FIND v(dout1_164) AT=765.025n

.meas tran vdout1_165ck1520 FIND v(dout1_165) AT=765.025n

.meas tran vdout1_166ck1520 FIND v(dout1_166) AT=765.025n

.meas tran vdout1_167ck1520 FIND v(dout1_167) AT=765.025n

.meas tran vdout1_168ck1520 FIND v(dout1_168) AT=765.025n

.meas tran vdout1_169ck1520 FIND v(dout1_169) AT=765.025n

.meas tran vdout1_170ck1520 FIND v(dout1_170) AT=765.025n

.meas tran vdout1_171ck1520 FIND v(dout1_171) AT=765.025n

.meas tran vdout1_172ck1520 FIND v(dout1_172) AT=765.025n

.meas tran vdout1_173ck1520 FIND v(dout1_173) AT=765.025n

.meas tran vdout1_174ck1520 FIND v(dout1_174) AT=765.025n

.meas tran vdout1_175ck1520 FIND v(dout1_175) AT=765.025n

.meas tran vdout1_176ck1520 FIND v(dout1_176) AT=765.025n

.meas tran vdout1_177ck1520 FIND v(dout1_177) AT=765.025n

.meas tran vdout1_178ck1520 FIND v(dout1_178) AT=765.025n

.meas tran vdout1_179ck1520 FIND v(dout1_179) AT=765.025n

.meas tran vdout1_180ck1520 FIND v(dout1_180) AT=765.025n

.meas tran vdout1_181ck1520 FIND v(dout1_181) AT=765.025n

.meas tran vdout1_182ck1520 FIND v(dout1_182) AT=765.025n

.meas tran vdout1_183ck1520 FIND v(dout1_183) AT=765.025n

.meas tran vdout1_184ck1520 FIND v(dout1_184) AT=765.025n

.meas tran vdout1_185ck1520 FIND v(dout1_185) AT=765.025n

.meas tran vdout1_186ck1520 FIND v(dout1_186) AT=765.025n

.meas tran vdout1_187ck1520 FIND v(dout1_187) AT=765.025n

.meas tran vdout1_188ck1520 FIND v(dout1_188) AT=765.025n

.meas tran vdout1_189ck1520 FIND v(dout1_189) AT=765.025n

.meas tran vdout1_190ck1520 FIND v(dout1_190) AT=765.025n

.meas tran vdout1_191ck1520 FIND v(dout1_191) AT=765.025n

.meas tran vdout1_192ck1520 FIND v(dout1_192) AT=765.025n

.meas tran vdout1_193ck1520 FIND v(dout1_193) AT=765.025n

.meas tran vdout1_194ck1520 FIND v(dout1_194) AT=765.025n

.meas tran vdout1_195ck1520 FIND v(dout1_195) AT=765.025n

.meas tran vdout1_196ck1520 FIND v(dout1_196) AT=765.025n

.meas tran vdout1_197ck1520 FIND v(dout1_197) AT=765.025n

.meas tran vdout1_198ck1520 FIND v(dout1_198) AT=765.025n

.meas tran vdout1_199ck1520 FIND v(dout1_199) AT=765.025n

.meas tran vdout1_200ck1520 FIND v(dout1_200) AT=765.025n

.meas tran vdout1_201ck1520 FIND v(dout1_201) AT=765.025n

.meas tran vdout1_202ck1520 FIND v(dout1_202) AT=765.025n

.meas tran vdout1_203ck1520 FIND v(dout1_203) AT=765.025n

.meas tran vdout1_204ck1520 FIND v(dout1_204) AT=765.025n

.meas tran vdout1_205ck1520 FIND v(dout1_205) AT=765.025n

.meas tran vdout1_206ck1520 FIND v(dout1_206) AT=765.025n

.meas tran vdout1_207ck1520 FIND v(dout1_207) AT=765.025n

.meas tran vdout1_208ck1520 FIND v(dout1_208) AT=765.025n

.meas tran vdout1_209ck1520 FIND v(dout1_209) AT=765.025n

.meas tran vdout1_210ck1520 FIND v(dout1_210) AT=765.025n

.meas tran vdout1_211ck1520 FIND v(dout1_211) AT=765.025n

.meas tran vdout1_212ck1520 FIND v(dout1_212) AT=765.025n

.meas tran vdout1_213ck1520 FIND v(dout1_213) AT=765.025n

.meas tran vdout1_214ck1520 FIND v(dout1_214) AT=765.025n

.meas tran vdout1_215ck1520 FIND v(dout1_215) AT=765.025n

.meas tran vdout1_216ck1520 FIND v(dout1_216) AT=765.025n

.meas tran vdout1_217ck1520 FIND v(dout1_217) AT=765.025n

.meas tran vdout1_218ck1520 FIND v(dout1_218) AT=765.025n

.meas tran vdout1_219ck1520 FIND v(dout1_219) AT=765.025n

.meas tran vdout1_220ck1520 FIND v(dout1_220) AT=765.025n

.meas tran vdout1_221ck1520 FIND v(dout1_221) AT=765.025n

.meas tran vdout1_222ck1520 FIND v(dout1_222) AT=765.025n

.meas tran vdout1_223ck1520 FIND v(dout1_223) AT=765.025n

.meas tran vdout1_224ck1520 FIND v(dout1_224) AT=765.025n

.meas tran vdout1_225ck1520 FIND v(dout1_225) AT=765.025n

.meas tran vdout1_226ck1520 FIND v(dout1_226) AT=765.025n

.meas tran vdout1_227ck1520 FIND v(dout1_227) AT=765.025n

.meas tran vdout1_228ck1520 FIND v(dout1_228) AT=765.025n

.meas tran vdout1_229ck1520 FIND v(dout1_229) AT=765.025n

.meas tran vdout1_230ck1520 FIND v(dout1_230) AT=765.025n

.meas tran vdout1_231ck1520 FIND v(dout1_231) AT=765.025n

.meas tran vdout1_232ck1520 FIND v(dout1_232) AT=765.025n

.meas tran vdout1_233ck1520 FIND v(dout1_233) AT=765.025n

.meas tran vdout1_234ck1520 FIND v(dout1_234) AT=765.025n

.meas tran vdout1_235ck1520 FIND v(dout1_235) AT=765.025n

.meas tran vdout1_236ck1520 FIND v(dout1_236) AT=765.025n

.meas tran vdout1_237ck1520 FIND v(dout1_237) AT=765.025n

.meas tran vdout1_238ck1520 FIND v(dout1_238) AT=765.025n

.meas tran vdout1_239ck1520 FIND v(dout1_239) AT=765.025n

.meas tran vdout1_240ck1520 FIND v(dout1_240) AT=765.025n

.meas tran vdout1_241ck1520 FIND v(dout1_241) AT=765.025n

.meas tran vdout1_242ck1520 FIND v(dout1_242) AT=765.025n

.meas tran vdout1_243ck1520 FIND v(dout1_243) AT=765.025n

.meas tran vdout1_244ck1520 FIND v(dout1_244) AT=765.025n

.meas tran vdout1_245ck1520 FIND v(dout1_245) AT=765.025n

.meas tran vdout1_246ck1520 FIND v(dout1_246) AT=765.025n

.meas tran vdout1_247ck1520 FIND v(dout1_247) AT=765.025n

.meas tran vdout1_248ck1520 FIND v(dout1_248) AT=765.025n

.meas tran vdout1_249ck1520 FIND v(dout1_249) AT=765.025n

.meas tran vdout1_250ck1520 FIND v(dout1_250) AT=765.025n

.meas tran vdout1_251ck1520 FIND v(dout1_251) AT=765.025n

.meas tran vdout1_252ck1520 FIND v(dout1_252) AT=765.025n

.meas tran vdout1_253ck1520 FIND v(dout1_253) AT=765.025n

.meas tran vdout1_254ck1520 FIND v(dout1_254) AT=765.025n

.meas tran vdout1_255ck1520 FIND v(dout1_255) AT=765.025n

.meas tran vdout1_256ck1520 FIND v(dout1_256) AT=765.025n

.meas tran vdout1_257ck1520 FIND v(dout1_257) AT=765.025n

.meas tran vdout1_258ck1520 FIND v(dout1_258) AT=765.025n

.meas tran vdout1_259ck1520 FIND v(dout1_259) AT=765.025n

.meas tran vdout1_260ck1520 FIND v(dout1_260) AT=765.025n

.meas tran vdout1_261ck1520 FIND v(dout1_261) AT=765.025n

.meas tran vdout1_262ck1520 FIND v(dout1_262) AT=765.025n

.meas tran vdout1_263ck1520 FIND v(dout1_263) AT=765.025n

.meas tran vdout1_264ck1520 FIND v(dout1_264) AT=765.025n

.meas tran vdout1_265ck1520 FIND v(dout1_265) AT=765.025n

.meas tran vdout1_266ck1520 FIND v(dout1_266) AT=765.025n

.meas tran vdout1_267ck1520 FIND v(dout1_267) AT=765.025n

.meas tran vdout1_268ck1520 FIND v(dout1_268) AT=765.025n

.meas tran vdout1_269ck1520 FIND v(dout1_269) AT=765.025n

.meas tran vdout1_270ck1520 FIND v(dout1_270) AT=765.025n

.meas tran vdout1_271ck1520 FIND v(dout1_271) AT=765.025n

.meas tran vdout1_272ck1520 FIND v(dout1_272) AT=765.025n

.meas tran vdout1_273ck1520 FIND v(dout1_273) AT=765.025n

.meas tran vdout1_274ck1520 FIND v(dout1_274) AT=765.025n

.meas tran vdout1_275ck1520 FIND v(dout1_275) AT=765.025n

.meas tran vdout1_276ck1520 FIND v(dout1_276) AT=765.025n

.meas tran vdout1_277ck1520 FIND v(dout1_277) AT=765.025n

.meas tran vdout1_278ck1520 FIND v(dout1_278) AT=765.025n

.meas tran vdout1_279ck1520 FIND v(dout1_279) AT=765.025n

.meas tran vdout1_280ck1520 FIND v(dout1_280) AT=765.025n

.meas tran vdout1_281ck1520 FIND v(dout1_281) AT=765.025n

.meas tran vdout1_282ck1520 FIND v(dout1_282) AT=765.025n

.meas tran vdout1_283ck1520 FIND v(dout1_283) AT=765.025n

.meas tran vdout1_284ck1520 FIND v(dout1_284) AT=765.025n

.meas tran vdout1_285ck1520 FIND v(dout1_285) AT=765.025n

.meas tran vdout1_286ck1520 FIND v(dout1_286) AT=765.025n

.meas tran vdout1_287ck1520 FIND v(dout1_287) AT=765.025n

.meas tran vdout1_288ck1520 FIND v(dout1_288) AT=765.025n

.meas tran vdout1_289ck1520 FIND v(dout1_289) AT=765.025n

.meas tran vdout1_290ck1520 FIND v(dout1_290) AT=765.025n

.meas tran vdout1_291ck1520 FIND v(dout1_291) AT=765.025n

.meas tran vdout1_292ck1520 FIND v(dout1_292) AT=765.025n

.meas tran vdout1_293ck1520 FIND v(dout1_293) AT=765.025n

.meas tran vdout1_294ck1520 FIND v(dout1_294) AT=765.025n

.meas tran vdout1_295ck1520 FIND v(dout1_295) AT=765.025n

.meas tran vdout1_296ck1520 FIND v(dout1_296) AT=765.025n

.meas tran vdout1_297ck1520 FIND v(dout1_297) AT=765.025n

.meas tran vdout1_298ck1520 FIND v(dout1_298) AT=765.025n

.meas tran vdout1_299ck1520 FIND v(dout1_299) AT=765.025n

.meas tran vdout1_300ck1520 FIND v(dout1_300) AT=765.025n

.meas tran vdout1_301ck1520 FIND v(dout1_301) AT=765.025n

.meas tran vdout1_302ck1520 FIND v(dout1_302) AT=765.025n

.meas tran vdout1_303ck1520 FIND v(dout1_303) AT=765.025n

.meas tran vdout1_304ck1520 FIND v(dout1_304) AT=765.025n

.meas tran vdout1_305ck1520 FIND v(dout1_305) AT=765.025n

.meas tran vdout1_306ck1520 FIND v(dout1_306) AT=765.025n

.meas tran vdout1_307ck1520 FIND v(dout1_307) AT=765.025n

.meas tran vdout1_308ck1520 FIND v(dout1_308) AT=765.025n

.meas tran vdout1_309ck1520 FIND v(dout1_309) AT=765.025n

.meas tran vdout1_310ck1520 FIND v(dout1_310) AT=765.025n

.meas tran vdout1_311ck1520 FIND v(dout1_311) AT=765.025n

.meas tran vdout1_312ck1520 FIND v(dout1_312) AT=765.025n

.meas tran vdout1_313ck1520 FIND v(dout1_313) AT=765.025n

.meas tran vdout1_314ck1520 FIND v(dout1_314) AT=765.025n

.meas tran vdout1_315ck1520 FIND v(dout1_315) AT=765.025n

.meas tran vdout1_316ck1520 FIND v(dout1_316) AT=765.025n

.meas tran vdout1_317ck1520 FIND v(dout1_317) AT=765.025n

.meas tran vdout1_318ck1520 FIND v(dout1_318) AT=765.025n

.meas tran vdout1_319ck1520 FIND v(dout1_319) AT=765.025n

.meas tran vdout1_320ck1520 FIND v(dout1_320) AT=765.025n

.meas tran vdout1_321ck1520 FIND v(dout1_321) AT=765.025n

.meas tran vdout1_322ck1520 FIND v(dout1_322) AT=765.025n

.meas tran vdout1_323ck1520 FIND v(dout1_323) AT=765.025n

.meas tran vdout1_324ck1520 FIND v(dout1_324) AT=765.025n

.meas tran vdout1_325ck1520 FIND v(dout1_325) AT=765.025n

.meas tran vdout1_326ck1520 FIND v(dout1_326) AT=765.025n

.meas tran vdout1_327ck1520 FIND v(dout1_327) AT=765.025n

.meas tran vdout1_328ck1520 FIND v(dout1_328) AT=765.025n

.meas tran vdout1_329ck1520 FIND v(dout1_329) AT=765.025n

.meas tran vdout1_330ck1520 FIND v(dout1_330) AT=765.025n

.meas tran vdout1_331ck1520 FIND v(dout1_331) AT=765.025n

.meas tran vdout1_332ck1520 FIND v(dout1_332) AT=765.025n

.meas tran vdout1_333ck1520 FIND v(dout1_333) AT=765.025n

.meas tran vdout1_334ck1520 FIND v(dout1_334) AT=765.025n

.meas tran vdout1_335ck1520 FIND v(dout1_335) AT=765.025n

.meas tran vdout1_336ck1520 FIND v(dout1_336) AT=765.025n

.meas tran vdout1_337ck1520 FIND v(dout1_337) AT=765.025n

.meas tran vdout1_338ck1520 FIND v(dout1_338) AT=765.025n

.meas tran vdout1_339ck1520 FIND v(dout1_339) AT=765.025n

.meas tran vdout1_340ck1520 FIND v(dout1_340) AT=765.025n

.meas tran vdout1_341ck1520 FIND v(dout1_341) AT=765.025n

.meas tran vdout1_342ck1520 FIND v(dout1_342) AT=765.025n

.meas tran vdout1_343ck1520 FIND v(dout1_343) AT=765.025n

.meas tran vdout1_344ck1520 FIND v(dout1_344) AT=765.025n

.meas tran vdout1_345ck1520 FIND v(dout1_345) AT=765.025n

.meas tran vdout1_346ck1520 FIND v(dout1_346) AT=765.025n

.meas tran vdout1_347ck1520 FIND v(dout1_347) AT=765.025n

.meas tran vdout1_348ck1520 FIND v(dout1_348) AT=765.025n

.meas tran vdout1_349ck1520 FIND v(dout1_349) AT=765.025n

.meas tran vdout1_350ck1520 FIND v(dout1_350) AT=765.025n

.meas tran vdout1_351ck1520 FIND v(dout1_351) AT=765.025n

.meas tran vdout1_352ck1520 FIND v(dout1_352) AT=765.025n

.meas tran vdout1_353ck1520 FIND v(dout1_353) AT=765.025n

.meas tran vdout1_354ck1520 FIND v(dout1_354) AT=765.025n

.meas tran vdout1_355ck1520 FIND v(dout1_355) AT=765.025n

.meas tran vdout1_356ck1520 FIND v(dout1_356) AT=765.025n

.meas tran vdout1_357ck1520 FIND v(dout1_357) AT=765.025n

.meas tran vdout1_358ck1520 FIND v(dout1_358) AT=765.025n

.meas tran vdout1_359ck1520 FIND v(dout1_359) AT=765.025n

.meas tran vdout1_360ck1520 FIND v(dout1_360) AT=765.025n

.meas tran vdout1_361ck1520 FIND v(dout1_361) AT=765.025n

.meas tran vdout1_362ck1520 FIND v(dout1_362) AT=765.025n

.meas tran vdout1_363ck1520 FIND v(dout1_363) AT=765.025n

.meas tran vdout1_364ck1520 FIND v(dout1_364) AT=765.025n

.meas tran vdout1_365ck1520 FIND v(dout1_365) AT=765.025n

.meas tran vdout1_366ck1520 FIND v(dout1_366) AT=765.025n

.meas tran vdout1_367ck1520 FIND v(dout1_367) AT=765.025n

.meas tran vdout1_368ck1520 FIND v(dout1_368) AT=765.025n

.meas tran vdout1_369ck1520 FIND v(dout1_369) AT=765.025n

.meas tran vdout1_370ck1520 FIND v(dout1_370) AT=765.025n

.meas tran vdout1_371ck1520 FIND v(dout1_371) AT=765.025n

.meas tran vdout1_372ck1520 FIND v(dout1_372) AT=765.025n

.meas tran vdout1_373ck1520 FIND v(dout1_373) AT=765.025n

.meas tran vdout1_374ck1520 FIND v(dout1_374) AT=765.025n

.meas tran vdout1_375ck1520 FIND v(dout1_375) AT=765.025n

.meas tran vdout1_376ck1520 FIND v(dout1_376) AT=765.025n

.meas tran vdout1_377ck1520 FIND v(dout1_377) AT=765.025n

.meas tran vdout1_378ck1520 FIND v(dout1_378) AT=765.025n

.meas tran vdout1_379ck1520 FIND v(dout1_379) AT=765.025n

.meas tran vdout1_380ck1520 FIND v(dout1_380) AT=765.025n

.meas tran vdout1_381ck1520 FIND v(dout1_381) AT=765.025n

.meas tran vdout1_382ck1520 FIND v(dout1_382) AT=765.025n

.meas tran vdout1_383ck1520 FIND v(dout1_383) AT=765.025n

.meas tran vdout1_384ck1520 FIND v(dout1_384) AT=765.025n

.meas tran vdout1_385ck1520 FIND v(dout1_385) AT=765.025n

.meas tran vdout1_386ck1520 FIND v(dout1_386) AT=765.025n

.meas tran vdout1_387ck1520 FIND v(dout1_387) AT=765.025n

.meas tran vdout1_388ck1520 FIND v(dout1_388) AT=765.025n

.meas tran vdout1_389ck1520 FIND v(dout1_389) AT=765.025n

.meas tran vdout1_390ck1520 FIND v(dout1_390) AT=765.025n

.meas tran vdout1_391ck1520 FIND v(dout1_391) AT=765.025n

.meas tran vdout1_392ck1520 FIND v(dout1_392) AT=765.025n

.meas tran vdout1_393ck1520 FIND v(dout1_393) AT=765.025n

.meas tran vdout1_394ck1520 FIND v(dout1_394) AT=765.025n

.meas tran vdout1_395ck1520 FIND v(dout1_395) AT=765.025n

.meas tran vdout1_396ck1520 FIND v(dout1_396) AT=765.025n

.meas tran vdout1_397ck1520 FIND v(dout1_397) AT=765.025n

.meas tran vdout1_398ck1520 FIND v(dout1_398) AT=765.025n

.meas tran vdout1_399ck1520 FIND v(dout1_399) AT=765.025n

.meas tran vdout1_400ck1520 FIND v(dout1_400) AT=765.025n

.meas tran vdout1_401ck1520 FIND v(dout1_401) AT=765.025n

.meas tran vdout1_402ck1520 FIND v(dout1_402) AT=765.025n

.meas tran vdout1_403ck1520 FIND v(dout1_403) AT=765.025n

.meas tran vdout1_404ck1520 FIND v(dout1_404) AT=765.025n

.meas tran vdout1_405ck1520 FIND v(dout1_405) AT=765.025n

.meas tran vdout1_406ck1520 FIND v(dout1_406) AT=765.025n

.meas tran vdout1_407ck1520 FIND v(dout1_407) AT=765.025n

.meas tran vdout1_408ck1520 FIND v(dout1_408) AT=765.025n

.meas tran vdout1_409ck1520 FIND v(dout1_409) AT=765.025n

.meas tran vdout1_410ck1520 FIND v(dout1_410) AT=765.025n

.meas tran vdout1_411ck1520 FIND v(dout1_411) AT=765.025n

.meas tran vdout1_412ck1520 FIND v(dout1_412) AT=765.025n

.meas tran vdout1_413ck1520 FIND v(dout1_413) AT=765.025n

.meas tran vdout1_414ck1520 FIND v(dout1_414) AT=765.025n

.meas tran vdout1_415ck1520 FIND v(dout1_415) AT=765.025n

.meas tran vdout1_416ck1520 FIND v(dout1_416) AT=765.025n

.meas tran vdout1_417ck1520 FIND v(dout1_417) AT=765.025n

.meas tran vdout1_418ck1520 FIND v(dout1_418) AT=765.025n

.meas tran vdout1_419ck1520 FIND v(dout1_419) AT=765.025n

.meas tran vdout1_420ck1520 FIND v(dout1_420) AT=765.025n

.meas tran vdout1_421ck1520 FIND v(dout1_421) AT=765.025n

.meas tran vdout1_422ck1520 FIND v(dout1_422) AT=765.025n

.meas tran vdout1_423ck1520 FIND v(dout1_423) AT=765.025n

.meas tran vdout1_424ck1520 FIND v(dout1_424) AT=765.025n

.meas tran vdout1_425ck1520 FIND v(dout1_425) AT=765.025n

.meas tran vdout1_426ck1520 FIND v(dout1_426) AT=765.025n

.meas tran vdout1_427ck1520 FIND v(dout1_427) AT=765.025n

.meas tran vdout1_428ck1520 FIND v(dout1_428) AT=765.025n

.meas tran vdout1_429ck1520 FIND v(dout1_429) AT=765.025n

.meas tran vdout1_430ck1520 FIND v(dout1_430) AT=765.025n

.meas tran vdout1_431ck1520 FIND v(dout1_431) AT=765.025n

.meas tran vdout1_432ck1520 FIND v(dout1_432) AT=765.025n

.meas tran vdout1_433ck1520 FIND v(dout1_433) AT=765.025n

.meas tran vdout1_434ck1520 FIND v(dout1_434) AT=765.025n

.meas tran vdout1_435ck1520 FIND v(dout1_435) AT=765.025n

.meas tran vdout1_436ck1520 FIND v(dout1_436) AT=765.025n

.meas tran vdout1_437ck1520 FIND v(dout1_437) AT=765.025n

.meas tran vdout1_438ck1520 FIND v(dout1_438) AT=765.025n

.meas tran vdout1_439ck1520 FIND v(dout1_439) AT=765.025n

.meas tran vdout1_440ck1520 FIND v(dout1_440) AT=765.025n

.meas tran vdout1_441ck1520 FIND v(dout1_441) AT=765.025n

.meas tran vdout1_442ck1520 FIND v(dout1_442) AT=765.025n

.meas tran vdout1_443ck1520 FIND v(dout1_443) AT=765.025n

.meas tran vdout1_444ck1520 FIND v(dout1_444) AT=765.025n

.meas tran vdout1_445ck1520 FIND v(dout1_445) AT=765.025n

.meas tran vdout1_446ck1520 FIND v(dout1_446) AT=765.025n

.meas tran vdout1_447ck1520 FIND v(dout1_447) AT=765.025n

.meas tran vdout1_448ck1520 FIND v(dout1_448) AT=765.025n

.meas tran vdout1_449ck1520 FIND v(dout1_449) AT=765.025n

.meas tran vdout1_450ck1520 FIND v(dout1_450) AT=765.025n

.meas tran vdout1_451ck1520 FIND v(dout1_451) AT=765.025n

.meas tran vdout1_452ck1520 FIND v(dout1_452) AT=765.025n

.meas tran vdout1_453ck1520 FIND v(dout1_453) AT=765.025n

.meas tran vdout1_454ck1520 FIND v(dout1_454) AT=765.025n

.meas tran vdout1_455ck1520 FIND v(dout1_455) AT=765.025n

.meas tran vdout1_456ck1520 FIND v(dout1_456) AT=765.025n

.meas tran vdout1_457ck1520 FIND v(dout1_457) AT=765.025n

.meas tran vdout1_458ck1520 FIND v(dout1_458) AT=765.025n

.meas tran vdout1_459ck1520 FIND v(dout1_459) AT=765.025n

.meas tran vdout1_460ck1520 FIND v(dout1_460) AT=765.025n

.meas tran vdout1_461ck1520 FIND v(dout1_461) AT=765.025n

.meas tran vdout1_462ck1520 FIND v(dout1_462) AT=765.025n

.meas tran vdout1_463ck1520 FIND v(dout1_463) AT=765.025n

.meas tran vdout1_464ck1520 FIND v(dout1_464) AT=765.025n

.meas tran vdout1_465ck1520 FIND v(dout1_465) AT=765.025n

.meas tran vdout1_466ck1520 FIND v(dout1_466) AT=765.025n

.meas tran vdout1_467ck1520 FIND v(dout1_467) AT=765.025n

.meas tran vdout1_468ck1520 FIND v(dout1_468) AT=765.025n

.meas tran vdout1_469ck1520 FIND v(dout1_469) AT=765.025n

.meas tran vdout1_470ck1520 FIND v(dout1_470) AT=765.025n

.meas tran vdout1_471ck1520 FIND v(dout1_471) AT=765.025n

.meas tran vdout1_472ck1520 FIND v(dout1_472) AT=765.025n

.meas tran vdout1_473ck1520 FIND v(dout1_473) AT=765.025n

.meas tran vdout1_474ck1520 FIND v(dout1_474) AT=765.025n

.meas tran vdout1_475ck1520 FIND v(dout1_475) AT=765.025n

.meas tran vdout1_476ck1520 FIND v(dout1_476) AT=765.025n

.meas tran vdout1_477ck1520 FIND v(dout1_477) AT=765.025n

.meas tran vdout1_478ck1520 FIND v(dout1_478) AT=765.025n

.meas tran vdout1_479ck1520 FIND v(dout1_479) AT=765.025n

.meas tran vdout1_480ck1520 FIND v(dout1_480) AT=765.025n

.meas tran vdout1_481ck1520 FIND v(dout1_481) AT=765.025n

.meas tran vdout1_482ck1520 FIND v(dout1_482) AT=765.025n

.meas tran vdout1_483ck1520 FIND v(dout1_483) AT=765.025n

.meas tran vdout1_484ck1520 FIND v(dout1_484) AT=765.025n

.meas tran vdout1_485ck1520 FIND v(dout1_485) AT=765.025n

.meas tran vdout1_486ck1520 FIND v(dout1_486) AT=765.025n

.meas tran vdout1_487ck1520 FIND v(dout1_487) AT=765.025n

.meas tran vdout1_488ck1520 FIND v(dout1_488) AT=765.025n

.meas tran vdout1_489ck1520 FIND v(dout1_489) AT=765.025n

.meas tran vdout1_490ck1520 FIND v(dout1_490) AT=765.025n

.meas tran vdout1_491ck1520 FIND v(dout1_491) AT=765.025n

.meas tran vdout1_492ck1520 FIND v(dout1_492) AT=765.025n

.meas tran vdout1_493ck1520 FIND v(dout1_493) AT=765.025n

.meas tran vdout1_494ck1520 FIND v(dout1_494) AT=765.025n

.meas tran vdout1_495ck1520 FIND v(dout1_495) AT=765.025n

.meas tran vdout1_496ck1520 FIND v(dout1_496) AT=765.025n

.meas tran vdout1_497ck1520 FIND v(dout1_497) AT=765.025n

.meas tran vdout1_498ck1520 FIND v(dout1_498) AT=765.025n

.meas tran vdout1_499ck1520 FIND v(dout1_499) AT=765.025n

.meas tran vdout1_500ck1520 FIND v(dout1_500) AT=765.025n

.meas tran vdout1_501ck1520 FIND v(dout1_501) AT=765.025n

.meas tran vdout1_502ck1520 FIND v(dout1_502) AT=765.025n

.meas tran vdout1_503ck1520 FIND v(dout1_503) AT=765.025n

.meas tran vdout1_504ck1520 FIND v(dout1_504) AT=765.025n

.meas tran vdout1_505ck1520 FIND v(dout1_505) AT=765.025n

.meas tran vdout1_506ck1520 FIND v(dout1_506) AT=765.025n

.meas tran vdout1_507ck1520 FIND v(dout1_507) AT=765.025n

.meas tran vdout1_508ck1520 FIND v(dout1_508) AT=765.025n

.meas tran vdout1_509ck1520 FIND v(dout1_509) AT=765.025n

.meas tran vdout1_510ck1520 FIND v(dout1_510) AT=765.025n

.meas tran vdout1_511ck1520 FIND v(dout1_511) AT=765.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_32ck1580 FIND v(dout1_32) AT=795.025n

.meas tran vdout1_33ck1580 FIND v(dout1_33) AT=795.025n

.meas tran vdout1_34ck1580 FIND v(dout1_34) AT=795.025n

.meas tran vdout1_35ck1580 FIND v(dout1_35) AT=795.025n

.meas tran vdout1_36ck1580 FIND v(dout1_36) AT=795.025n

.meas tran vdout1_37ck1580 FIND v(dout1_37) AT=795.025n

.meas tran vdout1_38ck1580 FIND v(dout1_38) AT=795.025n

.meas tran vdout1_39ck1580 FIND v(dout1_39) AT=795.025n

.meas tran vdout1_40ck1580 FIND v(dout1_40) AT=795.025n

.meas tran vdout1_41ck1580 FIND v(dout1_41) AT=795.025n

.meas tran vdout1_42ck1580 FIND v(dout1_42) AT=795.025n

.meas tran vdout1_43ck1580 FIND v(dout1_43) AT=795.025n

.meas tran vdout1_44ck1580 FIND v(dout1_44) AT=795.025n

.meas tran vdout1_45ck1580 FIND v(dout1_45) AT=795.025n

.meas tran vdout1_46ck1580 FIND v(dout1_46) AT=795.025n

.meas tran vdout1_47ck1580 FIND v(dout1_47) AT=795.025n

.meas tran vdout1_48ck1580 FIND v(dout1_48) AT=795.025n

.meas tran vdout1_49ck1580 FIND v(dout1_49) AT=795.025n

.meas tran vdout1_50ck1580 FIND v(dout1_50) AT=795.025n

.meas tran vdout1_51ck1580 FIND v(dout1_51) AT=795.025n

.meas tran vdout1_52ck1580 FIND v(dout1_52) AT=795.025n

.meas tran vdout1_53ck1580 FIND v(dout1_53) AT=795.025n

.meas tran vdout1_54ck1580 FIND v(dout1_54) AT=795.025n

.meas tran vdout1_55ck1580 FIND v(dout1_55) AT=795.025n

.meas tran vdout1_56ck1580 FIND v(dout1_56) AT=795.025n

.meas tran vdout1_57ck1580 FIND v(dout1_57) AT=795.025n

.meas tran vdout1_58ck1580 FIND v(dout1_58) AT=795.025n

.meas tran vdout1_59ck1580 FIND v(dout1_59) AT=795.025n

.meas tran vdout1_60ck1580 FIND v(dout1_60) AT=795.025n

.meas tran vdout1_61ck1580 FIND v(dout1_61) AT=795.025n

.meas tran vdout1_62ck1580 FIND v(dout1_62) AT=795.025n

.meas tran vdout1_63ck1580 FIND v(dout1_63) AT=795.025n

.meas tran vdout1_64ck1580 FIND v(dout1_64) AT=795.025n

.meas tran vdout1_65ck1580 FIND v(dout1_65) AT=795.025n

.meas tran vdout1_66ck1580 FIND v(dout1_66) AT=795.025n

.meas tran vdout1_67ck1580 FIND v(dout1_67) AT=795.025n

.meas tran vdout1_68ck1580 FIND v(dout1_68) AT=795.025n

.meas tran vdout1_69ck1580 FIND v(dout1_69) AT=795.025n

.meas tran vdout1_70ck1580 FIND v(dout1_70) AT=795.025n

.meas tran vdout1_71ck1580 FIND v(dout1_71) AT=795.025n

.meas tran vdout1_72ck1580 FIND v(dout1_72) AT=795.025n

.meas tran vdout1_73ck1580 FIND v(dout1_73) AT=795.025n

.meas tran vdout1_74ck1580 FIND v(dout1_74) AT=795.025n

.meas tran vdout1_75ck1580 FIND v(dout1_75) AT=795.025n

.meas tran vdout1_76ck1580 FIND v(dout1_76) AT=795.025n

.meas tran vdout1_77ck1580 FIND v(dout1_77) AT=795.025n

.meas tran vdout1_78ck1580 FIND v(dout1_78) AT=795.025n

.meas tran vdout1_79ck1580 FIND v(dout1_79) AT=795.025n

.meas tran vdout1_80ck1580 FIND v(dout1_80) AT=795.025n

.meas tran vdout1_81ck1580 FIND v(dout1_81) AT=795.025n

.meas tran vdout1_82ck1580 FIND v(dout1_82) AT=795.025n

.meas tran vdout1_83ck1580 FIND v(dout1_83) AT=795.025n

.meas tran vdout1_84ck1580 FIND v(dout1_84) AT=795.025n

.meas tran vdout1_85ck1580 FIND v(dout1_85) AT=795.025n

.meas tran vdout1_86ck1580 FIND v(dout1_86) AT=795.025n

.meas tran vdout1_87ck1580 FIND v(dout1_87) AT=795.025n

.meas tran vdout1_88ck1580 FIND v(dout1_88) AT=795.025n

.meas tran vdout1_89ck1580 FIND v(dout1_89) AT=795.025n

.meas tran vdout1_90ck1580 FIND v(dout1_90) AT=795.025n

.meas tran vdout1_91ck1580 FIND v(dout1_91) AT=795.025n

.meas tran vdout1_92ck1580 FIND v(dout1_92) AT=795.025n

.meas tran vdout1_93ck1580 FIND v(dout1_93) AT=795.025n

.meas tran vdout1_94ck1580 FIND v(dout1_94) AT=795.025n

.meas tran vdout1_95ck1580 FIND v(dout1_95) AT=795.025n

.meas tran vdout1_96ck1580 FIND v(dout1_96) AT=795.025n

.meas tran vdout1_97ck1580 FIND v(dout1_97) AT=795.025n

.meas tran vdout1_98ck1580 FIND v(dout1_98) AT=795.025n

.meas tran vdout1_99ck1580 FIND v(dout1_99) AT=795.025n

.meas tran vdout1_100ck1580 FIND v(dout1_100) AT=795.025n

.meas tran vdout1_101ck1580 FIND v(dout1_101) AT=795.025n

.meas tran vdout1_102ck1580 FIND v(dout1_102) AT=795.025n

.meas tran vdout1_103ck1580 FIND v(dout1_103) AT=795.025n

.meas tran vdout1_104ck1580 FIND v(dout1_104) AT=795.025n

.meas tran vdout1_105ck1580 FIND v(dout1_105) AT=795.025n

.meas tran vdout1_106ck1580 FIND v(dout1_106) AT=795.025n

.meas tran vdout1_107ck1580 FIND v(dout1_107) AT=795.025n

.meas tran vdout1_108ck1580 FIND v(dout1_108) AT=795.025n

.meas tran vdout1_109ck1580 FIND v(dout1_109) AT=795.025n

.meas tran vdout1_110ck1580 FIND v(dout1_110) AT=795.025n

.meas tran vdout1_111ck1580 FIND v(dout1_111) AT=795.025n

.meas tran vdout1_112ck1580 FIND v(dout1_112) AT=795.025n

.meas tran vdout1_113ck1580 FIND v(dout1_113) AT=795.025n

.meas tran vdout1_114ck1580 FIND v(dout1_114) AT=795.025n

.meas tran vdout1_115ck1580 FIND v(dout1_115) AT=795.025n

.meas tran vdout1_116ck1580 FIND v(dout1_116) AT=795.025n

.meas tran vdout1_117ck1580 FIND v(dout1_117) AT=795.025n

.meas tran vdout1_118ck1580 FIND v(dout1_118) AT=795.025n

.meas tran vdout1_119ck1580 FIND v(dout1_119) AT=795.025n

.meas tran vdout1_120ck1580 FIND v(dout1_120) AT=795.025n

.meas tran vdout1_121ck1580 FIND v(dout1_121) AT=795.025n

.meas tran vdout1_122ck1580 FIND v(dout1_122) AT=795.025n

.meas tran vdout1_123ck1580 FIND v(dout1_123) AT=795.025n

.meas tran vdout1_124ck1580 FIND v(dout1_124) AT=795.025n

.meas tran vdout1_125ck1580 FIND v(dout1_125) AT=795.025n

.meas tran vdout1_126ck1580 FIND v(dout1_126) AT=795.025n

.meas tran vdout1_127ck1580 FIND v(dout1_127) AT=795.025n

.meas tran vdout1_128ck1580 FIND v(dout1_128) AT=795.025n

.meas tran vdout1_129ck1580 FIND v(dout1_129) AT=795.025n

.meas tran vdout1_130ck1580 FIND v(dout1_130) AT=795.025n

.meas tran vdout1_131ck1580 FIND v(dout1_131) AT=795.025n

.meas tran vdout1_132ck1580 FIND v(dout1_132) AT=795.025n

.meas tran vdout1_133ck1580 FIND v(dout1_133) AT=795.025n

.meas tran vdout1_134ck1580 FIND v(dout1_134) AT=795.025n

.meas tran vdout1_135ck1580 FIND v(dout1_135) AT=795.025n

.meas tran vdout1_136ck1580 FIND v(dout1_136) AT=795.025n

.meas tran vdout1_137ck1580 FIND v(dout1_137) AT=795.025n

.meas tran vdout1_138ck1580 FIND v(dout1_138) AT=795.025n

.meas tran vdout1_139ck1580 FIND v(dout1_139) AT=795.025n

.meas tran vdout1_140ck1580 FIND v(dout1_140) AT=795.025n

.meas tran vdout1_141ck1580 FIND v(dout1_141) AT=795.025n

.meas tran vdout1_142ck1580 FIND v(dout1_142) AT=795.025n

.meas tran vdout1_143ck1580 FIND v(dout1_143) AT=795.025n

.meas tran vdout1_144ck1580 FIND v(dout1_144) AT=795.025n

.meas tran vdout1_145ck1580 FIND v(dout1_145) AT=795.025n

.meas tran vdout1_146ck1580 FIND v(dout1_146) AT=795.025n

.meas tran vdout1_147ck1580 FIND v(dout1_147) AT=795.025n

.meas tran vdout1_148ck1580 FIND v(dout1_148) AT=795.025n

.meas tran vdout1_149ck1580 FIND v(dout1_149) AT=795.025n

.meas tran vdout1_150ck1580 FIND v(dout1_150) AT=795.025n

.meas tran vdout1_151ck1580 FIND v(dout1_151) AT=795.025n

.meas tran vdout1_152ck1580 FIND v(dout1_152) AT=795.025n

.meas tran vdout1_153ck1580 FIND v(dout1_153) AT=795.025n

.meas tran vdout1_154ck1580 FIND v(dout1_154) AT=795.025n

.meas tran vdout1_155ck1580 FIND v(dout1_155) AT=795.025n

.meas tran vdout1_156ck1580 FIND v(dout1_156) AT=795.025n

.meas tran vdout1_157ck1580 FIND v(dout1_157) AT=795.025n

.meas tran vdout1_158ck1580 FIND v(dout1_158) AT=795.025n

.meas tran vdout1_159ck1580 FIND v(dout1_159) AT=795.025n

.meas tran vdout1_160ck1580 FIND v(dout1_160) AT=795.025n

.meas tran vdout1_161ck1580 FIND v(dout1_161) AT=795.025n

.meas tran vdout1_162ck1580 FIND v(dout1_162) AT=795.025n

.meas tran vdout1_163ck1580 FIND v(dout1_163) AT=795.025n

.meas tran vdout1_164ck1580 FIND v(dout1_164) AT=795.025n

.meas tran vdout1_165ck1580 FIND v(dout1_165) AT=795.025n

.meas tran vdout1_166ck1580 FIND v(dout1_166) AT=795.025n

.meas tran vdout1_167ck1580 FIND v(dout1_167) AT=795.025n

.meas tran vdout1_168ck1580 FIND v(dout1_168) AT=795.025n

.meas tran vdout1_169ck1580 FIND v(dout1_169) AT=795.025n

.meas tran vdout1_170ck1580 FIND v(dout1_170) AT=795.025n

.meas tran vdout1_171ck1580 FIND v(dout1_171) AT=795.025n

.meas tran vdout1_172ck1580 FIND v(dout1_172) AT=795.025n

.meas tran vdout1_173ck1580 FIND v(dout1_173) AT=795.025n

.meas tran vdout1_174ck1580 FIND v(dout1_174) AT=795.025n

.meas tran vdout1_175ck1580 FIND v(dout1_175) AT=795.025n

.meas tran vdout1_176ck1580 FIND v(dout1_176) AT=795.025n

.meas tran vdout1_177ck1580 FIND v(dout1_177) AT=795.025n

.meas tran vdout1_178ck1580 FIND v(dout1_178) AT=795.025n

.meas tran vdout1_179ck1580 FIND v(dout1_179) AT=795.025n

.meas tran vdout1_180ck1580 FIND v(dout1_180) AT=795.025n

.meas tran vdout1_181ck1580 FIND v(dout1_181) AT=795.025n

.meas tran vdout1_182ck1580 FIND v(dout1_182) AT=795.025n

.meas tran vdout1_183ck1580 FIND v(dout1_183) AT=795.025n

.meas tran vdout1_184ck1580 FIND v(dout1_184) AT=795.025n

.meas tran vdout1_185ck1580 FIND v(dout1_185) AT=795.025n

.meas tran vdout1_186ck1580 FIND v(dout1_186) AT=795.025n

.meas tran vdout1_187ck1580 FIND v(dout1_187) AT=795.025n

.meas tran vdout1_188ck1580 FIND v(dout1_188) AT=795.025n

.meas tran vdout1_189ck1580 FIND v(dout1_189) AT=795.025n

.meas tran vdout1_190ck1580 FIND v(dout1_190) AT=795.025n

.meas tran vdout1_191ck1580 FIND v(dout1_191) AT=795.025n

.meas tran vdout1_192ck1580 FIND v(dout1_192) AT=795.025n

.meas tran vdout1_193ck1580 FIND v(dout1_193) AT=795.025n

.meas tran vdout1_194ck1580 FIND v(dout1_194) AT=795.025n

.meas tran vdout1_195ck1580 FIND v(dout1_195) AT=795.025n

.meas tran vdout1_196ck1580 FIND v(dout1_196) AT=795.025n

.meas tran vdout1_197ck1580 FIND v(dout1_197) AT=795.025n

.meas tran vdout1_198ck1580 FIND v(dout1_198) AT=795.025n

.meas tran vdout1_199ck1580 FIND v(dout1_199) AT=795.025n

.meas tran vdout1_200ck1580 FIND v(dout1_200) AT=795.025n

.meas tran vdout1_201ck1580 FIND v(dout1_201) AT=795.025n

.meas tran vdout1_202ck1580 FIND v(dout1_202) AT=795.025n

.meas tran vdout1_203ck1580 FIND v(dout1_203) AT=795.025n

.meas tran vdout1_204ck1580 FIND v(dout1_204) AT=795.025n

.meas tran vdout1_205ck1580 FIND v(dout1_205) AT=795.025n

.meas tran vdout1_206ck1580 FIND v(dout1_206) AT=795.025n

.meas tran vdout1_207ck1580 FIND v(dout1_207) AT=795.025n

.meas tran vdout1_208ck1580 FIND v(dout1_208) AT=795.025n

.meas tran vdout1_209ck1580 FIND v(dout1_209) AT=795.025n

.meas tran vdout1_210ck1580 FIND v(dout1_210) AT=795.025n

.meas tran vdout1_211ck1580 FIND v(dout1_211) AT=795.025n

.meas tran vdout1_212ck1580 FIND v(dout1_212) AT=795.025n

.meas tran vdout1_213ck1580 FIND v(dout1_213) AT=795.025n

.meas tran vdout1_214ck1580 FIND v(dout1_214) AT=795.025n

.meas tran vdout1_215ck1580 FIND v(dout1_215) AT=795.025n

.meas tran vdout1_216ck1580 FIND v(dout1_216) AT=795.025n

.meas tran vdout1_217ck1580 FIND v(dout1_217) AT=795.025n

.meas tran vdout1_218ck1580 FIND v(dout1_218) AT=795.025n

.meas tran vdout1_219ck1580 FIND v(dout1_219) AT=795.025n

.meas tran vdout1_220ck1580 FIND v(dout1_220) AT=795.025n

.meas tran vdout1_221ck1580 FIND v(dout1_221) AT=795.025n

.meas tran vdout1_222ck1580 FIND v(dout1_222) AT=795.025n

.meas tran vdout1_223ck1580 FIND v(dout1_223) AT=795.025n

.meas tran vdout1_224ck1580 FIND v(dout1_224) AT=795.025n

.meas tran vdout1_225ck1580 FIND v(dout1_225) AT=795.025n

.meas tran vdout1_226ck1580 FIND v(dout1_226) AT=795.025n

.meas tran vdout1_227ck1580 FIND v(dout1_227) AT=795.025n

.meas tran vdout1_228ck1580 FIND v(dout1_228) AT=795.025n

.meas tran vdout1_229ck1580 FIND v(dout1_229) AT=795.025n

.meas tran vdout1_230ck1580 FIND v(dout1_230) AT=795.025n

.meas tran vdout1_231ck1580 FIND v(dout1_231) AT=795.025n

.meas tran vdout1_232ck1580 FIND v(dout1_232) AT=795.025n

.meas tran vdout1_233ck1580 FIND v(dout1_233) AT=795.025n

.meas tran vdout1_234ck1580 FIND v(dout1_234) AT=795.025n

.meas tran vdout1_235ck1580 FIND v(dout1_235) AT=795.025n

.meas tran vdout1_236ck1580 FIND v(dout1_236) AT=795.025n

.meas tran vdout1_237ck1580 FIND v(dout1_237) AT=795.025n

.meas tran vdout1_238ck1580 FIND v(dout1_238) AT=795.025n

.meas tran vdout1_239ck1580 FIND v(dout1_239) AT=795.025n

.meas tran vdout1_240ck1580 FIND v(dout1_240) AT=795.025n

.meas tran vdout1_241ck1580 FIND v(dout1_241) AT=795.025n

.meas tran vdout1_242ck1580 FIND v(dout1_242) AT=795.025n

.meas tran vdout1_243ck1580 FIND v(dout1_243) AT=795.025n

.meas tran vdout1_244ck1580 FIND v(dout1_244) AT=795.025n

.meas tran vdout1_245ck1580 FIND v(dout1_245) AT=795.025n

.meas tran vdout1_246ck1580 FIND v(dout1_246) AT=795.025n

.meas tran vdout1_247ck1580 FIND v(dout1_247) AT=795.025n

.meas tran vdout1_248ck1580 FIND v(dout1_248) AT=795.025n

.meas tran vdout1_249ck1580 FIND v(dout1_249) AT=795.025n

.meas tran vdout1_250ck1580 FIND v(dout1_250) AT=795.025n

.meas tran vdout1_251ck1580 FIND v(dout1_251) AT=795.025n

.meas tran vdout1_252ck1580 FIND v(dout1_252) AT=795.025n

.meas tran vdout1_253ck1580 FIND v(dout1_253) AT=795.025n

.meas tran vdout1_254ck1580 FIND v(dout1_254) AT=795.025n

.meas tran vdout1_255ck1580 FIND v(dout1_255) AT=795.025n

.meas tran vdout1_256ck1580 FIND v(dout1_256) AT=795.025n

.meas tran vdout1_257ck1580 FIND v(dout1_257) AT=795.025n

.meas tran vdout1_258ck1580 FIND v(dout1_258) AT=795.025n

.meas tran vdout1_259ck1580 FIND v(dout1_259) AT=795.025n

.meas tran vdout1_260ck1580 FIND v(dout1_260) AT=795.025n

.meas tran vdout1_261ck1580 FIND v(dout1_261) AT=795.025n

.meas tran vdout1_262ck1580 FIND v(dout1_262) AT=795.025n

.meas tran vdout1_263ck1580 FIND v(dout1_263) AT=795.025n

.meas tran vdout1_264ck1580 FIND v(dout1_264) AT=795.025n

.meas tran vdout1_265ck1580 FIND v(dout1_265) AT=795.025n

.meas tran vdout1_266ck1580 FIND v(dout1_266) AT=795.025n

.meas tran vdout1_267ck1580 FIND v(dout1_267) AT=795.025n

.meas tran vdout1_268ck1580 FIND v(dout1_268) AT=795.025n

.meas tran vdout1_269ck1580 FIND v(dout1_269) AT=795.025n

.meas tran vdout1_270ck1580 FIND v(dout1_270) AT=795.025n

.meas tran vdout1_271ck1580 FIND v(dout1_271) AT=795.025n

.meas tran vdout1_272ck1580 FIND v(dout1_272) AT=795.025n

.meas tran vdout1_273ck1580 FIND v(dout1_273) AT=795.025n

.meas tran vdout1_274ck1580 FIND v(dout1_274) AT=795.025n

.meas tran vdout1_275ck1580 FIND v(dout1_275) AT=795.025n

.meas tran vdout1_276ck1580 FIND v(dout1_276) AT=795.025n

.meas tran vdout1_277ck1580 FIND v(dout1_277) AT=795.025n

.meas tran vdout1_278ck1580 FIND v(dout1_278) AT=795.025n

.meas tran vdout1_279ck1580 FIND v(dout1_279) AT=795.025n

.meas tran vdout1_280ck1580 FIND v(dout1_280) AT=795.025n

.meas tran vdout1_281ck1580 FIND v(dout1_281) AT=795.025n

.meas tran vdout1_282ck1580 FIND v(dout1_282) AT=795.025n

.meas tran vdout1_283ck1580 FIND v(dout1_283) AT=795.025n

.meas tran vdout1_284ck1580 FIND v(dout1_284) AT=795.025n

.meas tran vdout1_285ck1580 FIND v(dout1_285) AT=795.025n

.meas tran vdout1_286ck1580 FIND v(dout1_286) AT=795.025n

.meas tran vdout1_287ck1580 FIND v(dout1_287) AT=795.025n

.meas tran vdout1_288ck1580 FIND v(dout1_288) AT=795.025n

.meas tran vdout1_289ck1580 FIND v(dout1_289) AT=795.025n

.meas tran vdout1_290ck1580 FIND v(dout1_290) AT=795.025n

.meas tran vdout1_291ck1580 FIND v(dout1_291) AT=795.025n

.meas tran vdout1_292ck1580 FIND v(dout1_292) AT=795.025n

.meas tran vdout1_293ck1580 FIND v(dout1_293) AT=795.025n

.meas tran vdout1_294ck1580 FIND v(dout1_294) AT=795.025n

.meas tran vdout1_295ck1580 FIND v(dout1_295) AT=795.025n

.meas tran vdout1_296ck1580 FIND v(dout1_296) AT=795.025n

.meas tran vdout1_297ck1580 FIND v(dout1_297) AT=795.025n

.meas tran vdout1_298ck1580 FIND v(dout1_298) AT=795.025n

.meas tran vdout1_299ck1580 FIND v(dout1_299) AT=795.025n

.meas tran vdout1_300ck1580 FIND v(dout1_300) AT=795.025n

.meas tran vdout1_301ck1580 FIND v(dout1_301) AT=795.025n

.meas tran vdout1_302ck1580 FIND v(dout1_302) AT=795.025n

.meas tran vdout1_303ck1580 FIND v(dout1_303) AT=795.025n

.meas tran vdout1_304ck1580 FIND v(dout1_304) AT=795.025n

.meas tran vdout1_305ck1580 FIND v(dout1_305) AT=795.025n

.meas tran vdout1_306ck1580 FIND v(dout1_306) AT=795.025n

.meas tran vdout1_307ck1580 FIND v(dout1_307) AT=795.025n

.meas tran vdout1_308ck1580 FIND v(dout1_308) AT=795.025n

.meas tran vdout1_309ck1580 FIND v(dout1_309) AT=795.025n

.meas tran vdout1_310ck1580 FIND v(dout1_310) AT=795.025n

.meas tran vdout1_311ck1580 FIND v(dout1_311) AT=795.025n

.meas tran vdout1_312ck1580 FIND v(dout1_312) AT=795.025n

.meas tran vdout1_313ck1580 FIND v(dout1_313) AT=795.025n

.meas tran vdout1_314ck1580 FIND v(dout1_314) AT=795.025n

.meas tran vdout1_315ck1580 FIND v(dout1_315) AT=795.025n

.meas tran vdout1_316ck1580 FIND v(dout1_316) AT=795.025n

.meas tran vdout1_317ck1580 FIND v(dout1_317) AT=795.025n

.meas tran vdout1_318ck1580 FIND v(dout1_318) AT=795.025n

.meas tran vdout1_319ck1580 FIND v(dout1_319) AT=795.025n

.meas tran vdout1_320ck1580 FIND v(dout1_320) AT=795.025n

.meas tran vdout1_321ck1580 FIND v(dout1_321) AT=795.025n

.meas tran vdout1_322ck1580 FIND v(dout1_322) AT=795.025n

.meas tran vdout1_323ck1580 FIND v(dout1_323) AT=795.025n

.meas tran vdout1_324ck1580 FIND v(dout1_324) AT=795.025n

.meas tran vdout1_325ck1580 FIND v(dout1_325) AT=795.025n

.meas tran vdout1_326ck1580 FIND v(dout1_326) AT=795.025n

.meas tran vdout1_327ck1580 FIND v(dout1_327) AT=795.025n

.meas tran vdout1_328ck1580 FIND v(dout1_328) AT=795.025n

.meas tran vdout1_329ck1580 FIND v(dout1_329) AT=795.025n

.meas tran vdout1_330ck1580 FIND v(dout1_330) AT=795.025n

.meas tran vdout1_331ck1580 FIND v(dout1_331) AT=795.025n

.meas tran vdout1_332ck1580 FIND v(dout1_332) AT=795.025n

.meas tran vdout1_333ck1580 FIND v(dout1_333) AT=795.025n

.meas tran vdout1_334ck1580 FIND v(dout1_334) AT=795.025n

.meas tran vdout1_335ck1580 FIND v(dout1_335) AT=795.025n

.meas tran vdout1_336ck1580 FIND v(dout1_336) AT=795.025n

.meas tran vdout1_337ck1580 FIND v(dout1_337) AT=795.025n

.meas tran vdout1_338ck1580 FIND v(dout1_338) AT=795.025n

.meas tran vdout1_339ck1580 FIND v(dout1_339) AT=795.025n

.meas tran vdout1_340ck1580 FIND v(dout1_340) AT=795.025n

.meas tran vdout1_341ck1580 FIND v(dout1_341) AT=795.025n

.meas tran vdout1_342ck1580 FIND v(dout1_342) AT=795.025n

.meas tran vdout1_343ck1580 FIND v(dout1_343) AT=795.025n

.meas tran vdout1_344ck1580 FIND v(dout1_344) AT=795.025n

.meas tran vdout1_345ck1580 FIND v(dout1_345) AT=795.025n

.meas tran vdout1_346ck1580 FIND v(dout1_346) AT=795.025n

.meas tran vdout1_347ck1580 FIND v(dout1_347) AT=795.025n

.meas tran vdout1_348ck1580 FIND v(dout1_348) AT=795.025n

.meas tran vdout1_349ck1580 FIND v(dout1_349) AT=795.025n

.meas tran vdout1_350ck1580 FIND v(dout1_350) AT=795.025n

.meas tran vdout1_351ck1580 FIND v(dout1_351) AT=795.025n

.meas tran vdout1_352ck1580 FIND v(dout1_352) AT=795.025n

.meas tran vdout1_353ck1580 FIND v(dout1_353) AT=795.025n

.meas tran vdout1_354ck1580 FIND v(dout1_354) AT=795.025n

.meas tran vdout1_355ck1580 FIND v(dout1_355) AT=795.025n

.meas tran vdout1_356ck1580 FIND v(dout1_356) AT=795.025n

.meas tran vdout1_357ck1580 FIND v(dout1_357) AT=795.025n

.meas tran vdout1_358ck1580 FIND v(dout1_358) AT=795.025n

.meas tran vdout1_359ck1580 FIND v(dout1_359) AT=795.025n

.meas tran vdout1_360ck1580 FIND v(dout1_360) AT=795.025n

.meas tran vdout1_361ck1580 FIND v(dout1_361) AT=795.025n

.meas tran vdout1_362ck1580 FIND v(dout1_362) AT=795.025n

.meas tran vdout1_363ck1580 FIND v(dout1_363) AT=795.025n

.meas tran vdout1_364ck1580 FIND v(dout1_364) AT=795.025n

.meas tran vdout1_365ck1580 FIND v(dout1_365) AT=795.025n

.meas tran vdout1_366ck1580 FIND v(dout1_366) AT=795.025n

.meas tran vdout1_367ck1580 FIND v(dout1_367) AT=795.025n

.meas tran vdout1_368ck1580 FIND v(dout1_368) AT=795.025n

.meas tran vdout1_369ck1580 FIND v(dout1_369) AT=795.025n

.meas tran vdout1_370ck1580 FIND v(dout1_370) AT=795.025n

.meas tran vdout1_371ck1580 FIND v(dout1_371) AT=795.025n

.meas tran vdout1_372ck1580 FIND v(dout1_372) AT=795.025n

.meas tran vdout1_373ck1580 FIND v(dout1_373) AT=795.025n

.meas tran vdout1_374ck1580 FIND v(dout1_374) AT=795.025n

.meas tran vdout1_375ck1580 FIND v(dout1_375) AT=795.025n

.meas tran vdout1_376ck1580 FIND v(dout1_376) AT=795.025n

.meas tran vdout1_377ck1580 FIND v(dout1_377) AT=795.025n

.meas tran vdout1_378ck1580 FIND v(dout1_378) AT=795.025n

.meas tran vdout1_379ck1580 FIND v(dout1_379) AT=795.025n

.meas tran vdout1_380ck1580 FIND v(dout1_380) AT=795.025n

.meas tran vdout1_381ck1580 FIND v(dout1_381) AT=795.025n

.meas tran vdout1_382ck1580 FIND v(dout1_382) AT=795.025n

.meas tran vdout1_383ck1580 FIND v(dout1_383) AT=795.025n

.meas tran vdout1_384ck1580 FIND v(dout1_384) AT=795.025n

.meas tran vdout1_385ck1580 FIND v(dout1_385) AT=795.025n

.meas tran vdout1_386ck1580 FIND v(dout1_386) AT=795.025n

.meas tran vdout1_387ck1580 FIND v(dout1_387) AT=795.025n

.meas tran vdout1_388ck1580 FIND v(dout1_388) AT=795.025n

.meas tran vdout1_389ck1580 FIND v(dout1_389) AT=795.025n

.meas tran vdout1_390ck1580 FIND v(dout1_390) AT=795.025n

.meas tran vdout1_391ck1580 FIND v(dout1_391) AT=795.025n

.meas tran vdout1_392ck1580 FIND v(dout1_392) AT=795.025n

.meas tran vdout1_393ck1580 FIND v(dout1_393) AT=795.025n

.meas tran vdout1_394ck1580 FIND v(dout1_394) AT=795.025n

.meas tran vdout1_395ck1580 FIND v(dout1_395) AT=795.025n

.meas tran vdout1_396ck1580 FIND v(dout1_396) AT=795.025n

.meas tran vdout1_397ck1580 FIND v(dout1_397) AT=795.025n

.meas tran vdout1_398ck1580 FIND v(dout1_398) AT=795.025n

.meas tran vdout1_399ck1580 FIND v(dout1_399) AT=795.025n

.meas tran vdout1_400ck1580 FIND v(dout1_400) AT=795.025n

.meas tran vdout1_401ck1580 FIND v(dout1_401) AT=795.025n

.meas tran vdout1_402ck1580 FIND v(dout1_402) AT=795.025n

.meas tran vdout1_403ck1580 FIND v(dout1_403) AT=795.025n

.meas tran vdout1_404ck1580 FIND v(dout1_404) AT=795.025n

.meas tran vdout1_405ck1580 FIND v(dout1_405) AT=795.025n

.meas tran vdout1_406ck1580 FIND v(dout1_406) AT=795.025n

.meas tran vdout1_407ck1580 FIND v(dout1_407) AT=795.025n

.meas tran vdout1_408ck1580 FIND v(dout1_408) AT=795.025n

.meas tran vdout1_409ck1580 FIND v(dout1_409) AT=795.025n

.meas tran vdout1_410ck1580 FIND v(dout1_410) AT=795.025n

.meas tran vdout1_411ck1580 FIND v(dout1_411) AT=795.025n

.meas tran vdout1_412ck1580 FIND v(dout1_412) AT=795.025n

.meas tran vdout1_413ck1580 FIND v(dout1_413) AT=795.025n

.meas tran vdout1_414ck1580 FIND v(dout1_414) AT=795.025n

.meas tran vdout1_415ck1580 FIND v(dout1_415) AT=795.025n

.meas tran vdout1_416ck1580 FIND v(dout1_416) AT=795.025n

.meas tran vdout1_417ck1580 FIND v(dout1_417) AT=795.025n

.meas tran vdout1_418ck1580 FIND v(dout1_418) AT=795.025n

.meas tran vdout1_419ck1580 FIND v(dout1_419) AT=795.025n

.meas tran vdout1_420ck1580 FIND v(dout1_420) AT=795.025n

.meas tran vdout1_421ck1580 FIND v(dout1_421) AT=795.025n

.meas tran vdout1_422ck1580 FIND v(dout1_422) AT=795.025n

.meas tran vdout1_423ck1580 FIND v(dout1_423) AT=795.025n

.meas tran vdout1_424ck1580 FIND v(dout1_424) AT=795.025n

.meas tran vdout1_425ck1580 FIND v(dout1_425) AT=795.025n

.meas tran vdout1_426ck1580 FIND v(dout1_426) AT=795.025n

.meas tran vdout1_427ck1580 FIND v(dout1_427) AT=795.025n

.meas tran vdout1_428ck1580 FIND v(dout1_428) AT=795.025n

.meas tran vdout1_429ck1580 FIND v(dout1_429) AT=795.025n

.meas tran vdout1_430ck1580 FIND v(dout1_430) AT=795.025n

.meas tran vdout1_431ck1580 FIND v(dout1_431) AT=795.025n

.meas tran vdout1_432ck1580 FIND v(dout1_432) AT=795.025n

.meas tran vdout1_433ck1580 FIND v(dout1_433) AT=795.025n

.meas tran vdout1_434ck1580 FIND v(dout1_434) AT=795.025n

.meas tran vdout1_435ck1580 FIND v(dout1_435) AT=795.025n

.meas tran vdout1_436ck1580 FIND v(dout1_436) AT=795.025n

.meas tran vdout1_437ck1580 FIND v(dout1_437) AT=795.025n

.meas tran vdout1_438ck1580 FIND v(dout1_438) AT=795.025n

.meas tran vdout1_439ck1580 FIND v(dout1_439) AT=795.025n

.meas tran vdout1_440ck1580 FIND v(dout1_440) AT=795.025n

.meas tran vdout1_441ck1580 FIND v(dout1_441) AT=795.025n

.meas tran vdout1_442ck1580 FIND v(dout1_442) AT=795.025n

.meas tran vdout1_443ck1580 FIND v(dout1_443) AT=795.025n

.meas tran vdout1_444ck1580 FIND v(dout1_444) AT=795.025n

.meas tran vdout1_445ck1580 FIND v(dout1_445) AT=795.025n

.meas tran vdout1_446ck1580 FIND v(dout1_446) AT=795.025n

.meas tran vdout1_447ck1580 FIND v(dout1_447) AT=795.025n

.meas tran vdout1_448ck1580 FIND v(dout1_448) AT=795.025n

.meas tran vdout1_449ck1580 FIND v(dout1_449) AT=795.025n

.meas tran vdout1_450ck1580 FIND v(dout1_450) AT=795.025n

.meas tran vdout1_451ck1580 FIND v(dout1_451) AT=795.025n

.meas tran vdout1_452ck1580 FIND v(dout1_452) AT=795.025n

.meas tran vdout1_453ck1580 FIND v(dout1_453) AT=795.025n

.meas tran vdout1_454ck1580 FIND v(dout1_454) AT=795.025n

.meas tran vdout1_455ck1580 FIND v(dout1_455) AT=795.025n

.meas tran vdout1_456ck1580 FIND v(dout1_456) AT=795.025n

.meas tran vdout1_457ck1580 FIND v(dout1_457) AT=795.025n

.meas tran vdout1_458ck1580 FIND v(dout1_458) AT=795.025n

.meas tran vdout1_459ck1580 FIND v(dout1_459) AT=795.025n

.meas tran vdout1_460ck1580 FIND v(dout1_460) AT=795.025n

.meas tran vdout1_461ck1580 FIND v(dout1_461) AT=795.025n

.meas tran vdout1_462ck1580 FIND v(dout1_462) AT=795.025n

.meas tran vdout1_463ck1580 FIND v(dout1_463) AT=795.025n

.meas tran vdout1_464ck1580 FIND v(dout1_464) AT=795.025n

.meas tran vdout1_465ck1580 FIND v(dout1_465) AT=795.025n

.meas tran vdout1_466ck1580 FIND v(dout1_466) AT=795.025n

.meas tran vdout1_467ck1580 FIND v(dout1_467) AT=795.025n

.meas tran vdout1_468ck1580 FIND v(dout1_468) AT=795.025n

.meas tran vdout1_469ck1580 FIND v(dout1_469) AT=795.025n

.meas tran vdout1_470ck1580 FIND v(dout1_470) AT=795.025n

.meas tran vdout1_471ck1580 FIND v(dout1_471) AT=795.025n

.meas tran vdout1_472ck1580 FIND v(dout1_472) AT=795.025n

.meas tran vdout1_473ck1580 FIND v(dout1_473) AT=795.025n

.meas tran vdout1_474ck1580 FIND v(dout1_474) AT=795.025n

.meas tran vdout1_475ck1580 FIND v(dout1_475) AT=795.025n

.meas tran vdout1_476ck1580 FIND v(dout1_476) AT=795.025n

.meas tran vdout1_477ck1580 FIND v(dout1_477) AT=795.025n

.meas tran vdout1_478ck1580 FIND v(dout1_478) AT=795.025n

.meas tran vdout1_479ck1580 FIND v(dout1_479) AT=795.025n

.meas tran vdout1_480ck1580 FIND v(dout1_480) AT=795.025n

.meas tran vdout1_481ck1580 FIND v(dout1_481) AT=795.025n

.meas tran vdout1_482ck1580 FIND v(dout1_482) AT=795.025n

.meas tran vdout1_483ck1580 FIND v(dout1_483) AT=795.025n

.meas tran vdout1_484ck1580 FIND v(dout1_484) AT=795.025n

.meas tran vdout1_485ck1580 FIND v(dout1_485) AT=795.025n

.meas tran vdout1_486ck1580 FIND v(dout1_486) AT=795.025n

.meas tran vdout1_487ck1580 FIND v(dout1_487) AT=795.025n

.meas tran vdout1_488ck1580 FIND v(dout1_488) AT=795.025n

.meas tran vdout1_489ck1580 FIND v(dout1_489) AT=795.025n

.meas tran vdout1_490ck1580 FIND v(dout1_490) AT=795.025n

.meas tran vdout1_491ck1580 FIND v(dout1_491) AT=795.025n

.meas tran vdout1_492ck1580 FIND v(dout1_492) AT=795.025n

.meas tran vdout1_493ck1580 FIND v(dout1_493) AT=795.025n

.meas tran vdout1_494ck1580 FIND v(dout1_494) AT=795.025n

.meas tran vdout1_495ck1580 FIND v(dout1_495) AT=795.025n

.meas tran vdout1_496ck1580 FIND v(dout1_496) AT=795.025n

.meas tran vdout1_497ck1580 FIND v(dout1_497) AT=795.025n

.meas tran vdout1_498ck1580 FIND v(dout1_498) AT=795.025n

.meas tran vdout1_499ck1580 FIND v(dout1_499) AT=795.025n

.meas tran vdout1_500ck1580 FIND v(dout1_500) AT=795.025n

.meas tran vdout1_501ck1580 FIND v(dout1_501) AT=795.025n

.meas tran vdout1_502ck1580 FIND v(dout1_502) AT=795.025n

.meas tran vdout1_503ck1580 FIND v(dout1_503) AT=795.025n

.meas tran vdout1_504ck1580 FIND v(dout1_504) AT=795.025n

.meas tran vdout1_505ck1580 FIND v(dout1_505) AT=795.025n

.meas tran vdout1_506ck1580 FIND v(dout1_506) AT=795.025n

.meas tran vdout1_507ck1580 FIND v(dout1_507) AT=795.025n

.meas tran vdout1_508ck1580 FIND v(dout1_508) AT=795.025n

.meas tran vdout1_509ck1580 FIND v(dout1_509) AT=795.025n

.meas tran vdout1_510ck1580 FIND v(dout1_510) AT=795.025n

.meas tran vdout1_511ck1580 FIND v(dout1_511) AT=795.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_19ck1590 FIND v(dout1_19) AT=800.025n

.meas tran vdout1_20ck1590 FIND v(dout1_20) AT=800.025n

.meas tran vdout1_21ck1590 FIND v(dout1_21) AT=800.025n

.meas tran vdout1_22ck1590 FIND v(dout1_22) AT=800.025n

.meas tran vdout1_23ck1590 FIND v(dout1_23) AT=800.025n

.meas tran vdout1_24ck1590 FIND v(dout1_24) AT=800.025n

.meas tran vdout1_25ck1590 FIND v(dout1_25) AT=800.025n

.meas tran vdout1_26ck1590 FIND v(dout1_26) AT=800.025n

.meas tran vdout1_27ck1590 FIND v(dout1_27) AT=800.025n

.meas tran vdout1_28ck1590 FIND v(dout1_28) AT=800.025n

.meas tran vdout1_29ck1590 FIND v(dout1_29) AT=800.025n

.meas tran vdout1_30ck1590 FIND v(dout1_30) AT=800.025n

.meas tran vdout1_31ck1590 FIND v(dout1_31) AT=800.025n

.meas tran vdout1_32ck1590 FIND v(dout1_32) AT=800.025n

.meas tran vdout1_33ck1590 FIND v(dout1_33) AT=800.025n

.meas tran vdout1_34ck1590 FIND v(dout1_34) AT=800.025n

.meas tran vdout1_35ck1590 FIND v(dout1_35) AT=800.025n

.meas tran vdout1_36ck1590 FIND v(dout1_36) AT=800.025n

.meas tran vdout1_37ck1590 FIND v(dout1_37) AT=800.025n

.meas tran vdout1_38ck1590 FIND v(dout1_38) AT=800.025n

.meas tran vdout1_39ck1590 FIND v(dout1_39) AT=800.025n

.meas tran vdout1_40ck1590 FIND v(dout1_40) AT=800.025n

.meas tran vdout1_41ck1590 FIND v(dout1_41) AT=800.025n

.meas tran vdout1_42ck1590 FIND v(dout1_42) AT=800.025n

.meas tran vdout1_43ck1590 FIND v(dout1_43) AT=800.025n

.meas tran vdout1_44ck1590 FIND v(dout1_44) AT=800.025n

.meas tran vdout1_45ck1590 FIND v(dout1_45) AT=800.025n

.meas tran vdout1_46ck1590 FIND v(dout1_46) AT=800.025n

.meas tran vdout1_47ck1590 FIND v(dout1_47) AT=800.025n

.meas tran vdout1_48ck1590 FIND v(dout1_48) AT=800.025n

.meas tran vdout1_49ck1590 FIND v(dout1_49) AT=800.025n

.meas tran vdout1_50ck1590 FIND v(dout1_50) AT=800.025n

.meas tran vdout1_51ck1590 FIND v(dout1_51) AT=800.025n

.meas tran vdout1_52ck1590 FIND v(dout1_52) AT=800.025n

.meas tran vdout1_53ck1590 FIND v(dout1_53) AT=800.025n

.meas tran vdout1_54ck1590 FIND v(dout1_54) AT=800.025n

.meas tran vdout1_55ck1590 FIND v(dout1_55) AT=800.025n

.meas tran vdout1_56ck1590 FIND v(dout1_56) AT=800.025n

.meas tran vdout1_57ck1590 FIND v(dout1_57) AT=800.025n

.meas tran vdout1_58ck1590 FIND v(dout1_58) AT=800.025n

.meas tran vdout1_59ck1590 FIND v(dout1_59) AT=800.025n

.meas tran vdout1_60ck1590 FIND v(dout1_60) AT=800.025n

.meas tran vdout1_61ck1590 FIND v(dout1_61) AT=800.025n

.meas tran vdout1_62ck1590 FIND v(dout1_62) AT=800.025n

.meas tran vdout1_63ck1590 FIND v(dout1_63) AT=800.025n

.meas tran vdout1_64ck1590 FIND v(dout1_64) AT=800.025n

.meas tran vdout1_65ck1590 FIND v(dout1_65) AT=800.025n

.meas tran vdout1_66ck1590 FIND v(dout1_66) AT=800.025n

.meas tran vdout1_67ck1590 FIND v(dout1_67) AT=800.025n

.meas tran vdout1_68ck1590 FIND v(dout1_68) AT=800.025n

.meas tran vdout1_69ck1590 FIND v(dout1_69) AT=800.025n

.meas tran vdout1_70ck1590 FIND v(dout1_70) AT=800.025n

.meas tran vdout1_71ck1590 FIND v(dout1_71) AT=800.025n

.meas tran vdout1_72ck1590 FIND v(dout1_72) AT=800.025n

.meas tran vdout1_73ck1590 FIND v(dout1_73) AT=800.025n

.meas tran vdout1_74ck1590 FIND v(dout1_74) AT=800.025n

.meas tran vdout1_75ck1590 FIND v(dout1_75) AT=800.025n

.meas tran vdout1_76ck1590 FIND v(dout1_76) AT=800.025n

.meas tran vdout1_77ck1590 FIND v(dout1_77) AT=800.025n

.meas tran vdout1_78ck1590 FIND v(dout1_78) AT=800.025n

.meas tran vdout1_79ck1590 FIND v(dout1_79) AT=800.025n

.meas tran vdout1_80ck1590 FIND v(dout1_80) AT=800.025n

.meas tran vdout1_81ck1590 FIND v(dout1_81) AT=800.025n

.meas tran vdout1_82ck1590 FIND v(dout1_82) AT=800.025n

.meas tran vdout1_83ck1590 FIND v(dout1_83) AT=800.025n

.meas tran vdout1_84ck1590 FIND v(dout1_84) AT=800.025n

.meas tran vdout1_85ck1590 FIND v(dout1_85) AT=800.025n

.meas tran vdout1_86ck1590 FIND v(dout1_86) AT=800.025n

.meas tran vdout1_87ck1590 FIND v(dout1_87) AT=800.025n

.meas tran vdout1_88ck1590 FIND v(dout1_88) AT=800.025n

.meas tran vdout1_89ck1590 FIND v(dout1_89) AT=800.025n

.meas tran vdout1_90ck1590 FIND v(dout1_90) AT=800.025n

.meas tran vdout1_91ck1590 FIND v(dout1_91) AT=800.025n

.meas tran vdout1_92ck1590 FIND v(dout1_92) AT=800.025n

.meas tran vdout1_93ck1590 FIND v(dout1_93) AT=800.025n

.meas tran vdout1_94ck1590 FIND v(dout1_94) AT=800.025n

.meas tran vdout1_95ck1590 FIND v(dout1_95) AT=800.025n

.meas tran vdout1_96ck1590 FIND v(dout1_96) AT=800.025n

.meas tran vdout1_97ck1590 FIND v(dout1_97) AT=800.025n

.meas tran vdout1_98ck1590 FIND v(dout1_98) AT=800.025n

.meas tran vdout1_99ck1590 FIND v(dout1_99) AT=800.025n

.meas tran vdout1_100ck1590 FIND v(dout1_100) AT=800.025n

.meas tran vdout1_101ck1590 FIND v(dout1_101) AT=800.025n

.meas tran vdout1_102ck1590 FIND v(dout1_102) AT=800.025n

.meas tran vdout1_103ck1590 FIND v(dout1_103) AT=800.025n

.meas tran vdout1_104ck1590 FIND v(dout1_104) AT=800.025n

.meas tran vdout1_105ck1590 FIND v(dout1_105) AT=800.025n

.meas tran vdout1_106ck1590 FIND v(dout1_106) AT=800.025n

.meas tran vdout1_107ck1590 FIND v(dout1_107) AT=800.025n

.meas tran vdout1_108ck1590 FIND v(dout1_108) AT=800.025n

.meas tran vdout1_109ck1590 FIND v(dout1_109) AT=800.025n

.meas tran vdout1_110ck1590 FIND v(dout1_110) AT=800.025n

.meas tran vdout1_111ck1590 FIND v(dout1_111) AT=800.025n

.meas tran vdout1_112ck1590 FIND v(dout1_112) AT=800.025n

.meas tran vdout1_113ck1590 FIND v(dout1_113) AT=800.025n

.meas tran vdout1_114ck1590 FIND v(dout1_114) AT=800.025n

.meas tran vdout1_115ck1590 FIND v(dout1_115) AT=800.025n

.meas tran vdout1_116ck1590 FIND v(dout1_116) AT=800.025n

.meas tran vdout1_117ck1590 FIND v(dout1_117) AT=800.025n

.meas tran vdout1_118ck1590 FIND v(dout1_118) AT=800.025n

.meas tran vdout1_119ck1590 FIND v(dout1_119) AT=800.025n

.meas tran vdout1_120ck1590 FIND v(dout1_120) AT=800.025n

.meas tran vdout1_121ck1590 FIND v(dout1_121) AT=800.025n

.meas tran vdout1_122ck1590 FIND v(dout1_122) AT=800.025n

.meas tran vdout1_123ck1590 FIND v(dout1_123) AT=800.025n

.meas tran vdout1_124ck1590 FIND v(dout1_124) AT=800.025n

.meas tran vdout1_125ck1590 FIND v(dout1_125) AT=800.025n

.meas tran vdout1_126ck1590 FIND v(dout1_126) AT=800.025n

.meas tran vdout1_127ck1590 FIND v(dout1_127) AT=800.025n

.meas tran vdout1_128ck1590 FIND v(dout1_128) AT=800.025n

.meas tran vdout1_129ck1590 FIND v(dout1_129) AT=800.025n

.meas tran vdout1_130ck1590 FIND v(dout1_130) AT=800.025n

.meas tran vdout1_131ck1590 FIND v(dout1_131) AT=800.025n

.meas tran vdout1_132ck1590 FIND v(dout1_132) AT=800.025n

.meas tran vdout1_133ck1590 FIND v(dout1_133) AT=800.025n

.meas tran vdout1_134ck1590 FIND v(dout1_134) AT=800.025n

.meas tran vdout1_135ck1590 FIND v(dout1_135) AT=800.025n

.meas tran vdout1_136ck1590 FIND v(dout1_136) AT=800.025n

.meas tran vdout1_137ck1590 FIND v(dout1_137) AT=800.025n

.meas tran vdout1_138ck1590 FIND v(dout1_138) AT=800.025n

.meas tran vdout1_139ck1590 FIND v(dout1_139) AT=800.025n

.meas tran vdout1_140ck1590 FIND v(dout1_140) AT=800.025n

.meas tran vdout1_141ck1590 FIND v(dout1_141) AT=800.025n

.meas tran vdout1_142ck1590 FIND v(dout1_142) AT=800.025n

.meas tran vdout1_143ck1590 FIND v(dout1_143) AT=800.025n

.meas tran vdout1_144ck1590 FIND v(dout1_144) AT=800.025n

.meas tran vdout1_145ck1590 FIND v(dout1_145) AT=800.025n

.meas tran vdout1_146ck1590 FIND v(dout1_146) AT=800.025n

.meas tran vdout1_147ck1590 FIND v(dout1_147) AT=800.025n

.meas tran vdout1_148ck1590 FIND v(dout1_148) AT=800.025n

.meas tran vdout1_149ck1590 FIND v(dout1_149) AT=800.025n

.meas tran vdout1_150ck1590 FIND v(dout1_150) AT=800.025n

.meas tran vdout1_151ck1590 FIND v(dout1_151) AT=800.025n

.meas tran vdout1_152ck1590 FIND v(dout1_152) AT=800.025n

.meas tran vdout1_153ck1590 FIND v(dout1_153) AT=800.025n

.meas tran vdout1_154ck1590 FIND v(dout1_154) AT=800.025n

.meas tran vdout1_155ck1590 FIND v(dout1_155) AT=800.025n

.meas tran vdout1_156ck1590 FIND v(dout1_156) AT=800.025n

.meas tran vdout1_157ck1590 FIND v(dout1_157) AT=800.025n

.meas tran vdout1_158ck1590 FIND v(dout1_158) AT=800.025n

.meas tran vdout1_159ck1590 FIND v(dout1_159) AT=800.025n

.meas tran vdout1_160ck1590 FIND v(dout1_160) AT=800.025n

.meas tran vdout1_161ck1590 FIND v(dout1_161) AT=800.025n

.meas tran vdout1_162ck1590 FIND v(dout1_162) AT=800.025n

.meas tran vdout1_163ck1590 FIND v(dout1_163) AT=800.025n

.meas tran vdout1_164ck1590 FIND v(dout1_164) AT=800.025n

.meas tran vdout1_165ck1590 FIND v(dout1_165) AT=800.025n

.meas tran vdout1_166ck1590 FIND v(dout1_166) AT=800.025n

.meas tran vdout1_167ck1590 FIND v(dout1_167) AT=800.025n

.meas tran vdout1_168ck1590 FIND v(dout1_168) AT=800.025n

.meas tran vdout1_169ck1590 FIND v(dout1_169) AT=800.025n

.meas tran vdout1_170ck1590 FIND v(dout1_170) AT=800.025n

.meas tran vdout1_171ck1590 FIND v(dout1_171) AT=800.025n

.meas tran vdout1_172ck1590 FIND v(dout1_172) AT=800.025n

.meas tran vdout1_173ck1590 FIND v(dout1_173) AT=800.025n

.meas tran vdout1_174ck1590 FIND v(dout1_174) AT=800.025n

.meas tran vdout1_175ck1590 FIND v(dout1_175) AT=800.025n

.meas tran vdout1_176ck1590 FIND v(dout1_176) AT=800.025n

.meas tran vdout1_177ck1590 FIND v(dout1_177) AT=800.025n

.meas tran vdout1_178ck1590 FIND v(dout1_178) AT=800.025n

.meas tran vdout1_179ck1590 FIND v(dout1_179) AT=800.025n

.meas tran vdout1_180ck1590 FIND v(dout1_180) AT=800.025n

.meas tran vdout1_181ck1590 FIND v(dout1_181) AT=800.025n

.meas tran vdout1_182ck1590 FIND v(dout1_182) AT=800.025n

.meas tran vdout1_183ck1590 FIND v(dout1_183) AT=800.025n

.meas tran vdout1_184ck1590 FIND v(dout1_184) AT=800.025n

.meas tran vdout1_185ck1590 FIND v(dout1_185) AT=800.025n

.meas tran vdout1_186ck1590 FIND v(dout1_186) AT=800.025n

.meas tran vdout1_187ck1590 FIND v(dout1_187) AT=800.025n

.meas tran vdout1_188ck1590 FIND v(dout1_188) AT=800.025n

.meas tran vdout1_189ck1590 FIND v(dout1_189) AT=800.025n

.meas tran vdout1_190ck1590 FIND v(dout1_190) AT=800.025n

.meas tran vdout1_191ck1590 FIND v(dout1_191) AT=800.025n

.meas tran vdout1_192ck1590 FIND v(dout1_192) AT=800.025n

.meas tran vdout1_193ck1590 FIND v(dout1_193) AT=800.025n

.meas tran vdout1_194ck1590 FIND v(dout1_194) AT=800.025n

.meas tran vdout1_195ck1590 FIND v(dout1_195) AT=800.025n

.meas tran vdout1_196ck1590 FIND v(dout1_196) AT=800.025n

.meas tran vdout1_197ck1590 FIND v(dout1_197) AT=800.025n

.meas tran vdout1_198ck1590 FIND v(dout1_198) AT=800.025n

.meas tran vdout1_199ck1590 FIND v(dout1_199) AT=800.025n

.meas tran vdout1_200ck1590 FIND v(dout1_200) AT=800.025n

.meas tran vdout1_201ck1590 FIND v(dout1_201) AT=800.025n

.meas tran vdout1_202ck1590 FIND v(dout1_202) AT=800.025n

.meas tran vdout1_203ck1590 FIND v(dout1_203) AT=800.025n

.meas tran vdout1_204ck1590 FIND v(dout1_204) AT=800.025n

.meas tran vdout1_205ck1590 FIND v(dout1_205) AT=800.025n

.meas tran vdout1_206ck1590 FIND v(dout1_206) AT=800.025n

.meas tran vdout1_207ck1590 FIND v(dout1_207) AT=800.025n

.meas tran vdout1_208ck1590 FIND v(dout1_208) AT=800.025n

.meas tran vdout1_209ck1590 FIND v(dout1_209) AT=800.025n

.meas tran vdout1_210ck1590 FIND v(dout1_210) AT=800.025n

.meas tran vdout1_211ck1590 FIND v(dout1_211) AT=800.025n

.meas tran vdout1_212ck1590 FIND v(dout1_212) AT=800.025n

.meas tran vdout1_213ck1590 FIND v(dout1_213) AT=800.025n

.meas tran vdout1_214ck1590 FIND v(dout1_214) AT=800.025n

.meas tran vdout1_215ck1590 FIND v(dout1_215) AT=800.025n

.meas tran vdout1_216ck1590 FIND v(dout1_216) AT=800.025n

.meas tran vdout1_217ck1590 FIND v(dout1_217) AT=800.025n

.meas tran vdout1_218ck1590 FIND v(dout1_218) AT=800.025n

.meas tran vdout1_219ck1590 FIND v(dout1_219) AT=800.025n

.meas tran vdout1_220ck1590 FIND v(dout1_220) AT=800.025n

.meas tran vdout1_221ck1590 FIND v(dout1_221) AT=800.025n

.meas tran vdout1_222ck1590 FIND v(dout1_222) AT=800.025n

.meas tran vdout1_223ck1590 FIND v(dout1_223) AT=800.025n

.meas tran vdout1_224ck1590 FIND v(dout1_224) AT=800.025n

.meas tran vdout1_225ck1590 FIND v(dout1_225) AT=800.025n

.meas tran vdout1_226ck1590 FIND v(dout1_226) AT=800.025n

.meas tran vdout1_227ck1590 FIND v(dout1_227) AT=800.025n

.meas tran vdout1_228ck1590 FIND v(dout1_228) AT=800.025n

.meas tran vdout1_229ck1590 FIND v(dout1_229) AT=800.025n

.meas tran vdout1_230ck1590 FIND v(dout1_230) AT=800.025n

.meas tran vdout1_231ck1590 FIND v(dout1_231) AT=800.025n

.meas tran vdout1_232ck1590 FIND v(dout1_232) AT=800.025n

.meas tran vdout1_233ck1590 FIND v(dout1_233) AT=800.025n

.meas tran vdout1_234ck1590 FIND v(dout1_234) AT=800.025n

.meas tran vdout1_235ck1590 FIND v(dout1_235) AT=800.025n

.meas tran vdout1_236ck1590 FIND v(dout1_236) AT=800.025n

.meas tran vdout1_237ck1590 FIND v(dout1_237) AT=800.025n

.meas tran vdout1_238ck1590 FIND v(dout1_238) AT=800.025n

.meas tran vdout1_239ck1590 FIND v(dout1_239) AT=800.025n

.meas tran vdout1_240ck1590 FIND v(dout1_240) AT=800.025n

.meas tran vdout1_241ck1590 FIND v(dout1_241) AT=800.025n

.meas tran vdout1_242ck1590 FIND v(dout1_242) AT=800.025n

.meas tran vdout1_243ck1590 FIND v(dout1_243) AT=800.025n

.meas tran vdout1_244ck1590 FIND v(dout1_244) AT=800.025n

.meas tran vdout1_245ck1590 FIND v(dout1_245) AT=800.025n

.meas tran vdout1_246ck1590 FIND v(dout1_246) AT=800.025n

.meas tran vdout1_247ck1590 FIND v(dout1_247) AT=800.025n

.meas tran vdout1_248ck1590 FIND v(dout1_248) AT=800.025n

.meas tran vdout1_249ck1590 FIND v(dout1_249) AT=800.025n

.meas tran vdout1_250ck1590 FIND v(dout1_250) AT=800.025n

.meas tran vdout1_251ck1590 FIND v(dout1_251) AT=800.025n

.meas tran vdout1_252ck1590 FIND v(dout1_252) AT=800.025n

.meas tran vdout1_253ck1590 FIND v(dout1_253) AT=800.025n

.meas tran vdout1_254ck1590 FIND v(dout1_254) AT=800.025n

.meas tran vdout1_255ck1590 FIND v(dout1_255) AT=800.025n

.meas tran vdout1_256ck1590 FIND v(dout1_256) AT=800.025n

.meas tran vdout1_257ck1590 FIND v(dout1_257) AT=800.025n

.meas tran vdout1_258ck1590 FIND v(dout1_258) AT=800.025n

.meas tran vdout1_259ck1590 FIND v(dout1_259) AT=800.025n

.meas tran vdout1_260ck1590 FIND v(dout1_260) AT=800.025n

.meas tran vdout1_261ck1590 FIND v(dout1_261) AT=800.025n

.meas tran vdout1_262ck1590 FIND v(dout1_262) AT=800.025n

.meas tran vdout1_263ck1590 FIND v(dout1_263) AT=800.025n

.meas tran vdout1_264ck1590 FIND v(dout1_264) AT=800.025n

.meas tran vdout1_265ck1590 FIND v(dout1_265) AT=800.025n

.meas tran vdout1_266ck1590 FIND v(dout1_266) AT=800.025n

.meas tran vdout1_267ck1590 FIND v(dout1_267) AT=800.025n

.meas tran vdout1_268ck1590 FIND v(dout1_268) AT=800.025n

.meas tran vdout1_269ck1590 FIND v(dout1_269) AT=800.025n

.meas tran vdout1_270ck1590 FIND v(dout1_270) AT=800.025n

.meas tran vdout1_271ck1590 FIND v(dout1_271) AT=800.025n

.meas tran vdout1_272ck1590 FIND v(dout1_272) AT=800.025n

.meas tran vdout1_273ck1590 FIND v(dout1_273) AT=800.025n

.meas tran vdout1_274ck1590 FIND v(dout1_274) AT=800.025n

.meas tran vdout1_275ck1590 FIND v(dout1_275) AT=800.025n

.meas tran vdout1_276ck1590 FIND v(dout1_276) AT=800.025n

.meas tran vdout1_277ck1590 FIND v(dout1_277) AT=800.025n

.meas tran vdout1_278ck1590 FIND v(dout1_278) AT=800.025n

.meas tran vdout1_279ck1590 FIND v(dout1_279) AT=800.025n

.meas tran vdout1_280ck1590 FIND v(dout1_280) AT=800.025n

.meas tran vdout1_281ck1590 FIND v(dout1_281) AT=800.025n

.meas tran vdout1_282ck1590 FIND v(dout1_282) AT=800.025n

.meas tran vdout1_283ck1590 FIND v(dout1_283) AT=800.025n

.meas tran vdout1_284ck1590 FIND v(dout1_284) AT=800.025n

.meas tran vdout1_285ck1590 FIND v(dout1_285) AT=800.025n

.meas tran vdout1_286ck1590 FIND v(dout1_286) AT=800.025n

.meas tran vdout1_287ck1590 FIND v(dout1_287) AT=800.025n

.meas tran vdout1_288ck1590 FIND v(dout1_288) AT=800.025n

.meas tran vdout1_289ck1590 FIND v(dout1_289) AT=800.025n

.meas tran vdout1_290ck1590 FIND v(dout1_290) AT=800.025n

.meas tran vdout1_291ck1590 FIND v(dout1_291) AT=800.025n

.meas tran vdout1_292ck1590 FIND v(dout1_292) AT=800.025n

.meas tran vdout1_293ck1590 FIND v(dout1_293) AT=800.025n

.meas tran vdout1_294ck1590 FIND v(dout1_294) AT=800.025n

.meas tran vdout1_295ck1590 FIND v(dout1_295) AT=800.025n

.meas tran vdout1_296ck1590 FIND v(dout1_296) AT=800.025n

.meas tran vdout1_297ck1590 FIND v(dout1_297) AT=800.025n

.meas tran vdout1_298ck1590 FIND v(dout1_298) AT=800.025n

.meas tran vdout1_299ck1590 FIND v(dout1_299) AT=800.025n

.meas tran vdout1_300ck1590 FIND v(dout1_300) AT=800.025n

.meas tran vdout1_301ck1590 FIND v(dout1_301) AT=800.025n

.meas tran vdout1_302ck1590 FIND v(dout1_302) AT=800.025n

.meas tran vdout1_303ck1590 FIND v(dout1_303) AT=800.025n

.meas tran vdout1_304ck1590 FIND v(dout1_304) AT=800.025n

.meas tran vdout1_305ck1590 FIND v(dout1_305) AT=800.025n

.meas tran vdout1_306ck1590 FIND v(dout1_306) AT=800.025n

.meas tran vdout1_307ck1590 FIND v(dout1_307) AT=800.025n

.meas tran vdout1_308ck1590 FIND v(dout1_308) AT=800.025n

.meas tran vdout1_309ck1590 FIND v(dout1_309) AT=800.025n

.meas tran vdout1_310ck1590 FIND v(dout1_310) AT=800.025n

.meas tran vdout1_311ck1590 FIND v(dout1_311) AT=800.025n

.meas tran vdout1_312ck1590 FIND v(dout1_312) AT=800.025n

.meas tran vdout1_313ck1590 FIND v(dout1_313) AT=800.025n

.meas tran vdout1_314ck1590 FIND v(dout1_314) AT=800.025n

.meas tran vdout1_315ck1590 FIND v(dout1_315) AT=800.025n

.meas tran vdout1_316ck1590 FIND v(dout1_316) AT=800.025n

.meas tran vdout1_317ck1590 FIND v(dout1_317) AT=800.025n

.meas tran vdout1_318ck1590 FIND v(dout1_318) AT=800.025n

.meas tran vdout1_319ck1590 FIND v(dout1_319) AT=800.025n

.meas tran vdout1_320ck1590 FIND v(dout1_320) AT=800.025n

.meas tran vdout1_321ck1590 FIND v(dout1_321) AT=800.025n

.meas tran vdout1_322ck1590 FIND v(dout1_322) AT=800.025n

.meas tran vdout1_323ck1590 FIND v(dout1_323) AT=800.025n

.meas tran vdout1_324ck1590 FIND v(dout1_324) AT=800.025n

.meas tran vdout1_325ck1590 FIND v(dout1_325) AT=800.025n

.meas tran vdout1_326ck1590 FIND v(dout1_326) AT=800.025n

.meas tran vdout1_327ck1590 FIND v(dout1_327) AT=800.025n

.meas tran vdout1_328ck1590 FIND v(dout1_328) AT=800.025n

.meas tran vdout1_329ck1590 FIND v(dout1_329) AT=800.025n

.meas tran vdout1_330ck1590 FIND v(dout1_330) AT=800.025n

.meas tran vdout1_331ck1590 FIND v(dout1_331) AT=800.025n

.meas tran vdout1_332ck1590 FIND v(dout1_332) AT=800.025n

.meas tran vdout1_333ck1590 FIND v(dout1_333) AT=800.025n

.meas tran vdout1_334ck1590 FIND v(dout1_334) AT=800.025n

.meas tran vdout1_335ck1590 FIND v(dout1_335) AT=800.025n

.meas tran vdout1_336ck1590 FIND v(dout1_336) AT=800.025n

.meas tran vdout1_337ck1590 FIND v(dout1_337) AT=800.025n

.meas tran vdout1_338ck1590 FIND v(dout1_338) AT=800.025n

.meas tran vdout1_339ck1590 FIND v(dout1_339) AT=800.025n

.meas tran vdout1_340ck1590 FIND v(dout1_340) AT=800.025n

.meas tran vdout1_341ck1590 FIND v(dout1_341) AT=800.025n

.meas tran vdout1_342ck1590 FIND v(dout1_342) AT=800.025n

.meas tran vdout1_343ck1590 FIND v(dout1_343) AT=800.025n

.meas tran vdout1_344ck1590 FIND v(dout1_344) AT=800.025n

.meas tran vdout1_345ck1590 FIND v(dout1_345) AT=800.025n

.meas tran vdout1_346ck1590 FIND v(dout1_346) AT=800.025n

.meas tran vdout1_347ck1590 FIND v(dout1_347) AT=800.025n

.meas tran vdout1_348ck1590 FIND v(dout1_348) AT=800.025n

.meas tran vdout1_349ck1590 FIND v(dout1_349) AT=800.025n

.meas tran vdout1_350ck1590 FIND v(dout1_350) AT=800.025n

.meas tran vdout1_351ck1590 FIND v(dout1_351) AT=800.025n

.meas tran vdout1_352ck1590 FIND v(dout1_352) AT=800.025n

.meas tran vdout1_353ck1590 FIND v(dout1_353) AT=800.025n

.meas tran vdout1_354ck1590 FIND v(dout1_354) AT=800.025n

.meas tran vdout1_355ck1590 FIND v(dout1_355) AT=800.025n

.meas tran vdout1_356ck1590 FIND v(dout1_356) AT=800.025n

.meas tran vdout1_357ck1590 FIND v(dout1_357) AT=800.025n

.meas tran vdout1_358ck1590 FIND v(dout1_358) AT=800.025n

.meas tran vdout1_359ck1590 FIND v(dout1_359) AT=800.025n

.meas tran vdout1_360ck1590 FIND v(dout1_360) AT=800.025n

.meas tran vdout1_361ck1590 FIND v(dout1_361) AT=800.025n

.meas tran vdout1_362ck1590 FIND v(dout1_362) AT=800.025n

.meas tran vdout1_363ck1590 FIND v(dout1_363) AT=800.025n

.meas tran vdout1_364ck1590 FIND v(dout1_364) AT=800.025n

.meas tran vdout1_365ck1590 FIND v(dout1_365) AT=800.025n

.meas tran vdout1_366ck1590 FIND v(dout1_366) AT=800.025n

.meas tran vdout1_367ck1590 FIND v(dout1_367) AT=800.025n

.meas tran vdout1_368ck1590 FIND v(dout1_368) AT=800.025n

.meas tran vdout1_369ck1590 FIND v(dout1_369) AT=800.025n

.meas tran vdout1_370ck1590 FIND v(dout1_370) AT=800.025n

.meas tran vdout1_371ck1590 FIND v(dout1_371) AT=800.025n

.meas tran vdout1_372ck1590 FIND v(dout1_372) AT=800.025n

.meas tran vdout1_373ck1590 FIND v(dout1_373) AT=800.025n

.meas tran vdout1_374ck1590 FIND v(dout1_374) AT=800.025n

.meas tran vdout1_375ck1590 FIND v(dout1_375) AT=800.025n

.meas tran vdout1_376ck1590 FIND v(dout1_376) AT=800.025n

.meas tran vdout1_377ck1590 FIND v(dout1_377) AT=800.025n

.meas tran vdout1_378ck1590 FIND v(dout1_378) AT=800.025n

.meas tran vdout1_379ck1590 FIND v(dout1_379) AT=800.025n

.meas tran vdout1_380ck1590 FIND v(dout1_380) AT=800.025n

.meas tran vdout1_381ck1590 FIND v(dout1_381) AT=800.025n

.meas tran vdout1_382ck1590 FIND v(dout1_382) AT=800.025n

.meas tran vdout1_383ck1590 FIND v(dout1_383) AT=800.025n

.meas tran vdout1_384ck1590 FIND v(dout1_384) AT=800.025n

.meas tran vdout1_385ck1590 FIND v(dout1_385) AT=800.025n

.meas tran vdout1_386ck1590 FIND v(dout1_386) AT=800.025n

.meas tran vdout1_387ck1590 FIND v(dout1_387) AT=800.025n

.meas tran vdout1_388ck1590 FIND v(dout1_388) AT=800.025n

.meas tran vdout1_389ck1590 FIND v(dout1_389) AT=800.025n

.meas tran vdout1_390ck1590 FIND v(dout1_390) AT=800.025n

.meas tran vdout1_391ck1590 FIND v(dout1_391) AT=800.025n

.meas tran vdout1_392ck1590 FIND v(dout1_392) AT=800.025n

.meas tran vdout1_393ck1590 FIND v(dout1_393) AT=800.025n

.meas tran vdout1_394ck1590 FIND v(dout1_394) AT=800.025n

.meas tran vdout1_395ck1590 FIND v(dout1_395) AT=800.025n

.meas tran vdout1_396ck1590 FIND v(dout1_396) AT=800.025n

.meas tran vdout1_397ck1590 FIND v(dout1_397) AT=800.025n

.meas tran vdout1_398ck1590 FIND v(dout1_398) AT=800.025n

.meas tran vdout1_399ck1590 FIND v(dout1_399) AT=800.025n

.meas tran vdout1_400ck1590 FIND v(dout1_400) AT=800.025n

.meas tran vdout1_401ck1590 FIND v(dout1_401) AT=800.025n

.meas tran vdout1_402ck1590 FIND v(dout1_402) AT=800.025n

.meas tran vdout1_403ck1590 FIND v(dout1_403) AT=800.025n

.meas tran vdout1_404ck1590 FIND v(dout1_404) AT=800.025n

.meas tran vdout1_405ck1590 FIND v(dout1_405) AT=800.025n

.meas tran vdout1_406ck1590 FIND v(dout1_406) AT=800.025n

.meas tran vdout1_407ck1590 FIND v(dout1_407) AT=800.025n

.meas tran vdout1_408ck1590 FIND v(dout1_408) AT=800.025n

.meas tran vdout1_409ck1590 FIND v(dout1_409) AT=800.025n

.meas tran vdout1_410ck1590 FIND v(dout1_410) AT=800.025n

.meas tran vdout1_411ck1590 FIND v(dout1_411) AT=800.025n

.meas tran vdout1_412ck1590 FIND v(dout1_412) AT=800.025n

.meas tran vdout1_413ck1590 FIND v(dout1_413) AT=800.025n

.meas tran vdout1_414ck1590 FIND v(dout1_414) AT=800.025n

.meas tran vdout1_415ck1590 FIND v(dout1_415) AT=800.025n

.meas tran vdout1_416ck1590 FIND v(dout1_416) AT=800.025n

.meas tran vdout1_417ck1590 FIND v(dout1_417) AT=800.025n

.meas tran vdout1_418ck1590 FIND v(dout1_418) AT=800.025n

.meas tran vdout1_419ck1590 FIND v(dout1_419) AT=800.025n

.meas tran vdout1_420ck1590 FIND v(dout1_420) AT=800.025n

.meas tran vdout1_421ck1590 FIND v(dout1_421) AT=800.025n

.meas tran vdout1_422ck1590 FIND v(dout1_422) AT=800.025n

.meas tran vdout1_423ck1590 FIND v(dout1_423) AT=800.025n

.meas tran vdout1_424ck1590 FIND v(dout1_424) AT=800.025n

.meas tran vdout1_425ck1590 FIND v(dout1_425) AT=800.025n

.meas tran vdout1_426ck1590 FIND v(dout1_426) AT=800.025n

.meas tran vdout1_427ck1590 FIND v(dout1_427) AT=800.025n

.meas tran vdout1_428ck1590 FIND v(dout1_428) AT=800.025n

.meas tran vdout1_429ck1590 FIND v(dout1_429) AT=800.025n

.meas tran vdout1_430ck1590 FIND v(dout1_430) AT=800.025n

.meas tran vdout1_431ck1590 FIND v(dout1_431) AT=800.025n

.meas tran vdout1_432ck1590 FIND v(dout1_432) AT=800.025n

.meas tran vdout1_433ck1590 FIND v(dout1_433) AT=800.025n

.meas tran vdout1_434ck1590 FIND v(dout1_434) AT=800.025n

.meas tran vdout1_435ck1590 FIND v(dout1_435) AT=800.025n

.meas tran vdout1_436ck1590 FIND v(dout1_436) AT=800.025n

.meas tran vdout1_437ck1590 FIND v(dout1_437) AT=800.025n

.meas tran vdout1_438ck1590 FIND v(dout1_438) AT=800.025n

.meas tran vdout1_439ck1590 FIND v(dout1_439) AT=800.025n

.meas tran vdout1_440ck1590 FIND v(dout1_440) AT=800.025n

.meas tran vdout1_441ck1590 FIND v(dout1_441) AT=800.025n

.meas tran vdout1_442ck1590 FIND v(dout1_442) AT=800.025n

.meas tran vdout1_443ck1590 FIND v(dout1_443) AT=800.025n

.meas tran vdout1_444ck1590 FIND v(dout1_444) AT=800.025n

.meas tran vdout1_445ck1590 FIND v(dout1_445) AT=800.025n

.meas tran vdout1_446ck1590 FIND v(dout1_446) AT=800.025n

.meas tran vdout1_447ck1590 FIND v(dout1_447) AT=800.025n

.meas tran vdout1_448ck1590 FIND v(dout1_448) AT=800.025n

.meas tran vdout1_449ck1590 FIND v(dout1_449) AT=800.025n

.meas tran vdout1_450ck1590 FIND v(dout1_450) AT=800.025n

.meas tran vdout1_451ck1590 FIND v(dout1_451) AT=800.025n

.meas tran vdout1_452ck1590 FIND v(dout1_452) AT=800.025n

.meas tran vdout1_453ck1590 FIND v(dout1_453) AT=800.025n

.meas tran vdout1_454ck1590 FIND v(dout1_454) AT=800.025n

.meas tran vdout1_455ck1590 FIND v(dout1_455) AT=800.025n

.meas tran vdout1_456ck1590 FIND v(dout1_456) AT=800.025n

.meas tran vdout1_457ck1590 FIND v(dout1_457) AT=800.025n

.meas tran vdout1_458ck1590 FIND v(dout1_458) AT=800.025n

.meas tran vdout1_459ck1590 FIND v(dout1_459) AT=800.025n

.meas tran vdout1_460ck1590 FIND v(dout1_460) AT=800.025n

.meas tran vdout1_461ck1590 FIND v(dout1_461) AT=800.025n

.meas tran vdout1_462ck1590 FIND v(dout1_462) AT=800.025n

.meas tran vdout1_463ck1590 FIND v(dout1_463) AT=800.025n

.meas tran vdout1_464ck1590 FIND v(dout1_464) AT=800.025n

.meas tran vdout1_465ck1590 FIND v(dout1_465) AT=800.025n

.meas tran vdout1_466ck1590 FIND v(dout1_466) AT=800.025n

.meas tran vdout1_467ck1590 FIND v(dout1_467) AT=800.025n

.meas tran vdout1_468ck1590 FIND v(dout1_468) AT=800.025n

.meas tran vdout1_469ck1590 FIND v(dout1_469) AT=800.025n

.meas tran vdout1_470ck1590 FIND v(dout1_470) AT=800.025n

.meas tran vdout1_471ck1590 FIND v(dout1_471) AT=800.025n

.meas tran vdout1_472ck1590 FIND v(dout1_472) AT=800.025n

.meas tran vdout1_473ck1590 FIND v(dout1_473) AT=800.025n

.meas tran vdout1_474ck1590 FIND v(dout1_474) AT=800.025n

.meas tran vdout1_475ck1590 FIND v(dout1_475) AT=800.025n

.meas tran vdout1_476ck1590 FIND v(dout1_476) AT=800.025n

.meas tran vdout1_477ck1590 FIND v(dout1_477) AT=800.025n

.meas tran vdout1_478ck1590 FIND v(dout1_478) AT=800.025n

.meas tran vdout1_479ck1590 FIND v(dout1_479) AT=800.025n

.meas tran vdout1_480ck1590 FIND v(dout1_480) AT=800.025n

.meas tran vdout1_481ck1590 FIND v(dout1_481) AT=800.025n

.meas tran vdout1_482ck1590 FIND v(dout1_482) AT=800.025n

.meas tran vdout1_483ck1590 FIND v(dout1_483) AT=800.025n

.meas tran vdout1_484ck1590 FIND v(dout1_484) AT=800.025n

.meas tran vdout1_485ck1590 FIND v(dout1_485) AT=800.025n

.meas tran vdout1_486ck1590 FIND v(dout1_486) AT=800.025n

.meas tran vdout1_487ck1590 FIND v(dout1_487) AT=800.025n

.meas tran vdout1_488ck1590 FIND v(dout1_488) AT=800.025n

.meas tran vdout1_489ck1590 FIND v(dout1_489) AT=800.025n

.meas tran vdout1_490ck1590 FIND v(dout1_490) AT=800.025n

.meas tran vdout1_491ck1590 FIND v(dout1_491) AT=800.025n

.meas tran vdout1_492ck1590 FIND v(dout1_492) AT=800.025n

.meas tran vdout1_493ck1590 FIND v(dout1_493) AT=800.025n

.meas tran vdout1_494ck1590 FIND v(dout1_494) AT=800.025n

.meas tran vdout1_495ck1590 FIND v(dout1_495) AT=800.025n

.meas tran vdout1_496ck1590 FIND v(dout1_496) AT=800.025n

.meas tran vdout1_497ck1590 FIND v(dout1_497) AT=800.025n

.meas tran vdout1_498ck1590 FIND v(dout1_498) AT=800.025n

.meas tran vdout1_499ck1590 FIND v(dout1_499) AT=800.025n

.meas tran vdout1_500ck1590 FIND v(dout1_500) AT=800.025n

.meas tran vdout1_501ck1590 FIND v(dout1_501) AT=800.025n

.meas tran vdout1_502ck1590 FIND v(dout1_502) AT=800.025n

.meas tran vdout1_503ck1590 FIND v(dout1_503) AT=800.025n

.meas tran vdout1_504ck1590 FIND v(dout1_504) AT=800.025n

.meas tran vdout1_505ck1590 FIND v(dout1_505) AT=800.025n

.meas tran vdout1_506ck1590 FIND v(dout1_506) AT=800.025n

.meas tran vdout1_507ck1590 FIND v(dout1_507) AT=800.025n

.meas tran vdout1_508ck1590 FIND v(dout1_508) AT=800.025n

.meas tran vdout1_509ck1590 FIND v(dout1_509) AT=800.025n

.meas tran vdout1_510ck1590 FIND v(dout1_510) AT=800.025n

.meas tran vdout1_511ck1590 FIND v(dout1_511) AT=800.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_22ck1610 FIND v(dout1_22) AT=810.025n

.meas tran vdout1_23ck1610 FIND v(dout1_23) AT=810.025n

.meas tran vdout1_24ck1610 FIND v(dout1_24) AT=810.025n

.meas tran vdout1_25ck1610 FIND v(dout1_25) AT=810.025n

.meas tran vdout1_26ck1610 FIND v(dout1_26) AT=810.025n

.meas tran vdout1_27ck1610 FIND v(dout1_27) AT=810.025n

.meas tran vdout1_28ck1610 FIND v(dout1_28) AT=810.025n

.meas tran vdout1_29ck1610 FIND v(dout1_29) AT=810.025n

.meas tran vdout1_30ck1610 FIND v(dout1_30) AT=810.025n

.meas tran vdout1_31ck1610 FIND v(dout1_31) AT=810.025n

.meas tran vdout1_32ck1610 FIND v(dout1_32) AT=810.025n

.meas tran vdout1_33ck1610 FIND v(dout1_33) AT=810.025n

.meas tran vdout1_34ck1610 FIND v(dout1_34) AT=810.025n

.meas tran vdout1_35ck1610 FIND v(dout1_35) AT=810.025n

.meas tran vdout1_36ck1610 FIND v(dout1_36) AT=810.025n

.meas tran vdout1_37ck1610 FIND v(dout1_37) AT=810.025n

.meas tran vdout1_38ck1610 FIND v(dout1_38) AT=810.025n

.meas tran vdout1_39ck1610 FIND v(dout1_39) AT=810.025n

.meas tran vdout1_40ck1610 FIND v(dout1_40) AT=810.025n

.meas tran vdout1_41ck1610 FIND v(dout1_41) AT=810.025n

.meas tran vdout1_42ck1610 FIND v(dout1_42) AT=810.025n

.meas tran vdout1_43ck1610 FIND v(dout1_43) AT=810.025n

.meas tran vdout1_44ck1610 FIND v(dout1_44) AT=810.025n

.meas tran vdout1_45ck1610 FIND v(dout1_45) AT=810.025n

.meas tran vdout1_46ck1610 FIND v(dout1_46) AT=810.025n

.meas tran vdout1_47ck1610 FIND v(dout1_47) AT=810.025n

.meas tran vdout1_48ck1610 FIND v(dout1_48) AT=810.025n

.meas tran vdout1_49ck1610 FIND v(dout1_49) AT=810.025n

.meas tran vdout1_50ck1610 FIND v(dout1_50) AT=810.025n

.meas tran vdout1_51ck1610 FIND v(dout1_51) AT=810.025n

.meas tran vdout1_52ck1610 FIND v(dout1_52) AT=810.025n

.meas tran vdout1_53ck1610 FIND v(dout1_53) AT=810.025n

.meas tran vdout1_54ck1610 FIND v(dout1_54) AT=810.025n

.meas tran vdout1_55ck1610 FIND v(dout1_55) AT=810.025n

.meas tran vdout1_56ck1610 FIND v(dout1_56) AT=810.025n

.meas tran vdout1_57ck1610 FIND v(dout1_57) AT=810.025n

.meas tran vdout1_58ck1610 FIND v(dout1_58) AT=810.025n

.meas tran vdout1_59ck1610 FIND v(dout1_59) AT=810.025n

.meas tran vdout1_60ck1610 FIND v(dout1_60) AT=810.025n

.meas tran vdout1_61ck1610 FIND v(dout1_61) AT=810.025n

.meas tran vdout1_62ck1610 FIND v(dout1_62) AT=810.025n

.meas tran vdout1_63ck1610 FIND v(dout1_63) AT=810.025n

.meas tran vdout1_64ck1610 FIND v(dout1_64) AT=810.025n

.meas tran vdout1_65ck1610 FIND v(dout1_65) AT=810.025n

.meas tran vdout1_66ck1610 FIND v(dout1_66) AT=810.025n

.meas tran vdout1_67ck1610 FIND v(dout1_67) AT=810.025n

.meas tran vdout1_68ck1610 FIND v(dout1_68) AT=810.025n

.meas tran vdout1_69ck1610 FIND v(dout1_69) AT=810.025n

.meas tran vdout1_70ck1610 FIND v(dout1_70) AT=810.025n

.meas tran vdout1_71ck1610 FIND v(dout1_71) AT=810.025n

.meas tran vdout1_72ck1610 FIND v(dout1_72) AT=810.025n

.meas tran vdout1_73ck1610 FIND v(dout1_73) AT=810.025n

.meas tran vdout1_74ck1610 FIND v(dout1_74) AT=810.025n

.meas tran vdout1_75ck1610 FIND v(dout1_75) AT=810.025n

.meas tran vdout1_76ck1610 FIND v(dout1_76) AT=810.025n

.meas tran vdout1_77ck1610 FIND v(dout1_77) AT=810.025n

.meas tran vdout1_78ck1610 FIND v(dout1_78) AT=810.025n

.meas tran vdout1_79ck1610 FIND v(dout1_79) AT=810.025n

.meas tran vdout1_80ck1610 FIND v(dout1_80) AT=810.025n

.meas tran vdout1_81ck1610 FIND v(dout1_81) AT=810.025n

.meas tran vdout1_82ck1610 FIND v(dout1_82) AT=810.025n

.meas tran vdout1_83ck1610 FIND v(dout1_83) AT=810.025n

.meas tran vdout1_84ck1610 FIND v(dout1_84) AT=810.025n

.meas tran vdout1_85ck1610 FIND v(dout1_85) AT=810.025n

.meas tran vdout1_86ck1610 FIND v(dout1_86) AT=810.025n

.meas tran vdout1_87ck1610 FIND v(dout1_87) AT=810.025n

.meas tran vdout1_88ck1610 FIND v(dout1_88) AT=810.025n

.meas tran vdout1_89ck1610 FIND v(dout1_89) AT=810.025n

.meas tran vdout1_90ck1610 FIND v(dout1_90) AT=810.025n

.meas tran vdout1_91ck1610 FIND v(dout1_91) AT=810.025n

.meas tran vdout1_92ck1610 FIND v(dout1_92) AT=810.025n

.meas tran vdout1_93ck1610 FIND v(dout1_93) AT=810.025n

.meas tran vdout1_94ck1610 FIND v(dout1_94) AT=810.025n

.meas tran vdout1_95ck1610 FIND v(dout1_95) AT=810.025n

.meas tran vdout1_96ck1610 FIND v(dout1_96) AT=810.025n

.meas tran vdout1_97ck1610 FIND v(dout1_97) AT=810.025n

.meas tran vdout1_98ck1610 FIND v(dout1_98) AT=810.025n

.meas tran vdout1_99ck1610 FIND v(dout1_99) AT=810.025n

.meas tran vdout1_100ck1610 FIND v(dout1_100) AT=810.025n

.meas tran vdout1_101ck1610 FIND v(dout1_101) AT=810.025n

.meas tran vdout1_102ck1610 FIND v(dout1_102) AT=810.025n

.meas tran vdout1_103ck1610 FIND v(dout1_103) AT=810.025n

.meas tran vdout1_104ck1610 FIND v(dout1_104) AT=810.025n

.meas tran vdout1_105ck1610 FIND v(dout1_105) AT=810.025n

.meas tran vdout1_106ck1610 FIND v(dout1_106) AT=810.025n

.meas tran vdout1_107ck1610 FIND v(dout1_107) AT=810.025n

.meas tran vdout1_108ck1610 FIND v(dout1_108) AT=810.025n

.meas tran vdout1_109ck1610 FIND v(dout1_109) AT=810.025n

.meas tran vdout1_110ck1610 FIND v(dout1_110) AT=810.025n

.meas tran vdout1_111ck1610 FIND v(dout1_111) AT=810.025n

.meas tran vdout1_112ck1610 FIND v(dout1_112) AT=810.025n

.meas tran vdout1_113ck1610 FIND v(dout1_113) AT=810.025n

.meas tran vdout1_114ck1610 FIND v(dout1_114) AT=810.025n

.meas tran vdout1_115ck1610 FIND v(dout1_115) AT=810.025n

.meas tran vdout1_116ck1610 FIND v(dout1_116) AT=810.025n

.meas tran vdout1_117ck1610 FIND v(dout1_117) AT=810.025n

.meas tran vdout1_118ck1610 FIND v(dout1_118) AT=810.025n

.meas tran vdout1_119ck1610 FIND v(dout1_119) AT=810.025n

.meas tran vdout1_120ck1610 FIND v(dout1_120) AT=810.025n

.meas tran vdout1_121ck1610 FIND v(dout1_121) AT=810.025n

.meas tran vdout1_122ck1610 FIND v(dout1_122) AT=810.025n

.meas tran vdout1_123ck1610 FIND v(dout1_123) AT=810.025n

.meas tran vdout1_124ck1610 FIND v(dout1_124) AT=810.025n

.meas tran vdout1_125ck1610 FIND v(dout1_125) AT=810.025n

.meas tran vdout1_126ck1610 FIND v(dout1_126) AT=810.025n

.meas tran vdout1_127ck1610 FIND v(dout1_127) AT=810.025n

.meas tran vdout1_128ck1610 FIND v(dout1_128) AT=810.025n

.meas tran vdout1_129ck1610 FIND v(dout1_129) AT=810.025n

.meas tran vdout1_130ck1610 FIND v(dout1_130) AT=810.025n

.meas tran vdout1_131ck1610 FIND v(dout1_131) AT=810.025n

.meas tran vdout1_132ck1610 FIND v(dout1_132) AT=810.025n

.meas tran vdout1_133ck1610 FIND v(dout1_133) AT=810.025n

.meas tran vdout1_134ck1610 FIND v(dout1_134) AT=810.025n

.meas tran vdout1_135ck1610 FIND v(dout1_135) AT=810.025n

.meas tran vdout1_136ck1610 FIND v(dout1_136) AT=810.025n

.meas tran vdout1_137ck1610 FIND v(dout1_137) AT=810.025n

.meas tran vdout1_138ck1610 FIND v(dout1_138) AT=810.025n

.meas tran vdout1_139ck1610 FIND v(dout1_139) AT=810.025n

.meas tran vdout1_140ck1610 FIND v(dout1_140) AT=810.025n

.meas tran vdout1_141ck1610 FIND v(dout1_141) AT=810.025n

.meas tran vdout1_142ck1610 FIND v(dout1_142) AT=810.025n

.meas tran vdout1_143ck1610 FIND v(dout1_143) AT=810.025n

.meas tran vdout1_144ck1610 FIND v(dout1_144) AT=810.025n

.meas tran vdout1_145ck1610 FIND v(dout1_145) AT=810.025n

.meas tran vdout1_146ck1610 FIND v(dout1_146) AT=810.025n

.meas tran vdout1_147ck1610 FIND v(dout1_147) AT=810.025n

.meas tran vdout1_148ck1610 FIND v(dout1_148) AT=810.025n

.meas tran vdout1_149ck1610 FIND v(dout1_149) AT=810.025n

.meas tran vdout1_150ck1610 FIND v(dout1_150) AT=810.025n

.meas tran vdout1_151ck1610 FIND v(dout1_151) AT=810.025n

.meas tran vdout1_152ck1610 FIND v(dout1_152) AT=810.025n

.meas tran vdout1_153ck1610 FIND v(dout1_153) AT=810.025n

.meas tran vdout1_154ck1610 FIND v(dout1_154) AT=810.025n

.meas tran vdout1_155ck1610 FIND v(dout1_155) AT=810.025n

.meas tran vdout1_156ck1610 FIND v(dout1_156) AT=810.025n

.meas tran vdout1_157ck1610 FIND v(dout1_157) AT=810.025n

.meas tran vdout1_158ck1610 FIND v(dout1_158) AT=810.025n

.meas tran vdout1_159ck1610 FIND v(dout1_159) AT=810.025n

.meas tran vdout1_160ck1610 FIND v(dout1_160) AT=810.025n

.meas tran vdout1_161ck1610 FIND v(dout1_161) AT=810.025n

.meas tran vdout1_162ck1610 FIND v(dout1_162) AT=810.025n

.meas tran vdout1_163ck1610 FIND v(dout1_163) AT=810.025n

.meas tran vdout1_164ck1610 FIND v(dout1_164) AT=810.025n

.meas tran vdout1_165ck1610 FIND v(dout1_165) AT=810.025n

.meas tran vdout1_166ck1610 FIND v(dout1_166) AT=810.025n

.meas tran vdout1_167ck1610 FIND v(dout1_167) AT=810.025n

.meas tran vdout1_168ck1610 FIND v(dout1_168) AT=810.025n

.meas tran vdout1_169ck1610 FIND v(dout1_169) AT=810.025n

.meas tran vdout1_170ck1610 FIND v(dout1_170) AT=810.025n

.meas tran vdout1_171ck1610 FIND v(dout1_171) AT=810.025n

.meas tran vdout1_172ck1610 FIND v(dout1_172) AT=810.025n

.meas tran vdout1_173ck1610 FIND v(dout1_173) AT=810.025n

.meas tran vdout1_174ck1610 FIND v(dout1_174) AT=810.025n

.meas tran vdout1_175ck1610 FIND v(dout1_175) AT=810.025n

.meas tran vdout1_176ck1610 FIND v(dout1_176) AT=810.025n

.meas tran vdout1_177ck1610 FIND v(dout1_177) AT=810.025n

.meas tran vdout1_178ck1610 FIND v(dout1_178) AT=810.025n

.meas tran vdout1_179ck1610 FIND v(dout1_179) AT=810.025n

.meas tran vdout1_180ck1610 FIND v(dout1_180) AT=810.025n

.meas tran vdout1_181ck1610 FIND v(dout1_181) AT=810.025n

.meas tran vdout1_182ck1610 FIND v(dout1_182) AT=810.025n

.meas tran vdout1_183ck1610 FIND v(dout1_183) AT=810.025n

.meas tran vdout1_184ck1610 FIND v(dout1_184) AT=810.025n

.meas tran vdout1_185ck1610 FIND v(dout1_185) AT=810.025n

.meas tran vdout1_186ck1610 FIND v(dout1_186) AT=810.025n

.meas tran vdout1_187ck1610 FIND v(dout1_187) AT=810.025n

.meas tran vdout1_188ck1610 FIND v(dout1_188) AT=810.025n

.meas tran vdout1_189ck1610 FIND v(dout1_189) AT=810.025n

.meas tran vdout1_190ck1610 FIND v(dout1_190) AT=810.025n

.meas tran vdout1_191ck1610 FIND v(dout1_191) AT=810.025n

.meas tran vdout1_192ck1610 FIND v(dout1_192) AT=810.025n

.meas tran vdout1_193ck1610 FIND v(dout1_193) AT=810.025n

.meas tran vdout1_194ck1610 FIND v(dout1_194) AT=810.025n

.meas tran vdout1_195ck1610 FIND v(dout1_195) AT=810.025n

.meas tran vdout1_196ck1610 FIND v(dout1_196) AT=810.025n

.meas tran vdout1_197ck1610 FIND v(dout1_197) AT=810.025n

.meas tran vdout1_198ck1610 FIND v(dout1_198) AT=810.025n

.meas tran vdout1_199ck1610 FIND v(dout1_199) AT=810.025n

.meas tran vdout1_200ck1610 FIND v(dout1_200) AT=810.025n

.meas tran vdout1_201ck1610 FIND v(dout1_201) AT=810.025n

.meas tran vdout1_202ck1610 FIND v(dout1_202) AT=810.025n

.meas tran vdout1_203ck1610 FIND v(dout1_203) AT=810.025n

.meas tran vdout1_204ck1610 FIND v(dout1_204) AT=810.025n

.meas tran vdout1_205ck1610 FIND v(dout1_205) AT=810.025n

.meas tran vdout1_206ck1610 FIND v(dout1_206) AT=810.025n

.meas tran vdout1_207ck1610 FIND v(dout1_207) AT=810.025n

.meas tran vdout1_208ck1610 FIND v(dout1_208) AT=810.025n

.meas tran vdout1_209ck1610 FIND v(dout1_209) AT=810.025n

.meas tran vdout1_210ck1610 FIND v(dout1_210) AT=810.025n

.meas tran vdout1_211ck1610 FIND v(dout1_211) AT=810.025n

.meas tran vdout1_212ck1610 FIND v(dout1_212) AT=810.025n

.meas tran vdout1_213ck1610 FIND v(dout1_213) AT=810.025n

.meas tran vdout1_214ck1610 FIND v(dout1_214) AT=810.025n

.meas tran vdout1_215ck1610 FIND v(dout1_215) AT=810.025n

.meas tran vdout1_216ck1610 FIND v(dout1_216) AT=810.025n

.meas tran vdout1_217ck1610 FIND v(dout1_217) AT=810.025n

.meas tran vdout1_218ck1610 FIND v(dout1_218) AT=810.025n

.meas tran vdout1_219ck1610 FIND v(dout1_219) AT=810.025n

.meas tran vdout1_220ck1610 FIND v(dout1_220) AT=810.025n

.meas tran vdout1_221ck1610 FIND v(dout1_221) AT=810.025n

.meas tran vdout1_222ck1610 FIND v(dout1_222) AT=810.025n

.meas tran vdout1_223ck1610 FIND v(dout1_223) AT=810.025n

.meas tran vdout1_224ck1610 FIND v(dout1_224) AT=810.025n

.meas tran vdout1_225ck1610 FIND v(dout1_225) AT=810.025n

.meas tran vdout1_226ck1610 FIND v(dout1_226) AT=810.025n

.meas tran vdout1_227ck1610 FIND v(dout1_227) AT=810.025n

.meas tran vdout1_228ck1610 FIND v(dout1_228) AT=810.025n

.meas tran vdout1_229ck1610 FIND v(dout1_229) AT=810.025n

.meas tran vdout1_230ck1610 FIND v(dout1_230) AT=810.025n

.meas tran vdout1_231ck1610 FIND v(dout1_231) AT=810.025n

.meas tran vdout1_232ck1610 FIND v(dout1_232) AT=810.025n

.meas tran vdout1_233ck1610 FIND v(dout1_233) AT=810.025n

.meas tran vdout1_234ck1610 FIND v(dout1_234) AT=810.025n

.meas tran vdout1_235ck1610 FIND v(dout1_235) AT=810.025n

.meas tran vdout1_236ck1610 FIND v(dout1_236) AT=810.025n

.meas tran vdout1_237ck1610 FIND v(dout1_237) AT=810.025n

.meas tran vdout1_238ck1610 FIND v(dout1_238) AT=810.025n

.meas tran vdout1_239ck1610 FIND v(dout1_239) AT=810.025n

.meas tran vdout1_240ck1610 FIND v(dout1_240) AT=810.025n

.meas tran vdout1_241ck1610 FIND v(dout1_241) AT=810.025n

.meas tran vdout1_242ck1610 FIND v(dout1_242) AT=810.025n

.meas tran vdout1_243ck1610 FIND v(dout1_243) AT=810.025n

.meas tran vdout1_244ck1610 FIND v(dout1_244) AT=810.025n

.meas tran vdout1_245ck1610 FIND v(dout1_245) AT=810.025n

.meas tran vdout1_246ck1610 FIND v(dout1_246) AT=810.025n

.meas tran vdout1_247ck1610 FIND v(dout1_247) AT=810.025n

.meas tran vdout1_248ck1610 FIND v(dout1_248) AT=810.025n

.meas tran vdout1_249ck1610 FIND v(dout1_249) AT=810.025n

.meas tran vdout1_250ck1610 FIND v(dout1_250) AT=810.025n

.meas tran vdout1_251ck1610 FIND v(dout1_251) AT=810.025n

.meas tran vdout1_252ck1610 FIND v(dout1_252) AT=810.025n

.meas tran vdout1_253ck1610 FIND v(dout1_253) AT=810.025n

.meas tran vdout1_254ck1610 FIND v(dout1_254) AT=810.025n

.meas tran vdout1_255ck1610 FIND v(dout1_255) AT=810.025n

.meas tran vdout1_256ck1610 FIND v(dout1_256) AT=810.025n

.meas tran vdout1_257ck1610 FIND v(dout1_257) AT=810.025n

.meas tran vdout1_258ck1610 FIND v(dout1_258) AT=810.025n

.meas tran vdout1_259ck1610 FIND v(dout1_259) AT=810.025n

.meas tran vdout1_260ck1610 FIND v(dout1_260) AT=810.025n

.meas tran vdout1_261ck1610 FIND v(dout1_261) AT=810.025n

.meas tran vdout1_262ck1610 FIND v(dout1_262) AT=810.025n

.meas tran vdout1_263ck1610 FIND v(dout1_263) AT=810.025n

.meas tran vdout1_264ck1610 FIND v(dout1_264) AT=810.025n

.meas tran vdout1_265ck1610 FIND v(dout1_265) AT=810.025n

.meas tran vdout1_266ck1610 FIND v(dout1_266) AT=810.025n

.meas tran vdout1_267ck1610 FIND v(dout1_267) AT=810.025n

.meas tran vdout1_268ck1610 FIND v(dout1_268) AT=810.025n

.meas tran vdout1_269ck1610 FIND v(dout1_269) AT=810.025n

.meas tran vdout1_270ck1610 FIND v(dout1_270) AT=810.025n

.meas tran vdout1_271ck1610 FIND v(dout1_271) AT=810.025n

.meas tran vdout1_272ck1610 FIND v(dout1_272) AT=810.025n

.meas tran vdout1_273ck1610 FIND v(dout1_273) AT=810.025n

.meas tran vdout1_274ck1610 FIND v(dout1_274) AT=810.025n

.meas tran vdout1_275ck1610 FIND v(dout1_275) AT=810.025n

.meas tran vdout1_276ck1610 FIND v(dout1_276) AT=810.025n

.meas tran vdout1_277ck1610 FIND v(dout1_277) AT=810.025n

.meas tran vdout1_278ck1610 FIND v(dout1_278) AT=810.025n

.meas tran vdout1_279ck1610 FIND v(dout1_279) AT=810.025n

.meas tran vdout1_280ck1610 FIND v(dout1_280) AT=810.025n

.meas tran vdout1_281ck1610 FIND v(dout1_281) AT=810.025n

.meas tran vdout1_282ck1610 FIND v(dout1_282) AT=810.025n

.meas tran vdout1_283ck1610 FIND v(dout1_283) AT=810.025n

.meas tran vdout1_284ck1610 FIND v(dout1_284) AT=810.025n

.meas tran vdout1_285ck1610 FIND v(dout1_285) AT=810.025n

.meas tran vdout1_286ck1610 FIND v(dout1_286) AT=810.025n

.meas tran vdout1_287ck1610 FIND v(dout1_287) AT=810.025n

.meas tran vdout1_288ck1610 FIND v(dout1_288) AT=810.025n

.meas tran vdout1_289ck1610 FIND v(dout1_289) AT=810.025n

.meas tran vdout1_290ck1610 FIND v(dout1_290) AT=810.025n

.meas tran vdout1_291ck1610 FIND v(dout1_291) AT=810.025n

.meas tran vdout1_292ck1610 FIND v(dout1_292) AT=810.025n

.meas tran vdout1_293ck1610 FIND v(dout1_293) AT=810.025n

.meas tran vdout1_294ck1610 FIND v(dout1_294) AT=810.025n

.meas tran vdout1_295ck1610 FIND v(dout1_295) AT=810.025n

.meas tran vdout1_296ck1610 FIND v(dout1_296) AT=810.025n

.meas tran vdout1_297ck1610 FIND v(dout1_297) AT=810.025n

.meas tran vdout1_298ck1610 FIND v(dout1_298) AT=810.025n

.meas tran vdout1_299ck1610 FIND v(dout1_299) AT=810.025n

.meas tran vdout1_300ck1610 FIND v(dout1_300) AT=810.025n

.meas tran vdout1_301ck1610 FIND v(dout1_301) AT=810.025n

.meas tran vdout1_302ck1610 FIND v(dout1_302) AT=810.025n

.meas tran vdout1_303ck1610 FIND v(dout1_303) AT=810.025n

.meas tran vdout1_304ck1610 FIND v(dout1_304) AT=810.025n

.meas tran vdout1_305ck1610 FIND v(dout1_305) AT=810.025n

.meas tran vdout1_306ck1610 FIND v(dout1_306) AT=810.025n

.meas tran vdout1_307ck1610 FIND v(dout1_307) AT=810.025n

.meas tran vdout1_308ck1610 FIND v(dout1_308) AT=810.025n

.meas tran vdout1_309ck1610 FIND v(dout1_309) AT=810.025n

.meas tran vdout1_310ck1610 FIND v(dout1_310) AT=810.025n

.meas tran vdout1_311ck1610 FIND v(dout1_311) AT=810.025n

.meas tran vdout1_312ck1610 FIND v(dout1_312) AT=810.025n

.meas tran vdout1_313ck1610 FIND v(dout1_313) AT=810.025n

.meas tran vdout1_314ck1610 FIND v(dout1_314) AT=810.025n

.meas tran vdout1_315ck1610 FIND v(dout1_315) AT=810.025n

.meas tran vdout1_316ck1610 FIND v(dout1_316) AT=810.025n

.meas tran vdout1_317ck1610 FIND v(dout1_317) AT=810.025n

.meas tran vdout1_318ck1610 FIND v(dout1_318) AT=810.025n

.meas tran vdout1_319ck1610 FIND v(dout1_319) AT=810.025n

.meas tran vdout1_320ck1610 FIND v(dout1_320) AT=810.025n

.meas tran vdout1_321ck1610 FIND v(dout1_321) AT=810.025n

.meas tran vdout1_322ck1610 FIND v(dout1_322) AT=810.025n

.meas tran vdout1_323ck1610 FIND v(dout1_323) AT=810.025n

.meas tran vdout1_324ck1610 FIND v(dout1_324) AT=810.025n

.meas tran vdout1_325ck1610 FIND v(dout1_325) AT=810.025n

.meas tran vdout1_326ck1610 FIND v(dout1_326) AT=810.025n

.meas tran vdout1_327ck1610 FIND v(dout1_327) AT=810.025n

.meas tran vdout1_328ck1610 FIND v(dout1_328) AT=810.025n

.meas tran vdout1_329ck1610 FIND v(dout1_329) AT=810.025n

.meas tran vdout1_330ck1610 FIND v(dout1_330) AT=810.025n

.meas tran vdout1_331ck1610 FIND v(dout1_331) AT=810.025n

.meas tran vdout1_332ck1610 FIND v(dout1_332) AT=810.025n

.meas tran vdout1_333ck1610 FIND v(dout1_333) AT=810.025n

.meas tran vdout1_334ck1610 FIND v(dout1_334) AT=810.025n

.meas tran vdout1_335ck1610 FIND v(dout1_335) AT=810.025n

.meas tran vdout1_336ck1610 FIND v(dout1_336) AT=810.025n

.meas tran vdout1_337ck1610 FIND v(dout1_337) AT=810.025n

.meas tran vdout1_338ck1610 FIND v(dout1_338) AT=810.025n

.meas tran vdout1_339ck1610 FIND v(dout1_339) AT=810.025n

.meas tran vdout1_340ck1610 FIND v(dout1_340) AT=810.025n

.meas tran vdout1_341ck1610 FIND v(dout1_341) AT=810.025n

.meas tran vdout1_342ck1610 FIND v(dout1_342) AT=810.025n

.meas tran vdout1_343ck1610 FIND v(dout1_343) AT=810.025n

.meas tran vdout1_344ck1610 FIND v(dout1_344) AT=810.025n

.meas tran vdout1_345ck1610 FIND v(dout1_345) AT=810.025n

.meas tran vdout1_346ck1610 FIND v(dout1_346) AT=810.025n

.meas tran vdout1_347ck1610 FIND v(dout1_347) AT=810.025n

.meas tran vdout1_348ck1610 FIND v(dout1_348) AT=810.025n

.meas tran vdout1_349ck1610 FIND v(dout1_349) AT=810.025n

.meas tran vdout1_350ck1610 FIND v(dout1_350) AT=810.025n

.meas tran vdout1_351ck1610 FIND v(dout1_351) AT=810.025n

.meas tran vdout1_352ck1610 FIND v(dout1_352) AT=810.025n

.meas tran vdout1_353ck1610 FIND v(dout1_353) AT=810.025n

.meas tran vdout1_354ck1610 FIND v(dout1_354) AT=810.025n

.meas tran vdout1_355ck1610 FIND v(dout1_355) AT=810.025n

.meas tran vdout1_356ck1610 FIND v(dout1_356) AT=810.025n

.meas tran vdout1_357ck1610 FIND v(dout1_357) AT=810.025n

.meas tran vdout1_358ck1610 FIND v(dout1_358) AT=810.025n

.meas tran vdout1_359ck1610 FIND v(dout1_359) AT=810.025n

.meas tran vdout1_360ck1610 FIND v(dout1_360) AT=810.025n

.meas tran vdout1_361ck1610 FIND v(dout1_361) AT=810.025n

.meas tran vdout1_362ck1610 FIND v(dout1_362) AT=810.025n

.meas tran vdout1_363ck1610 FIND v(dout1_363) AT=810.025n

.meas tran vdout1_364ck1610 FIND v(dout1_364) AT=810.025n

.meas tran vdout1_365ck1610 FIND v(dout1_365) AT=810.025n

.meas tran vdout1_366ck1610 FIND v(dout1_366) AT=810.025n

.meas tran vdout1_367ck1610 FIND v(dout1_367) AT=810.025n

.meas tran vdout1_368ck1610 FIND v(dout1_368) AT=810.025n

.meas tran vdout1_369ck1610 FIND v(dout1_369) AT=810.025n

.meas tran vdout1_370ck1610 FIND v(dout1_370) AT=810.025n

.meas tran vdout1_371ck1610 FIND v(dout1_371) AT=810.025n

.meas tran vdout1_372ck1610 FIND v(dout1_372) AT=810.025n

.meas tran vdout1_373ck1610 FIND v(dout1_373) AT=810.025n

.meas tran vdout1_374ck1610 FIND v(dout1_374) AT=810.025n

.meas tran vdout1_375ck1610 FIND v(dout1_375) AT=810.025n

.meas tran vdout1_376ck1610 FIND v(dout1_376) AT=810.025n

.meas tran vdout1_377ck1610 FIND v(dout1_377) AT=810.025n

.meas tran vdout1_378ck1610 FIND v(dout1_378) AT=810.025n

.meas tran vdout1_379ck1610 FIND v(dout1_379) AT=810.025n

.meas tran vdout1_380ck1610 FIND v(dout1_380) AT=810.025n

.meas tran vdout1_381ck1610 FIND v(dout1_381) AT=810.025n

.meas tran vdout1_382ck1610 FIND v(dout1_382) AT=810.025n

.meas tran vdout1_383ck1610 FIND v(dout1_383) AT=810.025n

.meas tran vdout1_384ck1610 FIND v(dout1_384) AT=810.025n

.meas tran vdout1_385ck1610 FIND v(dout1_385) AT=810.025n

.meas tran vdout1_386ck1610 FIND v(dout1_386) AT=810.025n

.meas tran vdout1_387ck1610 FIND v(dout1_387) AT=810.025n

.meas tran vdout1_388ck1610 FIND v(dout1_388) AT=810.025n

.meas tran vdout1_389ck1610 FIND v(dout1_389) AT=810.025n

.meas tran vdout1_390ck1610 FIND v(dout1_390) AT=810.025n

.meas tran vdout1_391ck1610 FIND v(dout1_391) AT=810.025n

.meas tran vdout1_392ck1610 FIND v(dout1_392) AT=810.025n

.meas tran vdout1_393ck1610 FIND v(dout1_393) AT=810.025n

.meas tran vdout1_394ck1610 FIND v(dout1_394) AT=810.025n

.meas tran vdout1_395ck1610 FIND v(dout1_395) AT=810.025n

.meas tran vdout1_396ck1610 FIND v(dout1_396) AT=810.025n

.meas tran vdout1_397ck1610 FIND v(dout1_397) AT=810.025n

.meas tran vdout1_398ck1610 FIND v(dout1_398) AT=810.025n

.meas tran vdout1_399ck1610 FIND v(dout1_399) AT=810.025n

.meas tran vdout1_400ck1610 FIND v(dout1_400) AT=810.025n

.meas tran vdout1_401ck1610 FIND v(dout1_401) AT=810.025n

.meas tran vdout1_402ck1610 FIND v(dout1_402) AT=810.025n

.meas tran vdout1_403ck1610 FIND v(dout1_403) AT=810.025n

.meas tran vdout1_404ck1610 FIND v(dout1_404) AT=810.025n

.meas tran vdout1_405ck1610 FIND v(dout1_405) AT=810.025n

.meas tran vdout1_406ck1610 FIND v(dout1_406) AT=810.025n

.meas tran vdout1_407ck1610 FIND v(dout1_407) AT=810.025n

.meas tran vdout1_408ck1610 FIND v(dout1_408) AT=810.025n

.meas tran vdout1_409ck1610 FIND v(dout1_409) AT=810.025n

.meas tran vdout1_410ck1610 FIND v(dout1_410) AT=810.025n

.meas tran vdout1_411ck1610 FIND v(dout1_411) AT=810.025n

.meas tran vdout1_412ck1610 FIND v(dout1_412) AT=810.025n

.meas tran vdout1_413ck1610 FIND v(dout1_413) AT=810.025n

.meas tran vdout1_414ck1610 FIND v(dout1_414) AT=810.025n

.meas tran vdout1_415ck1610 FIND v(dout1_415) AT=810.025n

.meas tran vdout1_416ck1610 FIND v(dout1_416) AT=810.025n

.meas tran vdout1_417ck1610 FIND v(dout1_417) AT=810.025n

.meas tran vdout1_418ck1610 FIND v(dout1_418) AT=810.025n

.meas tran vdout1_419ck1610 FIND v(dout1_419) AT=810.025n

.meas tran vdout1_420ck1610 FIND v(dout1_420) AT=810.025n

.meas tran vdout1_421ck1610 FIND v(dout1_421) AT=810.025n

.meas tran vdout1_422ck1610 FIND v(dout1_422) AT=810.025n

.meas tran vdout1_423ck1610 FIND v(dout1_423) AT=810.025n

.meas tran vdout1_424ck1610 FIND v(dout1_424) AT=810.025n

.meas tran vdout1_425ck1610 FIND v(dout1_425) AT=810.025n

.meas tran vdout1_426ck1610 FIND v(dout1_426) AT=810.025n

.meas tran vdout1_427ck1610 FIND v(dout1_427) AT=810.025n

.meas tran vdout1_428ck1610 FIND v(dout1_428) AT=810.025n

.meas tran vdout1_429ck1610 FIND v(dout1_429) AT=810.025n

.meas tran vdout1_430ck1610 FIND v(dout1_430) AT=810.025n

.meas tran vdout1_431ck1610 FIND v(dout1_431) AT=810.025n

.meas tran vdout1_432ck1610 FIND v(dout1_432) AT=810.025n

.meas tran vdout1_433ck1610 FIND v(dout1_433) AT=810.025n

.meas tran vdout1_434ck1610 FIND v(dout1_434) AT=810.025n

.meas tran vdout1_435ck1610 FIND v(dout1_435) AT=810.025n

.meas tran vdout1_436ck1610 FIND v(dout1_436) AT=810.025n

.meas tran vdout1_437ck1610 FIND v(dout1_437) AT=810.025n

.meas tran vdout1_438ck1610 FIND v(dout1_438) AT=810.025n

.meas tran vdout1_439ck1610 FIND v(dout1_439) AT=810.025n

.meas tran vdout1_440ck1610 FIND v(dout1_440) AT=810.025n

.meas tran vdout1_441ck1610 FIND v(dout1_441) AT=810.025n

.meas tran vdout1_442ck1610 FIND v(dout1_442) AT=810.025n

.meas tran vdout1_443ck1610 FIND v(dout1_443) AT=810.025n

.meas tran vdout1_444ck1610 FIND v(dout1_444) AT=810.025n

.meas tran vdout1_445ck1610 FIND v(dout1_445) AT=810.025n

.meas tran vdout1_446ck1610 FIND v(dout1_446) AT=810.025n

.meas tran vdout1_447ck1610 FIND v(dout1_447) AT=810.025n

.meas tran vdout1_448ck1610 FIND v(dout1_448) AT=810.025n

.meas tran vdout1_449ck1610 FIND v(dout1_449) AT=810.025n

.meas tran vdout1_450ck1610 FIND v(dout1_450) AT=810.025n

.meas tran vdout1_451ck1610 FIND v(dout1_451) AT=810.025n

.meas tran vdout1_452ck1610 FIND v(dout1_452) AT=810.025n

.meas tran vdout1_453ck1610 FIND v(dout1_453) AT=810.025n

.meas tran vdout1_454ck1610 FIND v(dout1_454) AT=810.025n

.meas tran vdout1_455ck1610 FIND v(dout1_455) AT=810.025n

.meas tran vdout1_456ck1610 FIND v(dout1_456) AT=810.025n

.meas tran vdout1_457ck1610 FIND v(dout1_457) AT=810.025n

.meas tran vdout1_458ck1610 FIND v(dout1_458) AT=810.025n

.meas tran vdout1_459ck1610 FIND v(dout1_459) AT=810.025n

.meas tran vdout1_460ck1610 FIND v(dout1_460) AT=810.025n

.meas tran vdout1_461ck1610 FIND v(dout1_461) AT=810.025n

.meas tran vdout1_462ck1610 FIND v(dout1_462) AT=810.025n

.meas tran vdout1_463ck1610 FIND v(dout1_463) AT=810.025n

.meas tran vdout1_464ck1610 FIND v(dout1_464) AT=810.025n

.meas tran vdout1_465ck1610 FIND v(dout1_465) AT=810.025n

.meas tran vdout1_466ck1610 FIND v(dout1_466) AT=810.025n

.meas tran vdout1_467ck1610 FIND v(dout1_467) AT=810.025n

.meas tran vdout1_468ck1610 FIND v(dout1_468) AT=810.025n

.meas tran vdout1_469ck1610 FIND v(dout1_469) AT=810.025n

.meas tran vdout1_470ck1610 FIND v(dout1_470) AT=810.025n

.meas tran vdout1_471ck1610 FIND v(dout1_471) AT=810.025n

.meas tran vdout1_472ck1610 FIND v(dout1_472) AT=810.025n

.meas tran vdout1_473ck1610 FIND v(dout1_473) AT=810.025n

.meas tran vdout1_474ck1610 FIND v(dout1_474) AT=810.025n

.meas tran vdout1_475ck1610 FIND v(dout1_475) AT=810.025n

.meas tran vdout1_476ck1610 FIND v(dout1_476) AT=810.025n

.meas tran vdout1_477ck1610 FIND v(dout1_477) AT=810.025n

.meas tran vdout1_478ck1610 FIND v(dout1_478) AT=810.025n

.meas tran vdout1_479ck1610 FIND v(dout1_479) AT=810.025n

.meas tran vdout1_480ck1610 FIND v(dout1_480) AT=810.025n

.meas tran vdout1_481ck1610 FIND v(dout1_481) AT=810.025n

.meas tran vdout1_482ck1610 FIND v(dout1_482) AT=810.025n

.meas tran vdout1_483ck1610 FIND v(dout1_483) AT=810.025n

.meas tran vdout1_484ck1610 FIND v(dout1_484) AT=810.025n

.meas tran vdout1_485ck1610 FIND v(dout1_485) AT=810.025n

.meas tran vdout1_486ck1610 FIND v(dout1_486) AT=810.025n

.meas tran vdout1_487ck1610 FIND v(dout1_487) AT=810.025n

.meas tran vdout1_488ck1610 FIND v(dout1_488) AT=810.025n

.meas tran vdout1_489ck1610 FIND v(dout1_489) AT=810.025n

.meas tran vdout1_490ck1610 FIND v(dout1_490) AT=810.025n

.meas tran vdout1_491ck1610 FIND v(dout1_491) AT=810.025n

.meas tran vdout1_492ck1610 FIND v(dout1_492) AT=810.025n

.meas tran vdout1_493ck1610 FIND v(dout1_493) AT=810.025n

.meas tran vdout1_494ck1610 FIND v(dout1_494) AT=810.025n

.meas tran vdout1_495ck1610 FIND v(dout1_495) AT=810.025n

.meas tran vdout1_496ck1610 FIND v(dout1_496) AT=810.025n

.meas tran vdout1_497ck1610 FIND v(dout1_497) AT=810.025n

.meas tran vdout1_498ck1610 FIND v(dout1_498) AT=810.025n

.meas tran vdout1_499ck1610 FIND v(dout1_499) AT=810.025n

.meas tran vdout1_500ck1610 FIND v(dout1_500) AT=810.025n

.meas tran vdout1_501ck1610 FIND v(dout1_501) AT=810.025n

.meas tran vdout1_502ck1610 FIND v(dout1_502) AT=810.025n

.meas tran vdout1_503ck1610 FIND v(dout1_503) AT=810.025n

.meas tran vdout1_504ck1610 FIND v(dout1_504) AT=810.025n

.meas tran vdout1_505ck1610 FIND v(dout1_505) AT=810.025n

.meas tran vdout1_506ck1610 FIND v(dout1_506) AT=810.025n

.meas tran vdout1_507ck1610 FIND v(dout1_507) AT=810.025n

.meas tran vdout1_508ck1610 FIND v(dout1_508) AT=810.025n

.meas tran vdout1_509ck1610 FIND v(dout1_509) AT=810.025n

.meas tran vdout1_510ck1610 FIND v(dout1_510) AT=810.025n

.meas tran vdout1_511ck1610 FIND v(dout1_511) AT=810.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_32ck1630 FIND v(dout1_32) AT=820.025n

.meas tran vdout1_33ck1630 FIND v(dout1_33) AT=820.025n

.meas tran vdout1_34ck1630 FIND v(dout1_34) AT=820.025n

.meas tran vdout1_35ck1630 FIND v(dout1_35) AT=820.025n

.meas tran vdout1_36ck1630 FIND v(dout1_36) AT=820.025n

.meas tran vdout1_37ck1630 FIND v(dout1_37) AT=820.025n

.meas tran vdout1_38ck1630 FIND v(dout1_38) AT=820.025n

.meas tran vdout1_39ck1630 FIND v(dout1_39) AT=820.025n

.meas tran vdout1_40ck1630 FIND v(dout1_40) AT=820.025n

.meas tran vdout1_41ck1630 FIND v(dout1_41) AT=820.025n

.meas tran vdout1_42ck1630 FIND v(dout1_42) AT=820.025n

.meas tran vdout1_43ck1630 FIND v(dout1_43) AT=820.025n

.meas tran vdout1_44ck1630 FIND v(dout1_44) AT=820.025n

.meas tran vdout1_45ck1630 FIND v(dout1_45) AT=820.025n

.meas tran vdout1_46ck1630 FIND v(dout1_46) AT=820.025n

.meas tran vdout1_47ck1630 FIND v(dout1_47) AT=820.025n

.meas tran vdout1_48ck1630 FIND v(dout1_48) AT=820.025n

.meas tran vdout1_49ck1630 FIND v(dout1_49) AT=820.025n

.meas tran vdout1_50ck1630 FIND v(dout1_50) AT=820.025n

.meas tran vdout1_51ck1630 FIND v(dout1_51) AT=820.025n

.meas tran vdout1_52ck1630 FIND v(dout1_52) AT=820.025n

.meas tran vdout1_53ck1630 FIND v(dout1_53) AT=820.025n

.meas tran vdout1_54ck1630 FIND v(dout1_54) AT=820.025n

.meas tran vdout1_55ck1630 FIND v(dout1_55) AT=820.025n

.meas tran vdout1_56ck1630 FIND v(dout1_56) AT=820.025n

.meas tran vdout1_57ck1630 FIND v(dout1_57) AT=820.025n

.meas tran vdout1_58ck1630 FIND v(dout1_58) AT=820.025n

.meas tran vdout1_59ck1630 FIND v(dout1_59) AT=820.025n

.meas tran vdout1_60ck1630 FIND v(dout1_60) AT=820.025n

.meas tran vdout1_61ck1630 FIND v(dout1_61) AT=820.025n

.meas tran vdout1_62ck1630 FIND v(dout1_62) AT=820.025n

.meas tran vdout1_63ck1630 FIND v(dout1_63) AT=820.025n

.meas tran vdout1_64ck1630 FIND v(dout1_64) AT=820.025n

.meas tran vdout1_65ck1630 FIND v(dout1_65) AT=820.025n

.meas tran vdout1_66ck1630 FIND v(dout1_66) AT=820.025n

.meas tran vdout1_67ck1630 FIND v(dout1_67) AT=820.025n

.meas tran vdout1_68ck1630 FIND v(dout1_68) AT=820.025n

.meas tran vdout1_69ck1630 FIND v(dout1_69) AT=820.025n

.meas tran vdout1_70ck1630 FIND v(dout1_70) AT=820.025n

.meas tran vdout1_71ck1630 FIND v(dout1_71) AT=820.025n

.meas tran vdout1_72ck1630 FIND v(dout1_72) AT=820.025n

.meas tran vdout1_73ck1630 FIND v(dout1_73) AT=820.025n

.meas tran vdout1_74ck1630 FIND v(dout1_74) AT=820.025n

.meas tran vdout1_75ck1630 FIND v(dout1_75) AT=820.025n

.meas tran vdout1_76ck1630 FIND v(dout1_76) AT=820.025n

.meas tran vdout1_77ck1630 FIND v(dout1_77) AT=820.025n

.meas tran vdout1_78ck1630 FIND v(dout1_78) AT=820.025n

.meas tran vdout1_79ck1630 FIND v(dout1_79) AT=820.025n

.meas tran vdout1_80ck1630 FIND v(dout1_80) AT=820.025n

.meas tran vdout1_81ck1630 FIND v(dout1_81) AT=820.025n

.meas tran vdout1_82ck1630 FIND v(dout1_82) AT=820.025n

.meas tran vdout1_83ck1630 FIND v(dout1_83) AT=820.025n

.meas tran vdout1_84ck1630 FIND v(dout1_84) AT=820.025n

.meas tran vdout1_85ck1630 FIND v(dout1_85) AT=820.025n

.meas tran vdout1_86ck1630 FIND v(dout1_86) AT=820.025n

.meas tran vdout1_87ck1630 FIND v(dout1_87) AT=820.025n

.meas tran vdout1_88ck1630 FIND v(dout1_88) AT=820.025n

.meas tran vdout1_89ck1630 FIND v(dout1_89) AT=820.025n

.meas tran vdout1_90ck1630 FIND v(dout1_90) AT=820.025n

.meas tran vdout1_91ck1630 FIND v(dout1_91) AT=820.025n

.meas tran vdout1_92ck1630 FIND v(dout1_92) AT=820.025n

.meas tran vdout1_93ck1630 FIND v(dout1_93) AT=820.025n

.meas tran vdout1_94ck1630 FIND v(dout1_94) AT=820.025n

.meas tran vdout1_95ck1630 FIND v(dout1_95) AT=820.025n

.meas tran vdout1_96ck1630 FIND v(dout1_96) AT=820.025n

.meas tran vdout1_97ck1630 FIND v(dout1_97) AT=820.025n

.meas tran vdout1_98ck1630 FIND v(dout1_98) AT=820.025n

.meas tran vdout1_99ck1630 FIND v(dout1_99) AT=820.025n

.meas tran vdout1_100ck1630 FIND v(dout1_100) AT=820.025n

.meas tran vdout1_101ck1630 FIND v(dout1_101) AT=820.025n

.meas tran vdout1_102ck1630 FIND v(dout1_102) AT=820.025n

.meas tran vdout1_103ck1630 FIND v(dout1_103) AT=820.025n

.meas tran vdout1_104ck1630 FIND v(dout1_104) AT=820.025n

.meas tran vdout1_105ck1630 FIND v(dout1_105) AT=820.025n

.meas tran vdout1_106ck1630 FIND v(dout1_106) AT=820.025n

.meas tran vdout1_107ck1630 FIND v(dout1_107) AT=820.025n

.meas tran vdout1_108ck1630 FIND v(dout1_108) AT=820.025n

.meas tran vdout1_109ck1630 FIND v(dout1_109) AT=820.025n

.meas tran vdout1_110ck1630 FIND v(dout1_110) AT=820.025n

.meas tran vdout1_111ck1630 FIND v(dout1_111) AT=820.025n

.meas tran vdout1_112ck1630 FIND v(dout1_112) AT=820.025n

.meas tran vdout1_113ck1630 FIND v(dout1_113) AT=820.025n

.meas tran vdout1_114ck1630 FIND v(dout1_114) AT=820.025n

.meas tran vdout1_115ck1630 FIND v(dout1_115) AT=820.025n

.meas tran vdout1_116ck1630 FIND v(dout1_116) AT=820.025n

.meas tran vdout1_117ck1630 FIND v(dout1_117) AT=820.025n

.meas tran vdout1_118ck1630 FIND v(dout1_118) AT=820.025n

.meas tran vdout1_119ck1630 FIND v(dout1_119) AT=820.025n

.meas tran vdout1_120ck1630 FIND v(dout1_120) AT=820.025n

.meas tran vdout1_121ck1630 FIND v(dout1_121) AT=820.025n

.meas tran vdout1_122ck1630 FIND v(dout1_122) AT=820.025n

.meas tran vdout1_123ck1630 FIND v(dout1_123) AT=820.025n

.meas tran vdout1_124ck1630 FIND v(dout1_124) AT=820.025n

.meas tran vdout1_125ck1630 FIND v(dout1_125) AT=820.025n

.meas tran vdout1_126ck1630 FIND v(dout1_126) AT=820.025n

.meas tran vdout1_127ck1630 FIND v(dout1_127) AT=820.025n

.meas tran vdout1_128ck1630 FIND v(dout1_128) AT=820.025n

.meas tran vdout1_129ck1630 FIND v(dout1_129) AT=820.025n

.meas tran vdout1_130ck1630 FIND v(dout1_130) AT=820.025n

.meas tran vdout1_131ck1630 FIND v(dout1_131) AT=820.025n

.meas tran vdout1_132ck1630 FIND v(dout1_132) AT=820.025n

.meas tran vdout1_133ck1630 FIND v(dout1_133) AT=820.025n

.meas tran vdout1_134ck1630 FIND v(dout1_134) AT=820.025n

.meas tran vdout1_135ck1630 FIND v(dout1_135) AT=820.025n

.meas tran vdout1_136ck1630 FIND v(dout1_136) AT=820.025n

.meas tran vdout1_137ck1630 FIND v(dout1_137) AT=820.025n

.meas tran vdout1_138ck1630 FIND v(dout1_138) AT=820.025n

.meas tran vdout1_139ck1630 FIND v(dout1_139) AT=820.025n

.meas tran vdout1_140ck1630 FIND v(dout1_140) AT=820.025n

.meas tran vdout1_141ck1630 FIND v(dout1_141) AT=820.025n

.meas tran vdout1_142ck1630 FIND v(dout1_142) AT=820.025n

.meas tran vdout1_143ck1630 FIND v(dout1_143) AT=820.025n

.meas tran vdout1_144ck1630 FIND v(dout1_144) AT=820.025n

.meas tran vdout1_145ck1630 FIND v(dout1_145) AT=820.025n

.meas tran vdout1_146ck1630 FIND v(dout1_146) AT=820.025n

.meas tran vdout1_147ck1630 FIND v(dout1_147) AT=820.025n

.meas tran vdout1_148ck1630 FIND v(dout1_148) AT=820.025n

.meas tran vdout1_149ck1630 FIND v(dout1_149) AT=820.025n

.meas tran vdout1_150ck1630 FIND v(dout1_150) AT=820.025n

.meas tran vdout1_151ck1630 FIND v(dout1_151) AT=820.025n

.meas tran vdout1_152ck1630 FIND v(dout1_152) AT=820.025n

.meas tran vdout1_153ck1630 FIND v(dout1_153) AT=820.025n

.meas tran vdout1_154ck1630 FIND v(dout1_154) AT=820.025n

.meas tran vdout1_155ck1630 FIND v(dout1_155) AT=820.025n

.meas tran vdout1_156ck1630 FIND v(dout1_156) AT=820.025n

.meas tran vdout1_157ck1630 FIND v(dout1_157) AT=820.025n

.meas tran vdout1_158ck1630 FIND v(dout1_158) AT=820.025n

.meas tran vdout1_159ck1630 FIND v(dout1_159) AT=820.025n

.meas tran vdout1_160ck1630 FIND v(dout1_160) AT=820.025n

.meas tran vdout1_161ck1630 FIND v(dout1_161) AT=820.025n

.meas tran vdout1_162ck1630 FIND v(dout1_162) AT=820.025n

.meas tran vdout1_163ck1630 FIND v(dout1_163) AT=820.025n

.meas tran vdout1_164ck1630 FIND v(dout1_164) AT=820.025n

.meas tran vdout1_165ck1630 FIND v(dout1_165) AT=820.025n

.meas tran vdout1_166ck1630 FIND v(dout1_166) AT=820.025n

.meas tran vdout1_167ck1630 FIND v(dout1_167) AT=820.025n

.meas tran vdout1_168ck1630 FIND v(dout1_168) AT=820.025n

.meas tran vdout1_169ck1630 FIND v(dout1_169) AT=820.025n

.meas tran vdout1_170ck1630 FIND v(dout1_170) AT=820.025n

.meas tran vdout1_171ck1630 FIND v(dout1_171) AT=820.025n

.meas tran vdout1_172ck1630 FIND v(dout1_172) AT=820.025n

.meas tran vdout1_173ck1630 FIND v(dout1_173) AT=820.025n

.meas tran vdout1_174ck1630 FIND v(dout1_174) AT=820.025n

.meas tran vdout1_175ck1630 FIND v(dout1_175) AT=820.025n

.meas tran vdout1_176ck1630 FIND v(dout1_176) AT=820.025n

.meas tran vdout1_177ck1630 FIND v(dout1_177) AT=820.025n

.meas tran vdout1_178ck1630 FIND v(dout1_178) AT=820.025n

.meas tran vdout1_179ck1630 FIND v(dout1_179) AT=820.025n

.meas tran vdout1_180ck1630 FIND v(dout1_180) AT=820.025n

.meas tran vdout1_181ck1630 FIND v(dout1_181) AT=820.025n

.meas tran vdout1_182ck1630 FIND v(dout1_182) AT=820.025n

.meas tran vdout1_183ck1630 FIND v(dout1_183) AT=820.025n

.meas tran vdout1_184ck1630 FIND v(dout1_184) AT=820.025n

.meas tran vdout1_185ck1630 FIND v(dout1_185) AT=820.025n

.meas tran vdout1_186ck1630 FIND v(dout1_186) AT=820.025n

.meas tran vdout1_187ck1630 FIND v(dout1_187) AT=820.025n

.meas tran vdout1_188ck1630 FIND v(dout1_188) AT=820.025n

.meas tran vdout1_189ck1630 FIND v(dout1_189) AT=820.025n

.meas tran vdout1_190ck1630 FIND v(dout1_190) AT=820.025n

.meas tran vdout1_191ck1630 FIND v(dout1_191) AT=820.025n

.meas tran vdout1_192ck1630 FIND v(dout1_192) AT=820.025n

.meas tran vdout1_193ck1630 FIND v(dout1_193) AT=820.025n

.meas tran vdout1_194ck1630 FIND v(dout1_194) AT=820.025n

.meas tran vdout1_195ck1630 FIND v(dout1_195) AT=820.025n

.meas tran vdout1_196ck1630 FIND v(dout1_196) AT=820.025n

.meas tran vdout1_197ck1630 FIND v(dout1_197) AT=820.025n

.meas tran vdout1_198ck1630 FIND v(dout1_198) AT=820.025n

.meas tran vdout1_199ck1630 FIND v(dout1_199) AT=820.025n

.meas tran vdout1_200ck1630 FIND v(dout1_200) AT=820.025n

.meas tran vdout1_201ck1630 FIND v(dout1_201) AT=820.025n

.meas tran vdout1_202ck1630 FIND v(dout1_202) AT=820.025n

.meas tran vdout1_203ck1630 FIND v(dout1_203) AT=820.025n

.meas tran vdout1_204ck1630 FIND v(dout1_204) AT=820.025n

.meas tran vdout1_205ck1630 FIND v(dout1_205) AT=820.025n

.meas tran vdout1_206ck1630 FIND v(dout1_206) AT=820.025n

.meas tran vdout1_207ck1630 FIND v(dout1_207) AT=820.025n

.meas tran vdout1_208ck1630 FIND v(dout1_208) AT=820.025n

.meas tran vdout1_209ck1630 FIND v(dout1_209) AT=820.025n

.meas tran vdout1_210ck1630 FIND v(dout1_210) AT=820.025n

.meas tran vdout1_211ck1630 FIND v(dout1_211) AT=820.025n

.meas tran vdout1_212ck1630 FIND v(dout1_212) AT=820.025n

.meas tran vdout1_213ck1630 FIND v(dout1_213) AT=820.025n

.meas tran vdout1_214ck1630 FIND v(dout1_214) AT=820.025n

.meas tran vdout1_215ck1630 FIND v(dout1_215) AT=820.025n

.meas tran vdout1_216ck1630 FIND v(dout1_216) AT=820.025n

.meas tran vdout1_217ck1630 FIND v(dout1_217) AT=820.025n

.meas tran vdout1_218ck1630 FIND v(dout1_218) AT=820.025n

.meas tran vdout1_219ck1630 FIND v(dout1_219) AT=820.025n

.meas tran vdout1_220ck1630 FIND v(dout1_220) AT=820.025n

.meas tran vdout1_221ck1630 FIND v(dout1_221) AT=820.025n

.meas tran vdout1_222ck1630 FIND v(dout1_222) AT=820.025n

.meas tran vdout1_223ck1630 FIND v(dout1_223) AT=820.025n

.meas tran vdout1_224ck1630 FIND v(dout1_224) AT=820.025n

.meas tran vdout1_225ck1630 FIND v(dout1_225) AT=820.025n

.meas tran vdout1_226ck1630 FIND v(dout1_226) AT=820.025n

.meas tran vdout1_227ck1630 FIND v(dout1_227) AT=820.025n

.meas tran vdout1_228ck1630 FIND v(dout1_228) AT=820.025n

.meas tran vdout1_229ck1630 FIND v(dout1_229) AT=820.025n

.meas tran vdout1_230ck1630 FIND v(dout1_230) AT=820.025n

.meas tran vdout1_231ck1630 FIND v(dout1_231) AT=820.025n

.meas tran vdout1_232ck1630 FIND v(dout1_232) AT=820.025n

.meas tran vdout1_233ck1630 FIND v(dout1_233) AT=820.025n

.meas tran vdout1_234ck1630 FIND v(dout1_234) AT=820.025n

.meas tran vdout1_235ck1630 FIND v(dout1_235) AT=820.025n

.meas tran vdout1_236ck1630 FIND v(dout1_236) AT=820.025n

.meas tran vdout1_237ck1630 FIND v(dout1_237) AT=820.025n

.meas tran vdout1_238ck1630 FIND v(dout1_238) AT=820.025n

.meas tran vdout1_239ck1630 FIND v(dout1_239) AT=820.025n

.meas tran vdout1_240ck1630 FIND v(dout1_240) AT=820.025n

.meas tran vdout1_241ck1630 FIND v(dout1_241) AT=820.025n

.meas tran vdout1_242ck1630 FIND v(dout1_242) AT=820.025n

.meas tran vdout1_243ck1630 FIND v(dout1_243) AT=820.025n

.meas tran vdout1_244ck1630 FIND v(dout1_244) AT=820.025n

.meas tran vdout1_245ck1630 FIND v(dout1_245) AT=820.025n

.meas tran vdout1_246ck1630 FIND v(dout1_246) AT=820.025n

.meas tran vdout1_247ck1630 FIND v(dout1_247) AT=820.025n

.meas tran vdout1_248ck1630 FIND v(dout1_248) AT=820.025n

.meas tran vdout1_249ck1630 FIND v(dout1_249) AT=820.025n

.meas tran vdout1_250ck1630 FIND v(dout1_250) AT=820.025n

.meas tran vdout1_251ck1630 FIND v(dout1_251) AT=820.025n

.meas tran vdout1_252ck1630 FIND v(dout1_252) AT=820.025n

.meas tran vdout1_253ck1630 FIND v(dout1_253) AT=820.025n

.meas tran vdout1_254ck1630 FIND v(dout1_254) AT=820.025n

.meas tran vdout1_255ck1630 FIND v(dout1_255) AT=820.025n

.meas tran vdout1_256ck1630 FIND v(dout1_256) AT=820.025n

.meas tran vdout1_257ck1630 FIND v(dout1_257) AT=820.025n

.meas tran vdout1_258ck1630 FIND v(dout1_258) AT=820.025n

.meas tran vdout1_259ck1630 FIND v(dout1_259) AT=820.025n

.meas tran vdout1_260ck1630 FIND v(dout1_260) AT=820.025n

.meas tran vdout1_261ck1630 FIND v(dout1_261) AT=820.025n

.meas tran vdout1_262ck1630 FIND v(dout1_262) AT=820.025n

.meas tran vdout1_263ck1630 FIND v(dout1_263) AT=820.025n

.meas tran vdout1_264ck1630 FIND v(dout1_264) AT=820.025n

.meas tran vdout1_265ck1630 FIND v(dout1_265) AT=820.025n

.meas tran vdout1_266ck1630 FIND v(dout1_266) AT=820.025n

.meas tran vdout1_267ck1630 FIND v(dout1_267) AT=820.025n

.meas tran vdout1_268ck1630 FIND v(dout1_268) AT=820.025n

.meas tran vdout1_269ck1630 FIND v(dout1_269) AT=820.025n

.meas tran vdout1_270ck1630 FIND v(dout1_270) AT=820.025n

.meas tran vdout1_271ck1630 FIND v(dout1_271) AT=820.025n

.meas tran vdout1_272ck1630 FIND v(dout1_272) AT=820.025n

.meas tran vdout1_273ck1630 FIND v(dout1_273) AT=820.025n

.meas tran vdout1_274ck1630 FIND v(dout1_274) AT=820.025n

.meas tran vdout1_275ck1630 FIND v(dout1_275) AT=820.025n

.meas tran vdout1_276ck1630 FIND v(dout1_276) AT=820.025n

.meas tran vdout1_277ck1630 FIND v(dout1_277) AT=820.025n

.meas tran vdout1_278ck1630 FIND v(dout1_278) AT=820.025n

.meas tran vdout1_279ck1630 FIND v(dout1_279) AT=820.025n

.meas tran vdout1_280ck1630 FIND v(dout1_280) AT=820.025n

.meas tran vdout1_281ck1630 FIND v(dout1_281) AT=820.025n

.meas tran vdout1_282ck1630 FIND v(dout1_282) AT=820.025n

.meas tran vdout1_283ck1630 FIND v(dout1_283) AT=820.025n

.meas tran vdout1_284ck1630 FIND v(dout1_284) AT=820.025n

.meas tran vdout1_285ck1630 FIND v(dout1_285) AT=820.025n

.meas tran vdout1_286ck1630 FIND v(dout1_286) AT=820.025n

.meas tran vdout1_287ck1630 FIND v(dout1_287) AT=820.025n

.meas tran vdout1_288ck1630 FIND v(dout1_288) AT=820.025n

.meas tran vdout1_289ck1630 FIND v(dout1_289) AT=820.025n

.meas tran vdout1_290ck1630 FIND v(dout1_290) AT=820.025n

.meas tran vdout1_291ck1630 FIND v(dout1_291) AT=820.025n

.meas tran vdout1_292ck1630 FIND v(dout1_292) AT=820.025n

.meas tran vdout1_293ck1630 FIND v(dout1_293) AT=820.025n

.meas tran vdout1_294ck1630 FIND v(dout1_294) AT=820.025n

.meas tran vdout1_295ck1630 FIND v(dout1_295) AT=820.025n

.meas tran vdout1_296ck1630 FIND v(dout1_296) AT=820.025n

.meas tran vdout1_297ck1630 FIND v(dout1_297) AT=820.025n

.meas tran vdout1_298ck1630 FIND v(dout1_298) AT=820.025n

.meas tran vdout1_299ck1630 FIND v(dout1_299) AT=820.025n

.meas tran vdout1_300ck1630 FIND v(dout1_300) AT=820.025n

.meas tran vdout1_301ck1630 FIND v(dout1_301) AT=820.025n

.meas tran vdout1_302ck1630 FIND v(dout1_302) AT=820.025n

.meas tran vdout1_303ck1630 FIND v(dout1_303) AT=820.025n

.meas tran vdout1_304ck1630 FIND v(dout1_304) AT=820.025n

.meas tran vdout1_305ck1630 FIND v(dout1_305) AT=820.025n

.meas tran vdout1_306ck1630 FIND v(dout1_306) AT=820.025n

.meas tran vdout1_307ck1630 FIND v(dout1_307) AT=820.025n

.meas tran vdout1_308ck1630 FIND v(dout1_308) AT=820.025n

.meas tran vdout1_309ck1630 FIND v(dout1_309) AT=820.025n

.meas tran vdout1_310ck1630 FIND v(dout1_310) AT=820.025n

.meas tran vdout1_311ck1630 FIND v(dout1_311) AT=820.025n

.meas tran vdout1_312ck1630 FIND v(dout1_312) AT=820.025n

.meas tran vdout1_313ck1630 FIND v(dout1_313) AT=820.025n

.meas tran vdout1_314ck1630 FIND v(dout1_314) AT=820.025n

.meas tran vdout1_315ck1630 FIND v(dout1_315) AT=820.025n

.meas tran vdout1_316ck1630 FIND v(dout1_316) AT=820.025n

.meas tran vdout1_317ck1630 FIND v(dout1_317) AT=820.025n

.meas tran vdout1_318ck1630 FIND v(dout1_318) AT=820.025n

.meas tran vdout1_319ck1630 FIND v(dout1_319) AT=820.025n

.meas tran vdout1_320ck1630 FIND v(dout1_320) AT=820.025n

.meas tran vdout1_321ck1630 FIND v(dout1_321) AT=820.025n

.meas tran vdout1_322ck1630 FIND v(dout1_322) AT=820.025n

.meas tran vdout1_323ck1630 FIND v(dout1_323) AT=820.025n

.meas tran vdout1_324ck1630 FIND v(dout1_324) AT=820.025n

.meas tran vdout1_325ck1630 FIND v(dout1_325) AT=820.025n

.meas tran vdout1_326ck1630 FIND v(dout1_326) AT=820.025n

.meas tran vdout1_327ck1630 FIND v(dout1_327) AT=820.025n

.meas tran vdout1_328ck1630 FIND v(dout1_328) AT=820.025n

.meas tran vdout1_329ck1630 FIND v(dout1_329) AT=820.025n

.meas tran vdout1_330ck1630 FIND v(dout1_330) AT=820.025n

.meas tran vdout1_331ck1630 FIND v(dout1_331) AT=820.025n

.meas tran vdout1_332ck1630 FIND v(dout1_332) AT=820.025n

.meas tran vdout1_333ck1630 FIND v(dout1_333) AT=820.025n

.meas tran vdout1_334ck1630 FIND v(dout1_334) AT=820.025n

.meas tran vdout1_335ck1630 FIND v(dout1_335) AT=820.025n

.meas tran vdout1_336ck1630 FIND v(dout1_336) AT=820.025n

.meas tran vdout1_337ck1630 FIND v(dout1_337) AT=820.025n

.meas tran vdout1_338ck1630 FIND v(dout1_338) AT=820.025n

.meas tran vdout1_339ck1630 FIND v(dout1_339) AT=820.025n

.meas tran vdout1_340ck1630 FIND v(dout1_340) AT=820.025n

.meas tran vdout1_341ck1630 FIND v(dout1_341) AT=820.025n

.meas tran vdout1_342ck1630 FIND v(dout1_342) AT=820.025n

.meas tran vdout1_343ck1630 FIND v(dout1_343) AT=820.025n

.meas tran vdout1_344ck1630 FIND v(dout1_344) AT=820.025n

.meas tran vdout1_345ck1630 FIND v(dout1_345) AT=820.025n

.meas tran vdout1_346ck1630 FIND v(dout1_346) AT=820.025n

.meas tran vdout1_347ck1630 FIND v(dout1_347) AT=820.025n

.meas tran vdout1_348ck1630 FIND v(dout1_348) AT=820.025n

.meas tran vdout1_349ck1630 FIND v(dout1_349) AT=820.025n

.meas tran vdout1_350ck1630 FIND v(dout1_350) AT=820.025n

.meas tran vdout1_351ck1630 FIND v(dout1_351) AT=820.025n

.meas tran vdout1_352ck1630 FIND v(dout1_352) AT=820.025n

.meas tran vdout1_353ck1630 FIND v(dout1_353) AT=820.025n

.meas tran vdout1_354ck1630 FIND v(dout1_354) AT=820.025n

.meas tran vdout1_355ck1630 FIND v(dout1_355) AT=820.025n

.meas tran vdout1_356ck1630 FIND v(dout1_356) AT=820.025n

.meas tran vdout1_357ck1630 FIND v(dout1_357) AT=820.025n

.meas tran vdout1_358ck1630 FIND v(dout1_358) AT=820.025n

.meas tran vdout1_359ck1630 FIND v(dout1_359) AT=820.025n

.meas tran vdout1_360ck1630 FIND v(dout1_360) AT=820.025n

.meas tran vdout1_361ck1630 FIND v(dout1_361) AT=820.025n

.meas tran vdout1_362ck1630 FIND v(dout1_362) AT=820.025n

.meas tran vdout1_363ck1630 FIND v(dout1_363) AT=820.025n

.meas tran vdout1_364ck1630 FIND v(dout1_364) AT=820.025n

.meas tran vdout1_365ck1630 FIND v(dout1_365) AT=820.025n

.meas tran vdout1_366ck1630 FIND v(dout1_366) AT=820.025n

.meas tran vdout1_367ck1630 FIND v(dout1_367) AT=820.025n

.meas tran vdout1_368ck1630 FIND v(dout1_368) AT=820.025n

.meas tran vdout1_369ck1630 FIND v(dout1_369) AT=820.025n

.meas tran vdout1_370ck1630 FIND v(dout1_370) AT=820.025n

.meas tran vdout1_371ck1630 FIND v(dout1_371) AT=820.025n

.meas tran vdout1_372ck1630 FIND v(dout1_372) AT=820.025n

.meas tran vdout1_373ck1630 FIND v(dout1_373) AT=820.025n

.meas tran vdout1_374ck1630 FIND v(dout1_374) AT=820.025n

.meas tran vdout1_375ck1630 FIND v(dout1_375) AT=820.025n

.meas tran vdout1_376ck1630 FIND v(dout1_376) AT=820.025n

.meas tran vdout1_377ck1630 FIND v(dout1_377) AT=820.025n

.meas tran vdout1_378ck1630 FIND v(dout1_378) AT=820.025n

.meas tran vdout1_379ck1630 FIND v(dout1_379) AT=820.025n

.meas tran vdout1_380ck1630 FIND v(dout1_380) AT=820.025n

.meas tran vdout1_381ck1630 FIND v(dout1_381) AT=820.025n

.meas tran vdout1_382ck1630 FIND v(dout1_382) AT=820.025n

.meas tran vdout1_383ck1630 FIND v(dout1_383) AT=820.025n

.meas tran vdout1_384ck1630 FIND v(dout1_384) AT=820.025n

.meas tran vdout1_385ck1630 FIND v(dout1_385) AT=820.025n

.meas tran vdout1_386ck1630 FIND v(dout1_386) AT=820.025n

.meas tran vdout1_387ck1630 FIND v(dout1_387) AT=820.025n

.meas tran vdout1_388ck1630 FIND v(dout1_388) AT=820.025n

.meas tran vdout1_389ck1630 FIND v(dout1_389) AT=820.025n

.meas tran vdout1_390ck1630 FIND v(dout1_390) AT=820.025n

.meas tran vdout1_391ck1630 FIND v(dout1_391) AT=820.025n

.meas tran vdout1_392ck1630 FIND v(dout1_392) AT=820.025n

.meas tran vdout1_393ck1630 FIND v(dout1_393) AT=820.025n

.meas tran vdout1_394ck1630 FIND v(dout1_394) AT=820.025n

.meas tran vdout1_395ck1630 FIND v(dout1_395) AT=820.025n

.meas tran vdout1_396ck1630 FIND v(dout1_396) AT=820.025n

.meas tran vdout1_397ck1630 FIND v(dout1_397) AT=820.025n

.meas tran vdout1_398ck1630 FIND v(dout1_398) AT=820.025n

.meas tran vdout1_399ck1630 FIND v(dout1_399) AT=820.025n

.meas tran vdout1_400ck1630 FIND v(dout1_400) AT=820.025n

.meas tran vdout1_401ck1630 FIND v(dout1_401) AT=820.025n

.meas tran vdout1_402ck1630 FIND v(dout1_402) AT=820.025n

.meas tran vdout1_403ck1630 FIND v(dout1_403) AT=820.025n

.meas tran vdout1_404ck1630 FIND v(dout1_404) AT=820.025n

.meas tran vdout1_405ck1630 FIND v(dout1_405) AT=820.025n

.meas tran vdout1_406ck1630 FIND v(dout1_406) AT=820.025n

.meas tran vdout1_407ck1630 FIND v(dout1_407) AT=820.025n

.meas tran vdout1_408ck1630 FIND v(dout1_408) AT=820.025n

.meas tran vdout1_409ck1630 FIND v(dout1_409) AT=820.025n

.meas tran vdout1_410ck1630 FIND v(dout1_410) AT=820.025n

.meas tran vdout1_411ck1630 FIND v(dout1_411) AT=820.025n

.meas tran vdout1_412ck1630 FIND v(dout1_412) AT=820.025n

.meas tran vdout1_413ck1630 FIND v(dout1_413) AT=820.025n

.meas tran vdout1_414ck1630 FIND v(dout1_414) AT=820.025n

.meas tran vdout1_415ck1630 FIND v(dout1_415) AT=820.025n

.meas tran vdout1_416ck1630 FIND v(dout1_416) AT=820.025n

.meas tran vdout1_417ck1630 FIND v(dout1_417) AT=820.025n

.meas tran vdout1_418ck1630 FIND v(dout1_418) AT=820.025n

.meas tran vdout1_419ck1630 FIND v(dout1_419) AT=820.025n

.meas tran vdout1_420ck1630 FIND v(dout1_420) AT=820.025n

.meas tran vdout1_421ck1630 FIND v(dout1_421) AT=820.025n

.meas tran vdout1_422ck1630 FIND v(dout1_422) AT=820.025n

.meas tran vdout1_423ck1630 FIND v(dout1_423) AT=820.025n

.meas tran vdout1_424ck1630 FIND v(dout1_424) AT=820.025n

.meas tran vdout1_425ck1630 FIND v(dout1_425) AT=820.025n

.meas tran vdout1_426ck1630 FIND v(dout1_426) AT=820.025n

.meas tran vdout1_427ck1630 FIND v(dout1_427) AT=820.025n

.meas tran vdout1_428ck1630 FIND v(dout1_428) AT=820.025n

.meas tran vdout1_429ck1630 FIND v(dout1_429) AT=820.025n

.meas tran vdout1_430ck1630 FIND v(dout1_430) AT=820.025n

.meas tran vdout1_431ck1630 FIND v(dout1_431) AT=820.025n

.meas tran vdout1_432ck1630 FIND v(dout1_432) AT=820.025n

.meas tran vdout1_433ck1630 FIND v(dout1_433) AT=820.025n

.meas tran vdout1_434ck1630 FIND v(dout1_434) AT=820.025n

.meas tran vdout1_435ck1630 FIND v(dout1_435) AT=820.025n

.meas tran vdout1_436ck1630 FIND v(dout1_436) AT=820.025n

.meas tran vdout1_437ck1630 FIND v(dout1_437) AT=820.025n

.meas tran vdout1_438ck1630 FIND v(dout1_438) AT=820.025n

.meas tran vdout1_439ck1630 FIND v(dout1_439) AT=820.025n

.meas tran vdout1_440ck1630 FIND v(dout1_440) AT=820.025n

.meas tran vdout1_441ck1630 FIND v(dout1_441) AT=820.025n

.meas tran vdout1_442ck1630 FIND v(dout1_442) AT=820.025n

.meas tran vdout1_443ck1630 FIND v(dout1_443) AT=820.025n

.meas tran vdout1_444ck1630 FIND v(dout1_444) AT=820.025n

.meas tran vdout1_445ck1630 FIND v(dout1_445) AT=820.025n

.meas tran vdout1_446ck1630 FIND v(dout1_446) AT=820.025n

.meas tran vdout1_447ck1630 FIND v(dout1_447) AT=820.025n

.meas tran vdout1_448ck1630 FIND v(dout1_448) AT=820.025n

.meas tran vdout1_449ck1630 FIND v(dout1_449) AT=820.025n

.meas tran vdout1_450ck1630 FIND v(dout1_450) AT=820.025n

.meas tran vdout1_451ck1630 FIND v(dout1_451) AT=820.025n

.meas tran vdout1_452ck1630 FIND v(dout1_452) AT=820.025n

.meas tran vdout1_453ck1630 FIND v(dout1_453) AT=820.025n

.meas tran vdout1_454ck1630 FIND v(dout1_454) AT=820.025n

.meas tran vdout1_455ck1630 FIND v(dout1_455) AT=820.025n

.meas tran vdout1_456ck1630 FIND v(dout1_456) AT=820.025n

.meas tran vdout1_457ck1630 FIND v(dout1_457) AT=820.025n

.meas tran vdout1_458ck1630 FIND v(dout1_458) AT=820.025n

.meas tran vdout1_459ck1630 FIND v(dout1_459) AT=820.025n

.meas tran vdout1_460ck1630 FIND v(dout1_460) AT=820.025n

.meas tran vdout1_461ck1630 FIND v(dout1_461) AT=820.025n

.meas tran vdout1_462ck1630 FIND v(dout1_462) AT=820.025n

.meas tran vdout1_463ck1630 FIND v(dout1_463) AT=820.025n

.meas tran vdout1_464ck1630 FIND v(dout1_464) AT=820.025n

.meas tran vdout1_465ck1630 FIND v(dout1_465) AT=820.025n

.meas tran vdout1_466ck1630 FIND v(dout1_466) AT=820.025n

.meas tran vdout1_467ck1630 FIND v(dout1_467) AT=820.025n

.meas tran vdout1_468ck1630 FIND v(dout1_468) AT=820.025n

.meas tran vdout1_469ck1630 FIND v(dout1_469) AT=820.025n

.meas tran vdout1_470ck1630 FIND v(dout1_470) AT=820.025n

.meas tran vdout1_471ck1630 FIND v(dout1_471) AT=820.025n

.meas tran vdout1_472ck1630 FIND v(dout1_472) AT=820.025n

.meas tran vdout1_473ck1630 FIND v(dout1_473) AT=820.025n

.meas tran vdout1_474ck1630 FIND v(dout1_474) AT=820.025n

.meas tran vdout1_475ck1630 FIND v(dout1_475) AT=820.025n

.meas tran vdout1_476ck1630 FIND v(dout1_476) AT=820.025n

.meas tran vdout1_477ck1630 FIND v(dout1_477) AT=820.025n

.meas tran vdout1_478ck1630 FIND v(dout1_478) AT=820.025n

.meas tran vdout1_479ck1630 FIND v(dout1_479) AT=820.025n

.meas tran vdout1_480ck1630 FIND v(dout1_480) AT=820.025n

.meas tran vdout1_481ck1630 FIND v(dout1_481) AT=820.025n

.meas tran vdout1_482ck1630 FIND v(dout1_482) AT=820.025n

.meas tran vdout1_483ck1630 FIND v(dout1_483) AT=820.025n

.meas tran vdout1_484ck1630 FIND v(dout1_484) AT=820.025n

.meas tran vdout1_485ck1630 FIND v(dout1_485) AT=820.025n

.meas tran vdout1_486ck1630 FIND v(dout1_486) AT=820.025n

.meas tran vdout1_487ck1630 FIND v(dout1_487) AT=820.025n

.meas tran vdout1_488ck1630 FIND v(dout1_488) AT=820.025n

.meas tran vdout1_489ck1630 FIND v(dout1_489) AT=820.025n

.meas tran vdout1_490ck1630 FIND v(dout1_490) AT=820.025n

.meas tran vdout1_491ck1630 FIND v(dout1_491) AT=820.025n

.meas tran vdout1_492ck1630 FIND v(dout1_492) AT=820.025n

.meas tran vdout1_493ck1630 FIND v(dout1_493) AT=820.025n

.meas tran vdout1_494ck1630 FIND v(dout1_494) AT=820.025n

.meas tran vdout1_495ck1630 FIND v(dout1_495) AT=820.025n

.meas tran vdout1_496ck1630 FIND v(dout1_496) AT=820.025n

.meas tran vdout1_497ck1630 FIND v(dout1_497) AT=820.025n

.meas tran vdout1_498ck1630 FIND v(dout1_498) AT=820.025n

.meas tran vdout1_499ck1630 FIND v(dout1_499) AT=820.025n

.meas tran vdout1_500ck1630 FIND v(dout1_500) AT=820.025n

.meas tran vdout1_501ck1630 FIND v(dout1_501) AT=820.025n

.meas tran vdout1_502ck1630 FIND v(dout1_502) AT=820.025n

.meas tran vdout1_503ck1630 FIND v(dout1_503) AT=820.025n

.meas tran vdout1_504ck1630 FIND v(dout1_504) AT=820.025n

.meas tran vdout1_505ck1630 FIND v(dout1_505) AT=820.025n

.meas tran vdout1_506ck1630 FIND v(dout1_506) AT=820.025n

.meas tran vdout1_507ck1630 FIND v(dout1_507) AT=820.025n

.meas tran vdout1_508ck1630 FIND v(dout1_508) AT=820.025n

.meas tran vdout1_509ck1630 FIND v(dout1_509) AT=820.025n

.meas tran vdout1_510ck1630 FIND v(dout1_510) AT=820.025n

.meas tran vdout1_511ck1630 FIND v(dout1_511) AT=820.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_32ck1660 FIND v(dout1_32) AT=835.025n

.meas tran vdout1_33ck1660 FIND v(dout1_33) AT=835.025n

.meas tran vdout1_34ck1660 FIND v(dout1_34) AT=835.025n

.meas tran vdout1_35ck1660 FIND v(dout1_35) AT=835.025n

.meas tran vdout1_36ck1660 FIND v(dout1_36) AT=835.025n

.meas tran vdout1_37ck1660 FIND v(dout1_37) AT=835.025n

.meas tran vdout1_38ck1660 FIND v(dout1_38) AT=835.025n

.meas tran vdout1_39ck1660 FIND v(dout1_39) AT=835.025n

.meas tran vdout1_40ck1660 FIND v(dout1_40) AT=835.025n

.meas tran vdout1_41ck1660 FIND v(dout1_41) AT=835.025n

.meas tran vdout1_42ck1660 FIND v(dout1_42) AT=835.025n

.meas tran vdout1_43ck1660 FIND v(dout1_43) AT=835.025n

.meas tran vdout1_44ck1660 FIND v(dout1_44) AT=835.025n

.meas tran vdout1_45ck1660 FIND v(dout1_45) AT=835.025n

.meas tran vdout1_46ck1660 FIND v(dout1_46) AT=835.025n

.meas tran vdout1_47ck1660 FIND v(dout1_47) AT=835.025n

.meas tran vdout1_48ck1660 FIND v(dout1_48) AT=835.025n

.meas tran vdout1_49ck1660 FIND v(dout1_49) AT=835.025n

.meas tran vdout1_50ck1660 FIND v(dout1_50) AT=835.025n

.meas tran vdout1_51ck1660 FIND v(dout1_51) AT=835.025n

.meas tran vdout1_52ck1660 FIND v(dout1_52) AT=835.025n

.meas tran vdout1_53ck1660 FIND v(dout1_53) AT=835.025n

.meas tran vdout1_54ck1660 FIND v(dout1_54) AT=835.025n

.meas tran vdout1_55ck1660 FIND v(dout1_55) AT=835.025n

.meas tran vdout1_56ck1660 FIND v(dout1_56) AT=835.025n

.meas tran vdout1_57ck1660 FIND v(dout1_57) AT=835.025n

.meas tran vdout1_58ck1660 FIND v(dout1_58) AT=835.025n

.meas tran vdout1_59ck1660 FIND v(dout1_59) AT=835.025n

.meas tran vdout1_60ck1660 FIND v(dout1_60) AT=835.025n

.meas tran vdout1_61ck1660 FIND v(dout1_61) AT=835.025n

.meas tran vdout1_62ck1660 FIND v(dout1_62) AT=835.025n

.meas tran vdout1_63ck1660 FIND v(dout1_63) AT=835.025n

.meas tran vdout1_64ck1660 FIND v(dout1_64) AT=835.025n

.meas tran vdout1_65ck1660 FIND v(dout1_65) AT=835.025n

.meas tran vdout1_66ck1660 FIND v(dout1_66) AT=835.025n

.meas tran vdout1_67ck1660 FIND v(dout1_67) AT=835.025n

.meas tran vdout1_68ck1660 FIND v(dout1_68) AT=835.025n

.meas tran vdout1_69ck1660 FIND v(dout1_69) AT=835.025n

.meas tran vdout1_70ck1660 FIND v(dout1_70) AT=835.025n

.meas tran vdout1_71ck1660 FIND v(dout1_71) AT=835.025n

.meas tran vdout1_72ck1660 FIND v(dout1_72) AT=835.025n

.meas tran vdout1_73ck1660 FIND v(dout1_73) AT=835.025n

.meas tran vdout1_74ck1660 FIND v(dout1_74) AT=835.025n

.meas tran vdout1_75ck1660 FIND v(dout1_75) AT=835.025n

.meas tran vdout1_76ck1660 FIND v(dout1_76) AT=835.025n

.meas tran vdout1_77ck1660 FIND v(dout1_77) AT=835.025n

.meas tran vdout1_78ck1660 FIND v(dout1_78) AT=835.025n

.meas tran vdout1_79ck1660 FIND v(dout1_79) AT=835.025n

.meas tran vdout1_80ck1660 FIND v(dout1_80) AT=835.025n

.meas tran vdout1_81ck1660 FIND v(dout1_81) AT=835.025n

.meas tran vdout1_82ck1660 FIND v(dout1_82) AT=835.025n

.meas tran vdout1_83ck1660 FIND v(dout1_83) AT=835.025n

.meas tran vdout1_84ck1660 FIND v(dout1_84) AT=835.025n

.meas tran vdout1_85ck1660 FIND v(dout1_85) AT=835.025n

.meas tran vdout1_86ck1660 FIND v(dout1_86) AT=835.025n

.meas tran vdout1_87ck1660 FIND v(dout1_87) AT=835.025n

.meas tran vdout1_88ck1660 FIND v(dout1_88) AT=835.025n

.meas tran vdout1_89ck1660 FIND v(dout1_89) AT=835.025n

.meas tran vdout1_90ck1660 FIND v(dout1_90) AT=835.025n

.meas tran vdout1_91ck1660 FIND v(dout1_91) AT=835.025n

.meas tran vdout1_92ck1660 FIND v(dout1_92) AT=835.025n

.meas tran vdout1_93ck1660 FIND v(dout1_93) AT=835.025n

.meas tran vdout1_94ck1660 FIND v(dout1_94) AT=835.025n

.meas tran vdout1_95ck1660 FIND v(dout1_95) AT=835.025n

.meas tran vdout1_96ck1660 FIND v(dout1_96) AT=835.025n

.meas tran vdout1_97ck1660 FIND v(dout1_97) AT=835.025n

.meas tran vdout1_98ck1660 FIND v(dout1_98) AT=835.025n

.meas tran vdout1_99ck1660 FIND v(dout1_99) AT=835.025n

.meas tran vdout1_100ck1660 FIND v(dout1_100) AT=835.025n

.meas tran vdout1_101ck1660 FIND v(dout1_101) AT=835.025n

.meas tran vdout1_102ck1660 FIND v(dout1_102) AT=835.025n

.meas tran vdout1_103ck1660 FIND v(dout1_103) AT=835.025n

.meas tran vdout1_104ck1660 FIND v(dout1_104) AT=835.025n

.meas tran vdout1_105ck1660 FIND v(dout1_105) AT=835.025n

.meas tran vdout1_106ck1660 FIND v(dout1_106) AT=835.025n

.meas tran vdout1_107ck1660 FIND v(dout1_107) AT=835.025n

.meas tran vdout1_108ck1660 FIND v(dout1_108) AT=835.025n

.meas tran vdout1_109ck1660 FIND v(dout1_109) AT=835.025n

.meas tran vdout1_110ck1660 FIND v(dout1_110) AT=835.025n

.meas tran vdout1_111ck1660 FIND v(dout1_111) AT=835.025n

.meas tran vdout1_112ck1660 FIND v(dout1_112) AT=835.025n

.meas tran vdout1_113ck1660 FIND v(dout1_113) AT=835.025n

.meas tran vdout1_114ck1660 FIND v(dout1_114) AT=835.025n

.meas tran vdout1_115ck1660 FIND v(dout1_115) AT=835.025n

.meas tran vdout1_116ck1660 FIND v(dout1_116) AT=835.025n

.meas tran vdout1_117ck1660 FIND v(dout1_117) AT=835.025n

.meas tran vdout1_118ck1660 FIND v(dout1_118) AT=835.025n

.meas tran vdout1_119ck1660 FIND v(dout1_119) AT=835.025n

.meas tran vdout1_120ck1660 FIND v(dout1_120) AT=835.025n

.meas tran vdout1_121ck1660 FIND v(dout1_121) AT=835.025n

.meas tran vdout1_122ck1660 FIND v(dout1_122) AT=835.025n

.meas tran vdout1_123ck1660 FIND v(dout1_123) AT=835.025n

.meas tran vdout1_124ck1660 FIND v(dout1_124) AT=835.025n

.meas tran vdout1_125ck1660 FIND v(dout1_125) AT=835.025n

.meas tran vdout1_126ck1660 FIND v(dout1_126) AT=835.025n

.meas tran vdout1_127ck1660 FIND v(dout1_127) AT=835.025n

.meas tran vdout1_128ck1660 FIND v(dout1_128) AT=835.025n

.meas tran vdout1_129ck1660 FIND v(dout1_129) AT=835.025n

.meas tran vdout1_130ck1660 FIND v(dout1_130) AT=835.025n

.meas tran vdout1_131ck1660 FIND v(dout1_131) AT=835.025n

.meas tran vdout1_132ck1660 FIND v(dout1_132) AT=835.025n

.meas tran vdout1_133ck1660 FIND v(dout1_133) AT=835.025n

.meas tran vdout1_134ck1660 FIND v(dout1_134) AT=835.025n

.meas tran vdout1_135ck1660 FIND v(dout1_135) AT=835.025n

.meas tran vdout1_136ck1660 FIND v(dout1_136) AT=835.025n

.meas tran vdout1_137ck1660 FIND v(dout1_137) AT=835.025n

.meas tran vdout1_138ck1660 FIND v(dout1_138) AT=835.025n

.meas tran vdout1_139ck1660 FIND v(dout1_139) AT=835.025n

.meas tran vdout1_140ck1660 FIND v(dout1_140) AT=835.025n

.meas tran vdout1_141ck1660 FIND v(dout1_141) AT=835.025n

.meas tran vdout1_142ck1660 FIND v(dout1_142) AT=835.025n

.meas tran vdout1_143ck1660 FIND v(dout1_143) AT=835.025n

.meas tran vdout1_144ck1660 FIND v(dout1_144) AT=835.025n

.meas tran vdout1_145ck1660 FIND v(dout1_145) AT=835.025n

.meas tran vdout1_146ck1660 FIND v(dout1_146) AT=835.025n

.meas tran vdout1_147ck1660 FIND v(dout1_147) AT=835.025n

.meas tran vdout1_148ck1660 FIND v(dout1_148) AT=835.025n

.meas tran vdout1_149ck1660 FIND v(dout1_149) AT=835.025n

.meas tran vdout1_150ck1660 FIND v(dout1_150) AT=835.025n

.meas tran vdout1_151ck1660 FIND v(dout1_151) AT=835.025n

.meas tran vdout1_152ck1660 FIND v(dout1_152) AT=835.025n

.meas tran vdout1_153ck1660 FIND v(dout1_153) AT=835.025n

.meas tran vdout1_154ck1660 FIND v(dout1_154) AT=835.025n

.meas tran vdout1_155ck1660 FIND v(dout1_155) AT=835.025n

.meas tran vdout1_156ck1660 FIND v(dout1_156) AT=835.025n

.meas tran vdout1_157ck1660 FIND v(dout1_157) AT=835.025n

.meas tran vdout1_158ck1660 FIND v(dout1_158) AT=835.025n

.meas tran vdout1_159ck1660 FIND v(dout1_159) AT=835.025n

.meas tran vdout1_160ck1660 FIND v(dout1_160) AT=835.025n

.meas tran vdout1_161ck1660 FIND v(dout1_161) AT=835.025n

.meas tran vdout1_162ck1660 FIND v(dout1_162) AT=835.025n

.meas tran vdout1_163ck1660 FIND v(dout1_163) AT=835.025n

.meas tran vdout1_164ck1660 FIND v(dout1_164) AT=835.025n

.meas tran vdout1_165ck1660 FIND v(dout1_165) AT=835.025n

.meas tran vdout1_166ck1660 FIND v(dout1_166) AT=835.025n

.meas tran vdout1_167ck1660 FIND v(dout1_167) AT=835.025n

.meas tran vdout1_168ck1660 FIND v(dout1_168) AT=835.025n

.meas tran vdout1_169ck1660 FIND v(dout1_169) AT=835.025n

.meas tran vdout1_170ck1660 FIND v(dout1_170) AT=835.025n

.meas tran vdout1_171ck1660 FIND v(dout1_171) AT=835.025n

.meas tran vdout1_172ck1660 FIND v(dout1_172) AT=835.025n

.meas tran vdout1_173ck1660 FIND v(dout1_173) AT=835.025n

.meas tran vdout1_174ck1660 FIND v(dout1_174) AT=835.025n

.meas tran vdout1_175ck1660 FIND v(dout1_175) AT=835.025n

.meas tran vdout1_176ck1660 FIND v(dout1_176) AT=835.025n

.meas tran vdout1_177ck1660 FIND v(dout1_177) AT=835.025n

.meas tran vdout1_178ck1660 FIND v(dout1_178) AT=835.025n

.meas tran vdout1_179ck1660 FIND v(dout1_179) AT=835.025n

.meas tran vdout1_180ck1660 FIND v(dout1_180) AT=835.025n

.meas tran vdout1_181ck1660 FIND v(dout1_181) AT=835.025n

.meas tran vdout1_182ck1660 FIND v(dout1_182) AT=835.025n

.meas tran vdout1_183ck1660 FIND v(dout1_183) AT=835.025n

.meas tran vdout1_184ck1660 FIND v(dout1_184) AT=835.025n

.meas tran vdout1_185ck1660 FIND v(dout1_185) AT=835.025n

.meas tran vdout1_186ck1660 FIND v(dout1_186) AT=835.025n

.meas tran vdout1_187ck1660 FIND v(dout1_187) AT=835.025n

.meas tran vdout1_188ck1660 FIND v(dout1_188) AT=835.025n

.meas tran vdout1_189ck1660 FIND v(dout1_189) AT=835.025n

.meas tran vdout1_190ck1660 FIND v(dout1_190) AT=835.025n

.meas tran vdout1_191ck1660 FIND v(dout1_191) AT=835.025n

.meas tran vdout1_192ck1660 FIND v(dout1_192) AT=835.025n

.meas tran vdout1_193ck1660 FIND v(dout1_193) AT=835.025n

.meas tran vdout1_194ck1660 FIND v(dout1_194) AT=835.025n

.meas tran vdout1_195ck1660 FIND v(dout1_195) AT=835.025n

.meas tran vdout1_196ck1660 FIND v(dout1_196) AT=835.025n

.meas tran vdout1_197ck1660 FIND v(dout1_197) AT=835.025n

.meas tran vdout1_198ck1660 FIND v(dout1_198) AT=835.025n

.meas tran vdout1_199ck1660 FIND v(dout1_199) AT=835.025n

.meas tran vdout1_200ck1660 FIND v(dout1_200) AT=835.025n

.meas tran vdout1_201ck1660 FIND v(dout1_201) AT=835.025n

.meas tran vdout1_202ck1660 FIND v(dout1_202) AT=835.025n

.meas tran vdout1_203ck1660 FIND v(dout1_203) AT=835.025n

.meas tran vdout1_204ck1660 FIND v(dout1_204) AT=835.025n

.meas tran vdout1_205ck1660 FIND v(dout1_205) AT=835.025n

.meas tran vdout1_206ck1660 FIND v(dout1_206) AT=835.025n

.meas tran vdout1_207ck1660 FIND v(dout1_207) AT=835.025n

.meas tran vdout1_208ck1660 FIND v(dout1_208) AT=835.025n

.meas tran vdout1_209ck1660 FIND v(dout1_209) AT=835.025n

.meas tran vdout1_210ck1660 FIND v(dout1_210) AT=835.025n

.meas tran vdout1_211ck1660 FIND v(dout1_211) AT=835.025n

.meas tran vdout1_212ck1660 FIND v(dout1_212) AT=835.025n

.meas tran vdout1_213ck1660 FIND v(dout1_213) AT=835.025n

.meas tran vdout1_214ck1660 FIND v(dout1_214) AT=835.025n

.meas tran vdout1_215ck1660 FIND v(dout1_215) AT=835.025n

.meas tran vdout1_216ck1660 FIND v(dout1_216) AT=835.025n

.meas tran vdout1_217ck1660 FIND v(dout1_217) AT=835.025n

.meas tran vdout1_218ck1660 FIND v(dout1_218) AT=835.025n

.meas tran vdout1_219ck1660 FIND v(dout1_219) AT=835.025n

.meas tran vdout1_220ck1660 FIND v(dout1_220) AT=835.025n

.meas tran vdout1_221ck1660 FIND v(dout1_221) AT=835.025n

.meas tran vdout1_222ck1660 FIND v(dout1_222) AT=835.025n

.meas tran vdout1_223ck1660 FIND v(dout1_223) AT=835.025n

.meas tran vdout1_224ck1660 FIND v(dout1_224) AT=835.025n

.meas tran vdout1_225ck1660 FIND v(dout1_225) AT=835.025n

.meas tran vdout1_226ck1660 FIND v(dout1_226) AT=835.025n

.meas tran vdout1_227ck1660 FIND v(dout1_227) AT=835.025n

.meas tran vdout1_228ck1660 FIND v(dout1_228) AT=835.025n

.meas tran vdout1_229ck1660 FIND v(dout1_229) AT=835.025n

.meas tran vdout1_230ck1660 FIND v(dout1_230) AT=835.025n

.meas tran vdout1_231ck1660 FIND v(dout1_231) AT=835.025n

.meas tran vdout1_232ck1660 FIND v(dout1_232) AT=835.025n

.meas tran vdout1_233ck1660 FIND v(dout1_233) AT=835.025n

.meas tran vdout1_234ck1660 FIND v(dout1_234) AT=835.025n

.meas tran vdout1_235ck1660 FIND v(dout1_235) AT=835.025n

.meas tran vdout1_236ck1660 FIND v(dout1_236) AT=835.025n

.meas tran vdout1_237ck1660 FIND v(dout1_237) AT=835.025n

.meas tran vdout1_238ck1660 FIND v(dout1_238) AT=835.025n

.meas tran vdout1_239ck1660 FIND v(dout1_239) AT=835.025n

.meas tran vdout1_240ck1660 FIND v(dout1_240) AT=835.025n

.meas tran vdout1_241ck1660 FIND v(dout1_241) AT=835.025n

.meas tran vdout1_242ck1660 FIND v(dout1_242) AT=835.025n

.meas tran vdout1_243ck1660 FIND v(dout1_243) AT=835.025n

.meas tran vdout1_244ck1660 FIND v(dout1_244) AT=835.025n

.meas tran vdout1_245ck1660 FIND v(dout1_245) AT=835.025n

.meas tran vdout1_246ck1660 FIND v(dout1_246) AT=835.025n

.meas tran vdout1_247ck1660 FIND v(dout1_247) AT=835.025n

.meas tran vdout1_248ck1660 FIND v(dout1_248) AT=835.025n

.meas tran vdout1_249ck1660 FIND v(dout1_249) AT=835.025n

.meas tran vdout1_250ck1660 FIND v(dout1_250) AT=835.025n

.meas tran vdout1_251ck1660 FIND v(dout1_251) AT=835.025n

.meas tran vdout1_252ck1660 FIND v(dout1_252) AT=835.025n

.meas tran vdout1_253ck1660 FIND v(dout1_253) AT=835.025n

.meas tran vdout1_254ck1660 FIND v(dout1_254) AT=835.025n

.meas tran vdout1_255ck1660 FIND v(dout1_255) AT=835.025n

.meas tran vdout1_256ck1660 FIND v(dout1_256) AT=835.025n

.meas tran vdout1_257ck1660 FIND v(dout1_257) AT=835.025n

.meas tran vdout1_258ck1660 FIND v(dout1_258) AT=835.025n

.meas tran vdout1_259ck1660 FIND v(dout1_259) AT=835.025n

.meas tran vdout1_260ck1660 FIND v(dout1_260) AT=835.025n

.meas tran vdout1_261ck1660 FIND v(dout1_261) AT=835.025n

.meas tran vdout1_262ck1660 FIND v(dout1_262) AT=835.025n

.meas tran vdout1_263ck1660 FIND v(dout1_263) AT=835.025n

.meas tran vdout1_264ck1660 FIND v(dout1_264) AT=835.025n

.meas tran vdout1_265ck1660 FIND v(dout1_265) AT=835.025n

.meas tran vdout1_266ck1660 FIND v(dout1_266) AT=835.025n

.meas tran vdout1_267ck1660 FIND v(dout1_267) AT=835.025n

.meas tran vdout1_268ck1660 FIND v(dout1_268) AT=835.025n

.meas tran vdout1_269ck1660 FIND v(dout1_269) AT=835.025n

.meas tran vdout1_270ck1660 FIND v(dout1_270) AT=835.025n

.meas tran vdout1_271ck1660 FIND v(dout1_271) AT=835.025n

.meas tran vdout1_272ck1660 FIND v(dout1_272) AT=835.025n

.meas tran vdout1_273ck1660 FIND v(dout1_273) AT=835.025n

.meas tran vdout1_274ck1660 FIND v(dout1_274) AT=835.025n

.meas tran vdout1_275ck1660 FIND v(dout1_275) AT=835.025n

.meas tran vdout1_276ck1660 FIND v(dout1_276) AT=835.025n

.meas tran vdout1_277ck1660 FIND v(dout1_277) AT=835.025n

.meas tran vdout1_278ck1660 FIND v(dout1_278) AT=835.025n

.meas tran vdout1_279ck1660 FIND v(dout1_279) AT=835.025n

.meas tran vdout1_280ck1660 FIND v(dout1_280) AT=835.025n

.meas tran vdout1_281ck1660 FIND v(dout1_281) AT=835.025n

.meas tran vdout1_282ck1660 FIND v(dout1_282) AT=835.025n

.meas tran vdout1_283ck1660 FIND v(dout1_283) AT=835.025n

.meas tran vdout1_284ck1660 FIND v(dout1_284) AT=835.025n

.meas tran vdout1_285ck1660 FIND v(dout1_285) AT=835.025n

.meas tran vdout1_286ck1660 FIND v(dout1_286) AT=835.025n

.meas tran vdout1_287ck1660 FIND v(dout1_287) AT=835.025n

.meas tran vdout1_288ck1660 FIND v(dout1_288) AT=835.025n

.meas tran vdout1_289ck1660 FIND v(dout1_289) AT=835.025n

.meas tran vdout1_290ck1660 FIND v(dout1_290) AT=835.025n

.meas tran vdout1_291ck1660 FIND v(dout1_291) AT=835.025n

.meas tran vdout1_292ck1660 FIND v(dout1_292) AT=835.025n

.meas tran vdout1_293ck1660 FIND v(dout1_293) AT=835.025n

.meas tran vdout1_294ck1660 FIND v(dout1_294) AT=835.025n

.meas tran vdout1_295ck1660 FIND v(dout1_295) AT=835.025n

.meas tran vdout1_296ck1660 FIND v(dout1_296) AT=835.025n

.meas tran vdout1_297ck1660 FIND v(dout1_297) AT=835.025n

.meas tran vdout1_298ck1660 FIND v(dout1_298) AT=835.025n

.meas tran vdout1_299ck1660 FIND v(dout1_299) AT=835.025n

.meas tran vdout1_300ck1660 FIND v(dout1_300) AT=835.025n

.meas tran vdout1_301ck1660 FIND v(dout1_301) AT=835.025n

.meas tran vdout1_302ck1660 FIND v(dout1_302) AT=835.025n

.meas tran vdout1_303ck1660 FIND v(dout1_303) AT=835.025n

.meas tran vdout1_304ck1660 FIND v(dout1_304) AT=835.025n

.meas tran vdout1_305ck1660 FIND v(dout1_305) AT=835.025n

.meas tran vdout1_306ck1660 FIND v(dout1_306) AT=835.025n

.meas tran vdout1_307ck1660 FIND v(dout1_307) AT=835.025n

.meas tran vdout1_308ck1660 FIND v(dout1_308) AT=835.025n

.meas tran vdout1_309ck1660 FIND v(dout1_309) AT=835.025n

.meas tran vdout1_310ck1660 FIND v(dout1_310) AT=835.025n

.meas tran vdout1_311ck1660 FIND v(dout1_311) AT=835.025n

.meas tran vdout1_312ck1660 FIND v(dout1_312) AT=835.025n

.meas tran vdout1_313ck1660 FIND v(dout1_313) AT=835.025n

.meas tran vdout1_314ck1660 FIND v(dout1_314) AT=835.025n

.meas tran vdout1_315ck1660 FIND v(dout1_315) AT=835.025n

.meas tran vdout1_316ck1660 FIND v(dout1_316) AT=835.025n

.meas tran vdout1_317ck1660 FIND v(dout1_317) AT=835.025n

.meas tran vdout1_318ck1660 FIND v(dout1_318) AT=835.025n

.meas tran vdout1_319ck1660 FIND v(dout1_319) AT=835.025n

.meas tran vdout1_320ck1660 FIND v(dout1_320) AT=835.025n

.meas tran vdout1_321ck1660 FIND v(dout1_321) AT=835.025n

.meas tran vdout1_322ck1660 FIND v(dout1_322) AT=835.025n

.meas tran vdout1_323ck1660 FIND v(dout1_323) AT=835.025n

.meas tran vdout1_324ck1660 FIND v(dout1_324) AT=835.025n

.meas tran vdout1_325ck1660 FIND v(dout1_325) AT=835.025n

.meas tran vdout1_326ck1660 FIND v(dout1_326) AT=835.025n

.meas tran vdout1_327ck1660 FIND v(dout1_327) AT=835.025n

.meas tran vdout1_328ck1660 FIND v(dout1_328) AT=835.025n

.meas tran vdout1_329ck1660 FIND v(dout1_329) AT=835.025n

.meas tran vdout1_330ck1660 FIND v(dout1_330) AT=835.025n

.meas tran vdout1_331ck1660 FIND v(dout1_331) AT=835.025n

.meas tran vdout1_332ck1660 FIND v(dout1_332) AT=835.025n

.meas tran vdout1_333ck1660 FIND v(dout1_333) AT=835.025n

.meas tran vdout1_334ck1660 FIND v(dout1_334) AT=835.025n

.meas tran vdout1_335ck1660 FIND v(dout1_335) AT=835.025n

.meas tran vdout1_336ck1660 FIND v(dout1_336) AT=835.025n

.meas tran vdout1_337ck1660 FIND v(dout1_337) AT=835.025n

.meas tran vdout1_338ck1660 FIND v(dout1_338) AT=835.025n

.meas tran vdout1_339ck1660 FIND v(dout1_339) AT=835.025n

.meas tran vdout1_340ck1660 FIND v(dout1_340) AT=835.025n

.meas tran vdout1_341ck1660 FIND v(dout1_341) AT=835.025n

.meas tran vdout1_342ck1660 FIND v(dout1_342) AT=835.025n

.meas tran vdout1_343ck1660 FIND v(dout1_343) AT=835.025n

.meas tran vdout1_344ck1660 FIND v(dout1_344) AT=835.025n

.meas tran vdout1_345ck1660 FIND v(dout1_345) AT=835.025n

.meas tran vdout1_346ck1660 FIND v(dout1_346) AT=835.025n

.meas tran vdout1_347ck1660 FIND v(dout1_347) AT=835.025n

.meas tran vdout1_348ck1660 FIND v(dout1_348) AT=835.025n

.meas tran vdout1_349ck1660 FIND v(dout1_349) AT=835.025n

.meas tran vdout1_350ck1660 FIND v(dout1_350) AT=835.025n

.meas tran vdout1_351ck1660 FIND v(dout1_351) AT=835.025n

.meas tran vdout1_352ck1660 FIND v(dout1_352) AT=835.025n

.meas tran vdout1_353ck1660 FIND v(dout1_353) AT=835.025n

.meas tran vdout1_354ck1660 FIND v(dout1_354) AT=835.025n

.meas tran vdout1_355ck1660 FIND v(dout1_355) AT=835.025n

.meas tran vdout1_356ck1660 FIND v(dout1_356) AT=835.025n

.meas tran vdout1_357ck1660 FIND v(dout1_357) AT=835.025n

.meas tran vdout1_358ck1660 FIND v(dout1_358) AT=835.025n

.meas tran vdout1_359ck1660 FIND v(dout1_359) AT=835.025n

.meas tran vdout1_360ck1660 FIND v(dout1_360) AT=835.025n

.meas tran vdout1_361ck1660 FIND v(dout1_361) AT=835.025n

.meas tran vdout1_362ck1660 FIND v(dout1_362) AT=835.025n

.meas tran vdout1_363ck1660 FIND v(dout1_363) AT=835.025n

.meas tran vdout1_364ck1660 FIND v(dout1_364) AT=835.025n

.meas tran vdout1_365ck1660 FIND v(dout1_365) AT=835.025n

.meas tran vdout1_366ck1660 FIND v(dout1_366) AT=835.025n

.meas tran vdout1_367ck1660 FIND v(dout1_367) AT=835.025n

.meas tran vdout1_368ck1660 FIND v(dout1_368) AT=835.025n

.meas tran vdout1_369ck1660 FIND v(dout1_369) AT=835.025n

.meas tran vdout1_370ck1660 FIND v(dout1_370) AT=835.025n

.meas tran vdout1_371ck1660 FIND v(dout1_371) AT=835.025n

.meas tran vdout1_372ck1660 FIND v(dout1_372) AT=835.025n

.meas tran vdout1_373ck1660 FIND v(dout1_373) AT=835.025n

.meas tran vdout1_374ck1660 FIND v(dout1_374) AT=835.025n

.meas tran vdout1_375ck1660 FIND v(dout1_375) AT=835.025n

.meas tran vdout1_376ck1660 FIND v(dout1_376) AT=835.025n

.meas tran vdout1_377ck1660 FIND v(dout1_377) AT=835.025n

.meas tran vdout1_378ck1660 FIND v(dout1_378) AT=835.025n

.meas tran vdout1_379ck1660 FIND v(dout1_379) AT=835.025n

.meas tran vdout1_380ck1660 FIND v(dout1_380) AT=835.025n

.meas tran vdout1_381ck1660 FIND v(dout1_381) AT=835.025n

.meas tran vdout1_382ck1660 FIND v(dout1_382) AT=835.025n

.meas tran vdout1_383ck1660 FIND v(dout1_383) AT=835.025n

.meas tran vdout1_384ck1660 FIND v(dout1_384) AT=835.025n

.meas tran vdout1_385ck1660 FIND v(dout1_385) AT=835.025n

.meas tran vdout1_386ck1660 FIND v(dout1_386) AT=835.025n

.meas tran vdout1_387ck1660 FIND v(dout1_387) AT=835.025n

.meas tran vdout1_388ck1660 FIND v(dout1_388) AT=835.025n

.meas tran vdout1_389ck1660 FIND v(dout1_389) AT=835.025n

.meas tran vdout1_390ck1660 FIND v(dout1_390) AT=835.025n

.meas tran vdout1_391ck1660 FIND v(dout1_391) AT=835.025n

.meas tran vdout1_392ck1660 FIND v(dout1_392) AT=835.025n

.meas tran vdout1_393ck1660 FIND v(dout1_393) AT=835.025n

.meas tran vdout1_394ck1660 FIND v(dout1_394) AT=835.025n

.meas tran vdout1_395ck1660 FIND v(dout1_395) AT=835.025n

.meas tran vdout1_396ck1660 FIND v(dout1_396) AT=835.025n

.meas tran vdout1_397ck1660 FIND v(dout1_397) AT=835.025n

.meas tran vdout1_398ck1660 FIND v(dout1_398) AT=835.025n

.meas tran vdout1_399ck1660 FIND v(dout1_399) AT=835.025n

.meas tran vdout1_400ck1660 FIND v(dout1_400) AT=835.025n

.meas tran vdout1_401ck1660 FIND v(dout1_401) AT=835.025n

.meas tran vdout1_402ck1660 FIND v(dout1_402) AT=835.025n

.meas tran vdout1_403ck1660 FIND v(dout1_403) AT=835.025n

.meas tran vdout1_404ck1660 FIND v(dout1_404) AT=835.025n

.meas tran vdout1_405ck1660 FIND v(dout1_405) AT=835.025n

.meas tran vdout1_406ck1660 FIND v(dout1_406) AT=835.025n

.meas tran vdout1_407ck1660 FIND v(dout1_407) AT=835.025n

.meas tran vdout1_408ck1660 FIND v(dout1_408) AT=835.025n

.meas tran vdout1_409ck1660 FIND v(dout1_409) AT=835.025n

.meas tran vdout1_410ck1660 FIND v(dout1_410) AT=835.025n

.meas tran vdout1_411ck1660 FIND v(dout1_411) AT=835.025n

.meas tran vdout1_412ck1660 FIND v(dout1_412) AT=835.025n

.meas tran vdout1_413ck1660 FIND v(dout1_413) AT=835.025n

.meas tran vdout1_414ck1660 FIND v(dout1_414) AT=835.025n

.meas tran vdout1_415ck1660 FIND v(dout1_415) AT=835.025n

.meas tran vdout1_416ck1660 FIND v(dout1_416) AT=835.025n

.meas tran vdout1_417ck1660 FIND v(dout1_417) AT=835.025n

.meas tran vdout1_418ck1660 FIND v(dout1_418) AT=835.025n

.meas tran vdout1_419ck1660 FIND v(dout1_419) AT=835.025n

.meas tran vdout1_420ck1660 FIND v(dout1_420) AT=835.025n

.meas tran vdout1_421ck1660 FIND v(dout1_421) AT=835.025n

.meas tran vdout1_422ck1660 FIND v(dout1_422) AT=835.025n

.meas tran vdout1_423ck1660 FIND v(dout1_423) AT=835.025n

.meas tran vdout1_424ck1660 FIND v(dout1_424) AT=835.025n

.meas tran vdout1_425ck1660 FIND v(dout1_425) AT=835.025n

.meas tran vdout1_426ck1660 FIND v(dout1_426) AT=835.025n

.meas tran vdout1_427ck1660 FIND v(dout1_427) AT=835.025n

.meas tran vdout1_428ck1660 FIND v(dout1_428) AT=835.025n

.meas tran vdout1_429ck1660 FIND v(dout1_429) AT=835.025n

.meas tran vdout1_430ck1660 FIND v(dout1_430) AT=835.025n

.meas tran vdout1_431ck1660 FIND v(dout1_431) AT=835.025n

.meas tran vdout1_432ck1660 FIND v(dout1_432) AT=835.025n

.meas tran vdout1_433ck1660 FIND v(dout1_433) AT=835.025n

.meas tran vdout1_434ck1660 FIND v(dout1_434) AT=835.025n

.meas tran vdout1_435ck1660 FIND v(dout1_435) AT=835.025n

.meas tran vdout1_436ck1660 FIND v(dout1_436) AT=835.025n

.meas tran vdout1_437ck1660 FIND v(dout1_437) AT=835.025n

.meas tran vdout1_438ck1660 FIND v(dout1_438) AT=835.025n

.meas tran vdout1_439ck1660 FIND v(dout1_439) AT=835.025n

.meas tran vdout1_440ck1660 FIND v(dout1_440) AT=835.025n

.meas tran vdout1_441ck1660 FIND v(dout1_441) AT=835.025n

.meas tran vdout1_442ck1660 FIND v(dout1_442) AT=835.025n

.meas tran vdout1_443ck1660 FIND v(dout1_443) AT=835.025n

.meas tran vdout1_444ck1660 FIND v(dout1_444) AT=835.025n

.meas tran vdout1_445ck1660 FIND v(dout1_445) AT=835.025n

.meas tran vdout1_446ck1660 FIND v(dout1_446) AT=835.025n

.meas tran vdout1_447ck1660 FIND v(dout1_447) AT=835.025n

.meas tran vdout1_448ck1660 FIND v(dout1_448) AT=835.025n

.meas tran vdout1_449ck1660 FIND v(dout1_449) AT=835.025n

.meas tran vdout1_450ck1660 FIND v(dout1_450) AT=835.025n

.meas tran vdout1_451ck1660 FIND v(dout1_451) AT=835.025n

.meas tran vdout1_452ck1660 FIND v(dout1_452) AT=835.025n

.meas tran vdout1_453ck1660 FIND v(dout1_453) AT=835.025n

.meas tran vdout1_454ck1660 FIND v(dout1_454) AT=835.025n

.meas tran vdout1_455ck1660 FIND v(dout1_455) AT=835.025n

.meas tran vdout1_456ck1660 FIND v(dout1_456) AT=835.025n

.meas tran vdout1_457ck1660 FIND v(dout1_457) AT=835.025n

.meas tran vdout1_458ck1660 FIND v(dout1_458) AT=835.025n

.meas tran vdout1_459ck1660 FIND v(dout1_459) AT=835.025n

.meas tran vdout1_460ck1660 FIND v(dout1_460) AT=835.025n

.meas tran vdout1_461ck1660 FIND v(dout1_461) AT=835.025n

.meas tran vdout1_462ck1660 FIND v(dout1_462) AT=835.025n

.meas tran vdout1_463ck1660 FIND v(dout1_463) AT=835.025n

.meas tran vdout1_464ck1660 FIND v(dout1_464) AT=835.025n

.meas tran vdout1_465ck1660 FIND v(dout1_465) AT=835.025n

.meas tran vdout1_466ck1660 FIND v(dout1_466) AT=835.025n

.meas tran vdout1_467ck1660 FIND v(dout1_467) AT=835.025n

.meas tran vdout1_468ck1660 FIND v(dout1_468) AT=835.025n

.meas tran vdout1_469ck1660 FIND v(dout1_469) AT=835.025n

.meas tran vdout1_470ck1660 FIND v(dout1_470) AT=835.025n

.meas tran vdout1_471ck1660 FIND v(dout1_471) AT=835.025n

.meas tran vdout1_472ck1660 FIND v(dout1_472) AT=835.025n

.meas tran vdout1_473ck1660 FIND v(dout1_473) AT=835.025n

.meas tran vdout1_474ck1660 FIND v(dout1_474) AT=835.025n

.meas tran vdout1_475ck1660 FIND v(dout1_475) AT=835.025n

.meas tran vdout1_476ck1660 FIND v(dout1_476) AT=835.025n

.meas tran vdout1_477ck1660 FIND v(dout1_477) AT=835.025n

.meas tran vdout1_478ck1660 FIND v(dout1_478) AT=835.025n

.meas tran vdout1_479ck1660 FIND v(dout1_479) AT=835.025n

.meas tran vdout1_480ck1660 FIND v(dout1_480) AT=835.025n

.meas tran vdout1_481ck1660 FIND v(dout1_481) AT=835.025n

.meas tran vdout1_482ck1660 FIND v(dout1_482) AT=835.025n

.meas tran vdout1_483ck1660 FIND v(dout1_483) AT=835.025n

.meas tran vdout1_484ck1660 FIND v(dout1_484) AT=835.025n

.meas tran vdout1_485ck1660 FIND v(dout1_485) AT=835.025n

.meas tran vdout1_486ck1660 FIND v(dout1_486) AT=835.025n

.meas tran vdout1_487ck1660 FIND v(dout1_487) AT=835.025n

.meas tran vdout1_488ck1660 FIND v(dout1_488) AT=835.025n

.meas tran vdout1_489ck1660 FIND v(dout1_489) AT=835.025n

.meas tran vdout1_490ck1660 FIND v(dout1_490) AT=835.025n

.meas tran vdout1_491ck1660 FIND v(dout1_491) AT=835.025n

.meas tran vdout1_492ck1660 FIND v(dout1_492) AT=835.025n

.meas tran vdout1_493ck1660 FIND v(dout1_493) AT=835.025n

.meas tran vdout1_494ck1660 FIND v(dout1_494) AT=835.025n

.meas tran vdout1_495ck1660 FIND v(dout1_495) AT=835.025n

.meas tran vdout1_496ck1660 FIND v(dout1_496) AT=835.025n

.meas tran vdout1_497ck1660 FIND v(dout1_497) AT=835.025n

.meas tran vdout1_498ck1660 FIND v(dout1_498) AT=835.025n

.meas tran vdout1_499ck1660 FIND v(dout1_499) AT=835.025n

.meas tran vdout1_500ck1660 FIND v(dout1_500) AT=835.025n

.meas tran vdout1_501ck1660 FIND v(dout1_501) AT=835.025n

.meas tran vdout1_502ck1660 FIND v(dout1_502) AT=835.025n

.meas tran vdout1_503ck1660 FIND v(dout1_503) AT=835.025n

.meas tran vdout1_504ck1660 FIND v(dout1_504) AT=835.025n

.meas tran vdout1_505ck1660 FIND v(dout1_505) AT=835.025n

.meas tran vdout1_506ck1660 FIND v(dout1_506) AT=835.025n

.meas tran vdout1_507ck1660 FIND v(dout1_507) AT=835.025n

.meas tran vdout1_508ck1660 FIND v(dout1_508) AT=835.025n

.meas tran vdout1_509ck1660 FIND v(dout1_509) AT=835.025n

.meas tran vdout1_510ck1660 FIND v(dout1_510) AT=835.025n

.meas tran vdout1_511ck1660 FIND v(dout1_511) AT=835.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_22ck1750 FIND v(dout1_22) AT=880.025n

.meas tran vdout1_23ck1750 FIND v(dout1_23) AT=880.025n

.meas tran vdout1_24ck1750 FIND v(dout1_24) AT=880.025n

.meas tran vdout1_25ck1750 FIND v(dout1_25) AT=880.025n

.meas tran vdout1_26ck1750 FIND v(dout1_26) AT=880.025n

.meas tran vdout1_27ck1750 FIND v(dout1_27) AT=880.025n

.meas tran vdout1_28ck1750 FIND v(dout1_28) AT=880.025n

.meas tran vdout1_29ck1750 FIND v(dout1_29) AT=880.025n

.meas tran vdout1_30ck1750 FIND v(dout1_30) AT=880.025n

.meas tran vdout1_31ck1750 FIND v(dout1_31) AT=880.025n

.meas tran vdout1_32ck1750 FIND v(dout1_32) AT=880.025n

.meas tran vdout1_33ck1750 FIND v(dout1_33) AT=880.025n

.meas tran vdout1_34ck1750 FIND v(dout1_34) AT=880.025n

.meas tran vdout1_35ck1750 FIND v(dout1_35) AT=880.025n

.meas tran vdout1_36ck1750 FIND v(dout1_36) AT=880.025n

.meas tran vdout1_37ck1750 FIND v(dout1_37) AT=880.025n

.meas tran vdout1_38ck1750 FIND v(dout1_38) AT=880.025n

.meas tran vdout1_39ck1750 FIND v(dout1_39) AT=880.025n

.meas tran vdout1_40ck1750 FIND v(dout1_40) AT=880.025n

.meas tran vdout1_41ck1750 FIND v(dout1_41) AT=880.025n

.meas tran vdout1_42ck1750 FIND v(dout1_42) AT=880.025n

.meas tran vdout1_43ck1750 FIND v(dout1_43) AT=880.025n

.meas tran vdout1_44ck1750 FIND v(dout1_44) AT=880.025n

.meas tran vdout1_45ck1750 FIND v(dout1_45) AT=880.025n

.meas tran vdout1_46ck1750 FIND v(dout1_46) AT=880.025n

.meas tran vdout1_47ck1750 FIND v(dout1_47) AT=880.025n

.meas tran vdout1_48ck1750 FIND v(dout1_48) AT=880.025n

.meas tran vdout1_49ck1750 FIND v(dout1_49) AT=880.025n

.meas tran vdout1_50ck1750 FIND v(dout1_50) AT=880.025n

.meas tran vdout1_51ck1750 FIND v(dout1_51) AT=880.025n

.meas tran vdout1_52ck1750 FIND v(dout1_52) AT=880.025n

.meas tran vdout1_53ck1750 FIND v(dout1_53) AT=880.025n

.meas tran vdout1_54ck1750 FIND v(dout1_54) AT=880.025n

.meas tran vdout1_55ck1750 FIND v(dout1_55) AT=880.025n

.meas tran vdout1_56ck1750 FIND v(dout1_56) AT=880.025n

.meas tran vdout1_57ck1750 FIND v(dout1_57) AT=880.025n

.meas tran vdout1_58ck1750 FIND v(dout1_58) AT=880.025n

.meas tran vdout1_59ck1750 FIND v(dout1_59) AT=880.025n

.meas tran vdout1_60ck1750 FIND v(dout1_60) AT=880.025n

.meas tran vdout1_61ck1750 FIND v(dout1_61) AT=880.025n

.meas tran vdout1_62ck1750 FIND v(dout1_62) AT=880.025n

.meas tran vdout1_63ck1750 FIND v(dout1_63) AT=880.025n

.meas tran vdout1_64ck1750 FIND v(dout1_64) AT=880.025n

.meas tran vdout1_65ck1750 FIND v(dout1_65) AT=880.025n

.meas tran vdout1_66ck1750 FIND v(dout1_66) AT=880.025n

.meas tran vdout1_67ck1750 FIND v(dout1_67) AT=880.025n

.meas tran vdout1_68ck1750 FIND v(dout1_68) AT=880.025n

.meas tran vdout1_69ck1750 FIND v(dout1_69) AT=880.025n

.meas tran vdout1_70ck1750 FIND v(dout1_70) AT=880.025n

.meas tran vdout1_71ck1750 FIND v(dout1_71) AT=880.025n

.meas tran vdout1_72ck1750 FIND v(dout1_72) AT=880.025n

.meas tran vdout1_73ck1750 FIND v(dout1_73) AT=880.025n

.meas tran vdout1_74ck1750 FIND v(dout1_74) AT=880.025n

.meas tran vdout1_75ck1750 FIND v(dout1_75) AT=880.025n

.meas tran vdout1_76ck1750 FIND v(dout1_76) AT=880.025n

.meas tran vdout1_77ck1750 FIND v(dout1_77) AT=880.025n

.meas tran vdout1_78ck1750 FIND v(dout1_78) AT=880.025n

.meas tran vdout1_79ck1750 FIND v(dout1_79) AT=880.025n

.meas tran vdout1_80ck1750 FIND v(dout1_80) AT=880.025n

.meas tran vdout1_81ck1750 FIND v(dout1_81) AT=880.025n

.meas tran vdout1_82ck1750 FIND v(dout1_82) AT=880.025n

.meas tran vdout1_83ck1750 FIND v(dout1_83) AT=880.025n

.meas tran vdout1_84ck1750 FIND v(dout1_84) AT=880.025n

.meas tran vdout1_85ck1750 FIND v(dout1_85) AT=880.025n

.meas tran vdout1_86ck1750 FIND v(dout1_86) AT=880.025n

.meas tran vdout1_87ck1750 FIND v(dout1_87) AT=880.025n

.meas tran vdout1_88ck1750 FIND v(dout1_88) AT=880.025n

.meas tran vdout1_89ck1750 FIND v(dout1_89) AT=880.025n

.meas tran vdout1_90ck1750 FIND v(dout1_90) AT=880.025n

.meas tran vdout1_91ck1750 FIND v(dout1_91) AT=880.025n

.meas tran vdout1_92ck1750 FIND v(dout1_92) AT=880.025n

.meas tran vdout1_93ck1750 FIND v(dout1_93) AT=880.025n

.meas tran vdout1_94ck1750 FIND v(dout1_94) AT=880.025n

.meas tran vdout1_95ck1750 FIND v(dout1_95) AT=880.025n

.meas tran vdout1_96ck1750 FIND v(dout1_96) AT=880.025n

.meas tran vdout1_97ck1750 FIND v(dout1_97) AT=880.025n

.meas tran vdout1_98ck1750 FIND v(dout1_98) AT=880.025n

.meas tran vdout1_99ck1750 FIND v(dout1_99) AT=880.025n

.meas tran vdout1_100ck1750 FIND v(dout1_100) AT=880.025n

.meas tran vdout1_101ck1750 FIND v(dout1_101) AT=880.025n

.meas tran vdout1_102ck1750 FIND v(dout1_102) AT=880.025n

.meas tran vdout1_103ck1750 FIND v(dout1_103) AT=880.025n

.meas tran vdout1_104ck1750 FIND v(dout1_104) AT=880.025n

.meas tran vdout1_105ck1750 FIND v(dout1_105) AT=880.025n

.meas tran vdout1_106ck1750 FIND v(dout1_106) AT=880.025n

.meas tran vdout1_107ck1750 FIND v(dout1_107) AT=880.025n

.meas tran vdout1_108ck1750 FIND v(dout1_108) AT=880.025n

.meas tran vdout1_109ck1750 FIND v(dout1_109) AT=880.025n

.meas tran vdout1_110ck1750 FIND v(dout1_110) AT=880.025n

.meas tran vdout1_111ck1750 FIND v(dout1_111) AT=880.025n

.meas tran vdout1_112ck1750 FIND v(dout1_112) AT=880.025n

.meas tran vdout1_113ck1750 FIND v(dout1_113) AT=880.025n

.meas tran vdout1_114ck1750 FIND v(dout1_114) AT=880.025n

.meas tran vdout1_115ck1750 FIND v(dout1_115) AT=880.025n

.meas tran vdout1_116ck1750 FIND v(dout1_116) AT=880.025n

.meas tran vdout1_117ck1750 FIND v(dout1_117) AT=880.025n

.meas tran vdout1_118ck1750 FIND v(dout1_118) AT=880.025n

.meas tran vdout1_119ck1750 FIND v(dout1_119) AT=880.025n

.meas tran vdout1_120ck1750 FIND v(dout1_120) AT=880.025n

.meas tran vdout1_121ck1750 FIND v(dout1_121) AT=880.025n

.meas tran vdout1_122ck1750 FIND v(dout1_122) AT=880.025n

.meas tran vdout1_123ck1750 FIND v(dout1_123) AT=880.025n

.meas tran vdout1_124ck1750 FIND v(dout1_124) AT=880.025n

.meas tran vdout1_125ck1750 FIND v(dout1_125) AT=880.025n

.meas tran vdout1_126ck1750 FIND v(dout1_126) AT=880.025n

.meas tran vdout1_127ck1750 FIND v(dout1_127) AT=880.025n

.meas tran vdout1_128ck1750 FIND v(dout1_128) AT=880.025n

.meas tran vdout1_129ck1750 FIND v(dout1_129) AT=880.025n

.meas tran vdout1_130ck1750 FIND v(dout1_130) AT=880.025n

.meas tran vdout1_131ck1750 FIND v(dout1_131) AT=880.025n

.meas tran vdout1_132ck1750 FIND v(dout1_132) AT=880.025n

.meas tran vdout1_133ck1750 FIND v(dout1_133) AT=880.025n

.meas tran vdout1_134ck1750 FIND v(dout1_134) AT=880.025n

.meas tran vdout1_135ck1750 FIND v(dout1_135) AT=880.025n

.meas tran vdout1_136ck1750 FIND v(dout1_136) AT=880.025n

.meas tran vdout1_137ck1750 FIND v(dout1_137) AT=880.025n

.meas tran vdout1_138ck1750 FIND v(dout1_138) AT=880.025n

.meas tran vdout1_139ck1750 FIND v(dout1_139) AT=880.025n

.meas tran vdout1_140ck1750 FIND v(dout1_140) AT=880.025n

.meas tran vdout1_141ck1750 FIND v(dout1_141) AT=880.025n

.meas tran vdout1_142ck1750 FIND v(dout1_142) AT=880.025n

.meas tran vdout1_143ck1750 FIND v(dout1_143) AT=880.025n

.meas tran vdout1_144ck1750 FIND v(dout1_144) AT=880.025n

.meas tran vdout1_145ck1750 FIND v(dout1_145) AT=880.025n

.meas tran vdout1_146ck1750 FIND v(dout1_146) AT=880.025n

.meas tran vdout1_147ck1750 FIND v(dout1_147) AT=880.025n

.meas tran vdout1_148ck1750 FIND v(dout1_148) AT=880.025n

.meas tran vdout1_149ck1750 FIND v(dout1_149) AT=880.025n

.meas tran vdout1_150ck1750 FIND v(dout1_150) AT=880.025n

.meas tran vdout1_151ck1750 FIND v(dout1_151) AT=880.025n

.meas tran vdout1_152ck1750 FIND v(dout1_152) AT=880.025n

.meas tran vdout1_153ck1750 FIND v(dout1_153) AT=880.025n

.meas tran vdout1_154ck1750 FIND v(dout1_154) AT=880.025n

.meas tran vdout1_155ck1750 FIND v(dout1_155) AT=880.025n

.meas tran vdout1_156ck1750 FIND v(dout1_156) AT=880.025n

.meas tran vdout1_157ck1750 FIND v(dout1_157) AT=880.025n

.meas tran vdout1_158ck1750 FIND v(dout1_158) AT=880.025n

.meas tran vdout1_159ck1750 FIND v(dout1_159) AT=880.025n

.meas tran vdout1_160ck1750 FIND v(dout1_160) AT=880.025n

.meas tran vdout1_161ck1750 FIND v(dout1_161) AT=880.025n

.meas tran vdout1_162ck1750 FIND v(dout1_162) AT=880.025n

.meas tran vdout1_163ck1750 FIND v(dout1_163) AT=880.025n

.meas tran vdout1_164ck1750 FIND v(dout1_164) AT=880.025n

.meas tran vdout1_165ck1750 FIND v(dout1_165) AT=880.025n

.meas tran vdout1_166ck1750 FIND v(dout1_166) AT=880.025n

.meas tran vdout1_167ck1750 FIND v(dout1_167) AT=880.025n

.meas tran vdout1_168ck1750 FIND v(dout1_168) AT=880.025n

.meas tran vdout1_169ck1750 FIND v(dout1_169) AT=880.025n

.meas tran vdout1_170ck1750 FIND v(dout1_170) AT=880.025n

.meas tran vdout1_171ck1750 FIND v(dout1_171) AT=880.025n

.meas tran vdout1_172ck1750 FIND v(dout1_172) AT=880.025n

.meas tran vdout1_173ck1750 FIND v(dout1_173) AT=880.025n

.meas tran vdout1_174ck1750 FIND v(dout1_174) AT=880.025n

.meas tran vdout1_175ck1750 FIND v(dout1_175) AT=880.025n

.meas tran vdout1_176ck1750 FIND v(dout1_176) AT=880.025n

.meas tran vdout1_177ck1750 FIND v(dout1_177) AT=880.025n

.meas tran vdout1_178ck1750 FIND v(dout1_178) AT=880.025n

.meas tran vdout1_179ck1750 FIND v(dout1_179) AT=880.025n

.meas tran vdout1_180ck1750 FIND v(dout1_180) AT=880.025n

.meas tran vdout1_181ck1750 FIND v(dout1_181) AT=880.025n

.meas tran vdout1_182ck1750 FIND v(dout1_182) AT=880.025n

.meas tran vdout1_183ck1750 FIND v(dout1_183) AT=880.025n

.meas tran vdout1_184ck1750 FIND v(dout1_184) AT=880.025n

.meas tran vdout1_185ck1750 FIND v(dout1_185) AT=880.025n

.meas tran vdout1_186ck1750 FIND v(dout1_186) AT=880.025n

.meas tran vdout1_187ck1750 FIND v(dout1_187) AT=880.025n

.meas tran vdout1_188ck1750 FIND v(dout1_188) AT=880.025n

.meas tran vdout1_189ck1750 FIND v(dout1_189) AT=880.025n

.meas tran vdout1_190ck1750 FIND v(dout1_190) AT=880.025n

.meas tran vdout1_191ck1750 FIND v(dout1_191) AT=880.025n

.meas tran vdout1_192ck1750 FIND v(dout1_192) AT=880.025n

.meas tran vdout1_193ck1750 FIND v(dout1_193) AT=880.025n

.meas tran vdout1_194ck1750 FIND v(dout1_194) AT=880.025n

.meas tran vdout1_195ck1750 FIND v(dout1_195) AT=880.025n

.meas tran vdout1_196ck1750 FIND v(dout1_196) AT=880.025n

.meas tran vdout1_197ck1750 FIND v(dout1_197) AT=880.025n

.meas tran vdout1_198ck1750 FIND v(dout1_198) AT=880.025n

.meas tran vdout1_199ck1750 FIND v(dout1_199) AT=880.025n

.meas tran vdout1_200ck1750 FIND v(dout1_200) AT=880.025n

.meas tran vdout1_201ck1750 FIND v(dout1_201) AT=880.025n

.meas tran vdout1_202ck1750 FIND v(dout1_202) AT=880.025n

.meas tran vdout1_203ck1750 FIND v(dout1_203) AT=880.025n

.meas tran vdout1_204ck1750 FIND v(dout1_204) AT=880.025n

.meas tran vdout1_205ck1750 FIND v(dout1_205) AT=880.025n

.meas tran vdout1_206ck1750 FIND v(dout1_206) AT=880.025n

.meas tran vdout1_207ck1750 FIND v(dout1_207) AT=880.025n

.meas tran vdout1_208ck1750 FIND v(dout1_208) AT=880.025n

.meas tran vdout1_209ck1750 FIND v(dout1_209) AT=880.025n

.meas tran vdout1_210ck1750 FIND v(dout1_210) AT=880.025n

.meas tran vdout1_211ck1750 FIND v(dout1_211) AT=880.025n

.meas tran vdout1_212ck1750 FIND v(dout1_212) AT=880.025n

.meas tran vdout1_213ck1750 FIND v(dout1_213) AT=880.025n

.meas tran vdout1_214ck1750 FIND v(dout1_214) AT=880.025n

.meas tran vdout1_215ck1750 FIND v(dout1_215) AT=880.025n

.meas tran vdout1_216ck1750 FIND v(dout1_216) AT=880.025n

.meas tran vdout1_217ck1750 FIND v(dout1_217) AT=880.025n

.meas tran vdout1_218ck1750 FIND v(dout1_218) AT=880.025n

.meas tran vdout1_219ck1750 FIND v(dout1_219) AT=880.025n

.meas tran vdout1_220ck1750 FIND v(dout1_220) AT=880.025n

.meas tran vdout1_221ck1750 FIND v(dout1_221) AT=880.025n

.meas tran vdout1_222ck1750 FIND v(dout1_222) AT=880.025n

.meas tran vdout1_223ck1750 FIND v(dout1_223) AT=880.025n

.meas tran vdout1_224ck1750 FIND v(dout1_224) AT=880.025n

.meas tran vdout1_225ck1750 FIND v(dout1_225) AT=880.025n

.meas tran vdout1_226ck1750 FIND v(dout1_226) AT=880.025n

.meas tran vdout1_227ck1750 FIND v(dout1_227) AT=880.025n

.meas tran vdout1_228ck1750 FIND v(dout1_228) AT=880.025n

.meas tran vdout1_229ck1750 FIND v(dout1_229) AT=880.025n

.meas tran vdout1_230ck1750 FIND v(dout1_230) AT=880.025n

.meas tran vdout1_231ck1750 FIND v(dout1_231) AT=880.025n

.meas tran vdout1_232ck1750 FIND v(dout1_232) AT=880.025n

.meas tran vdout1_233ck1750 FIND v(dout1_233) AT=880.025n

.meas tran vdout1_234ck1750 FIND v(dout1_234) AT=880.025n

.meas tran vdout1_235ck1750 FIND v(dout1_235) AT=880.025n

.meas tran vdout1_236ck1750 FIND v(dout1_236) AT=880.025n

.meas tran vdout1_237ck1750 FIND v(dout1_237) AT=880.025n

.meas tran vdout1_238ck1750 FIND v(dout1_238) AT=880.025n

.meas tran vdout1_239ck1750 FIND v(dout1_239) AT=880.025n

.meas tran vdout1_240ck1750 FIND v(dout1_240) AT=880.025n

.meas tran vdout1_241ck1750 FIND v(dout1_241) AT=880.025n

.meas tran vdout1_242ck1750 FIND v(dout1_242) AT=880.025n

.meas tran vdout1_243ck1750 FIND v(dout1_243) AT=880.025n

.meas tran vdout1_244ck1750 FIND v(dout1_244) AT=880.025n

.meas tran vdout1_245ck1750 FIND v(dout1_245) AT=880.025n

.meas tran vdout1_246ck1750 FIND v(dout1_246) AT=880.025n

.meas tran vdout1_247ck1750 FIND v(dout1_247) AT=880.025n

.meas tran vdout1_248ck1750 FIND v(dout1_248) AT=880.025n

.meas tran vdout1_249ck1750 FIND v(dout1_249) AT=880.025n

.meas tran vdout1_250ck1750 FIND v(dout1_250) AT=880.025n

.meas tran vdout1_251ck1750 FIND v(dout1_251) AT=880.025n

.meas tran vdout1_252ck1750 FIND v(dout1_252) AT=880.025n

.meas tran vdout1_253ck1750 FIND v(dout1_253) AT=880.025n

.meas tran vdout1_254ck1750 FIND v(dout1_254) AT=880.025n

.meas tran vdout1_255ck1750 FIND v(dout1_255) AT=880.025n

.meas tran vdout1_256ck1750 FIND v(dout1_256) AT=880.025n

.meas tran vdout1_257ck1750 FIND v(dout1_257) AT=880.025n

.meas tran vdout1_258ck1750 FIND v(dout1_258) AT=880.025n

.meas tran vdout1_259ck1750 FIND v(dout1_259) AT=880.025n

.meas tran vdout1_260ck1750 FIND v(dout1_260) AT=880.025n

.meas tran vdout1_261ck1750 FIND v(dout1_261) AT=880.025n

.meas tran vdout1_262ck1750 FIND v(dout1_262) AT=880.025n

.meas tran vdout1_263ck1750 FIND v(dout1_263) AT=880.025n

.meas tran vdout1_264ck1750 FIND v(dout1_264) AT=880.025n

.meas tran vdout1_265ck1750 FIND v(dout1_265) AT=880.025n

.meas tran vdout1_266ck1750 FIND v(dout1_266) AT=880.025n

.meas tran vdout1_267ck1750 FIND v(dout1_267) AT=880.025n

.meas tran vdout1_268ck1750 FIND v(dout1_268) AT=880.025n

.meas tran vdout1_269ck1750 FIND v(dout1_269) AT=880.025n

.meas tran vdout1_270ck1750 FIND v(dout1_270) AT=880.025n

.meas tran vdout1_271ck1750 FIND v(dout1_271) AT=880.025n

.meas tran vdout1_272ck1750 FIND v(dout1_272) AT=880.025n

.meas tran vdout1_273ck1750 FIND v(dout1_273) AT=880.025n

.meas tran vdout1_274ck1750 FIND v(dout1_274) AT=880.025n

.meas tran vdout1_275ck1750 FIND v(dout1_275) AT=880.025n

.meas tran vdout1_276ck1750 FIND v(dout1_276) AT=880.025n

.meas tran vdout1_277ck1750 FIND v(dout1_277) AT=880.025n

.meas tran vdout1_278ck1750 FIND v(dout1_278) AT=880.025n

.meas tran vdout1_279ck1750 FIND v(dout1_279) AT=880.025n

.meas tran vdout1_280ck1750 FIND v(dout1_280) AT=880.025n

.meas tran vdout1_281ck1750 FIND v(dout1_281) AT=880.025n

.meas tran vdout1_282ck1750 FIND v(dout1_282) AT=880.025n

.meas tran vdout1_283ck1750 FIND v(dout1_283) AT=880.025n

.meas tran vdout1_284ck1750 FIND v(dout1_284) AT=880.025n

.meas tran vdout1_285ck1750 FIND v(dout1_285) AT=880.025n

.meas tran vdout1_286ck1750 FIND v(dout1_286) AT=880.025n

.meas tran vdout1_287ck1750 FIND v(dout1_287) AT=880.025n

.meas tran vdout1_288ck1750 FIND v(dout1_288) AT=880.025n

.meas tran vdout1_289ck1750 FIND v(dout1_289) AT=880.025n

.meas tran vdout1_290ck1750 FIND v(dout1_290) AT=880.025n

.meas tran vdout1_291ck1750 FIND v(dout1_291) AT=880.025n

.meas tran vdout1_292ck1750 FIND v(dout1_292) AT=880.025n

.meas tran vdout1_293ck1750 FIND v(dout1_293) AT=880.025n

.meas tran vdout1_294ck1750 FIND v(dout1_294) AT=880.025n

.meas tran vdout1_295ck1750 FIND v(dout1_295) AT=880.025n

.meas tran vdout1_296ck1750 FIND v(dout1_296) AT=880.025n

.meas tran vdout1_297ck1750 FIND v(dout1_297) AT=880.025n

.meas tran vdout1_298ck1750 FIND v(dout1_298) AT=880.025n

.meas tran vdout1_299ck1750 FIND v(dout1_299) AT=880.025n

.meas tran vdout1_300ck1750 FIND v(dout1_300) AT=880.025n

.meas tran vdout1_301ck1750 FIND v(dout1_301) AT=880.025n

.meas tran vdout1_302ck1750 FIND v(dout1_302) AT=880.025n

.meas tran vdout1_303ck1750 FIND v(dout1_303) AT=880.025n

.meas tran vdout1_304ck1750 FIND v(dout1_304) AT=880.025n

.meas tran vdout1_305ck1750 FIND v(dout1_305) AT=880.025n

.meas tran vdout1_306ck1750 FIND v(dout1_306) AT=880.025n

.meas tran vdout1_307ck1750 FIND v(dout1_307) AT=880.025n

.meas tran vdout1_308ck1750 FIND v(dout1_308) AT=880.025n

.meas tran vdout1_309ck1750 FIND v(dout1_309) AT=880.025n

.meas tran vdout1_310ck1750 FIND v(dout1_310) AT=880.025n

.meas tran vdout1_311ck1750 FIND v(dout1_311) AT=880.025n

.meas tran vdout1_312ck1750 FIND v(dout1_312) AT=880.025n

.meas tran vdout1_313ck1750 FIND v(dout1_313) AT=880.025n

.meas tran vdout1_314ck1750 FIND v(dout1_314) AT=880.025n

.meas tran vdout1_315ck1750 FIND v(dout1_315) AT=880.025n

.meas tran vdout1_316ck1750 FIND v(dout1_316) AT=880.025n

.meas tran vdout1_317ck1750 FIND v(dout1_317) AT=880.025n

.meas tran vdout1_318ck1750 FIND v(dout1_318) AT=880.025n

.meas tran vdout1_319ck1750 FIND v(dout1_319) AT=880.025n

.meas tran vdout1_320ck1750 FIND v(dout1_320) AT=880.025n

.meas tran vdout1_321ck1750 FIND v(dout1_321) AT=880.025n

.meas tran vdout1_322ck1750 FIND v(dout1_322) AT=880.025n

.meas tran vdout1_323ck1750 FIND v(dout1_323) AT=880.025n

.meas tran vdout1_324ck1750 FIND v(dout1_324) AT=880.025n

.meas tran vdout1_325ck1750 FIND v(dout1_325) AT=880.025n

.meas tran vdout1_326ck1750 FIND v(dout1_326) AT=880.025n

.meas tran vdout1_327ck1750 FIND v(dout1_327) AT=880.025n

.meas tran vdout1_328ck1750 FIND v(dout1_328) AT=880.025n

.meas tran vdout1_329ck1750 FIND v(dout1_329) AT=880.025n

.meas tran vdout1_330ck1750 FIND v(dout1_330) AT=880.025n

.meas tran vdout1_331ck1750 FIND v(dout1_331) AT=880.025n

.meas tran vdout1_332ck1750 FIND v(dout1_332) AT=880.025n

.meas tran vdout1_333ck1750 FIND v(dout1_333) AT=880.025n

.meas tran vdout1_334ck1750 FIND v(dout1_334) AT=880.025n

.meas tran vdout1_335ck1750 FIND v(dout1_335) AT=880.025n

.meas tran vdout1_336ck1750 FIND v(dout1_336) AT=880.025n

.meas tran vdout1_337ck1750 FIND v(dout1_337) AT=880.025n

.meas tran vdout1_338ck1750 FIND v(dout1_338) AT=880.025n

.meas tran vdout1_339ck1750 FIND v(dout1_339) AT=880.025n

.meas tran vdout1_340ck1750 FIND v(dout1_340) AT=880.025n

.meas tran vdout1_341ck1750 FIND v(dout1_341) AT=880.025n

.meas tran vdout1_342ck1750 FIND v(dout1_342) AT=880.025n

.meas tran vdout1_343ck1750 FIND v(dout1_343) AT=880.025n

.meas tran vdout1_344ck1750 FIND v(dout1_344) AT=880.025n

.meas tran vdout1_345ck1750 FIND v(dout1_345) AT=880.025n

.meas tran vdout1_346ck1750 FIND v(dout1_346) AT=880.025n

.meas tran vdout1_347ck1750 FIND v(dout1_347) AT=880.025n

.meas tran vdout1_348ck1750 FIND v(dout1_348) AT=880.025n

.meas tran vdout1_349ck1750 FIND v(dout1_349) AT=880.025n

.meas tran vdout1_350ck1750 FIND v(dout1_350) AT=880.025n

.meas tran vdout1_351ck1750 FIND v(dout1_351) AT=880.025n

.meas tran vdout1_352ck1750 FIND v(dout1_352) AT=880.025n

.meas tran vdout1_353ck1750 FIND v(dout1_353) AT=880.025n

.meas tran vdout1_354ck1750 FIND v(dout1_354) AT=880.025n

.meas tran vdout1_355ck1750 FIND v(dout1_355) AT=880.025n

.meas tran vdout1_356ck1750 FIND v(dout1_356) AT=880.025n

.meas tran vdout1_357ck1750 FIND v(dout1_357) AT=880.025n

.meas tran vdout1_358ck1750 FIND v(dout1_358) AT=880.025n

.meas tran vdout1_359ck1750 FIND v(dout1_359) AT=880.025n

.meas tran vdout1_360ck1750 FIND v(dout1_360) AT=880.025n

.meas tran vdout1_361ck1750 FIND v(dout1_361) AT=880.025n

.meas tran vdout1_362ck1750 FIND v(dout1_362) AT=880.025n

.meas tran vdout1_363ck1750 FIND v(dout1_363) AT=880.025n

.meas tran vdout1_364ck1750 FIND v(dout1_364) AT=880.025n

.meas tran vdout1_365ck1750 FIND v(dout1_365) AT=880.025n

.meas tran vdout1_366ck1750 FIND v(dout1_366) AT=880.025n

.meas tran vdout1_367ck1750 FIND v(dout1_367) AT=880.025n

.meas tran vdout1_368ck1750 FIND v(dout1_368) AT=880.025n

.meas tran vdout1_369ck1750 FIND v(dout1_369) AT=880.025n

.meas tran vdout1_370ck1750 FIND v(dout1_370) AT=880.025n

.meas tran vdout1_371ck1750 FIND v(dout1_371) AT=880.025n

.meas tran vdout1_372ck1750 FIND v(dout1_372) AT=880.025n

.meas tran vdout1_373ck1750 FIND v(dout1_373) AT=880.025n

.meas tran vdout1_374ck1750 FIND v(dout1_374) AT=880.025n

.meas tran vdout1_375ck1750 FIND v(dout1_375) AT=880.025n

.meas tran vdout1_376ck1750 FIND v(dout1_376) AT=880.025n

.meas tran vdout1_377ck1750 FIND v(dout1_377) AT=880.025n

.meas tran vdout1_378ck1750 FIND v(dout1_378) AT=880.025n

.meas tran vdout1_379ck1750 FIND v(dout1_379) AT=880.025n

.meas tran vdout1_380ck1750 FIND v(dout1_380) AT=880.025n

.meas tran vdout1_381ck1750 FIND v(dout1_381) AT=880.025n

.meas tran vdout1_382ck1750 FIND v(dout1_382) AT=880.025n

.meas tran vdout1_383ck1750 FIND v(dout1_383) AT=880.025n

.meas tran vdout1_384ck1750 FIND v(dout1_384) AT=880.025n

.meas tran vdout1_385ck1750 FIND v(dout1_385) AT=880.025n

.meas tran vdout1_386ck1750 FIND v(dout1_386) AT=880.025n

.meas tran vdout1_387ck1750 FIND v(dout1_387) AT=880.025n

.meas tran vdout1_388ck1750 FIND v(dout1_388) AT=880.025n

.meas tran vdout1_389ck1750 FIND v(dout1_389) AT=880.025n

.meas tran vdout1_390ck1750 FIND v(dout1_390) AT=880.025n

.meas tran vdout1_391ck1750 FIND v(dout1_391) AT=880.025n

.meas tran vdout1_392ck1750 FIND v(dout1_392) AT=880.025n

.meas tran vdout1_393ck1750 FIND v(dout1_393) AT=880.025n

.meas tran vdout1_394ck1750 FIND v(dout1_394) AT=880.025n

.meas tran vdout1_395ck1750 FIND v(dout1_395) AT=880.025n

.meas tran vdout1_396ck1750 FIND v(dout1_396) AT=880.025n

.meas tran vdout1_397ck1750 FIND v(dout1_397) AT=880.025n

.meas tran vdout1_398ck1750 FIND v(dout1_398) AT=880.025n

.meas tran vdout1_399ck1750 FIND v(dout1_399) AT=880.025n

.meas tran vdout1_400ck1750 FIND v(dout1_400) AT=880.025n

.meas tran vdout1_401ck1750 FIND v(dout1_401) AT=880.025n

.meas tran vdout1_402ck1750 FIND v(dout1_402) AT=880.025n

.meas tran vdout1_403ck1750 FIND v(dout1_403) AT=880.025n

.meas tran vdout1_404ck1750 FIND v(dout1_404) AT=880.025n

.meas tran vdout1_405ck1750 FIND v(dout1_405) AT=880.025n

.meas tran vdout1_406ck1750 FIND v(dout1_406) AT=880.025n

.meas tran vdout1_407ck1750 FIND v(dout1_407) AT=880.025n

.meas tran vdout1_408ck1750 FIND v(dout1_408) AT=880.025n

.meas tran vdout1_409ck1750 FIND v(dout1_409) AT=880.025n

.meas tran vdout1_410ck1750 FIND v(dout1_410) AT=880.025n

.meas tran vdout1_411ck1750 FIND v(dout1_411) AT=880.025n

.meas tran vdout1_412ck1750 FIND v(dout1_412) AT=880.025n

.meas tran vdout1_413ck1750 FIND v(dout1_413) AT=880.025n

.meas tran vdout1_414ck1750 FIND v(dout1_414) AT=880.025n

.meas tran vdout1_415ck1750 FIND v(dout1_415) AT=880.025n

.meas tran vdout1_416ck1750 FIND v(dout1_416) AT=880.025n

.meas tran vdout1_417ck1750 FIND v(dout1_417) AT=880.025n

.meas tran vdout1_418ck1750 FIND v(dout1_418) AT=880.025n

.meas tran vdout1_419ck1750 FIND v(dout1_419) AT=880.025n

.meas tran vdout1_420ck1750 FIND v(dout1_420) AT=880.025n

.meas tran vdout1_421ck1750 FIND v(dout1_421) AT=880.025n

.meas tran vdout1_422ck1750 FIND v(dout1_422) AT=880.025n

.meas tran vdout1_423ck1750 FIND v(dout1_423) AT=880.025n

.meas tran vdout1_424ck1750 FIND v(dout1_424) AT=880.025n

.meas tran vdout1_425ck1750 FIND v(dout1_425) AT=880.025n

.meas tran vdout1_426ck1750 FIND v(dout1_426) AT=880.025n

.meas tran vdout1_427ck1750 FIND v(dout1_427) AT=880.025n

.meas tran vdout1_428ck1750 FIND v(dout1_428) AT=880.025n

.meas tran vdout1_429ck1750 FIND v(dout1_429) AT=880.025n

.meas tran vdout1_430ck1750 FIND v(dout1_430) AT=880.025n

.meas tran vdout1_431ck1750 FIND v(dout1_431) AT=880.025n

.meas tran vdout1_432ck1750 FIND v(dout1_432) AT=880.025n

.meas tran vdout1_433ck1750 FIND v(dout1_433) AT=880.025n

.meas tran vdout1_434ck1750 FIND v(dout1_434) AT=880.025n

.meas tran vdout1_435ck1750 FIND v(dout1_435) AT=880.025n

.meas tran vdout1_436ck1750 FIND v(dout1_436) AT=880.025n

.meas tran vdout1_437ck1750 FIND v(dout1_437) AT=880.025n

.meas tran vdout1_438ck1750 FIND v(dout1_438) AT=880.025n

.meas tran vdout1_439ck1750 FIND v(dout1_439) AT=880.025n

.meas tran vdout1_440ck1750 FIND v(dout1_440) AT=880.025n

.meas tran vdout1_441ck1750 FIND v(dout1_441) AT=880.025n

.meas tran vdout1_442ck1750 FIND v(dout1_442) AT=880.025n

.meas tran vdout1_443ck1750 FIND v(dout1_443) AT=880.025n

.meas tran vdout1_444ck1750 FIND v(dout1_444) AT=880.025n

.meas tran vdout1_445ck1750 FIND v(dout1_445) AT=880.025n

.meas tran vdout1_446ck1750 FIND v(dout1_446) AT=880.025n

.meas tran vdout1_447ck1750 FIND v(dout1_447) AT=880.025n

.meas tran vdout1_448ck1750 FIND v(dout1_448) AT=880.025n

.meas tran vdout1_449ck1750 FIND v(dout1_449) AT=880.025n

.meas tran vdout1_450ck1750 FIND v(dout1_450) AT=880.025n

.meas tran vdout1_451ck1750 FIND v(dout1_451) AT=880.025n

.meas tran vdout1_452ck1750 FIND v(dout1_452) AT=880.025n

.meas tran vdout1_453ck1750 FIND v(dout1_453) AT=880.025n

.meas tran vdout1_454ck1750 FIND v(dout1_454) AT=880.025n

.meas tran vdout1_455ck1750 FIND v(dout1_455) AT=880.025n

.meas tran vdout1_456ck1750 FIND v(dout1_456) AT=880.025n

.meas tran vdout1_457ck1750 FIND v(dout1_457) AT=880.025n

.meas tran vdout1_458ck1750 FIND v(dout1_458) AT=880.025n

.meas tran vdout1_459ck1750 FIND v(dout1_459) AT=880.025n

.meas tran vdout1_460ck1750 FIND v(dout1_460) AT=880.025n

.meas tran vdout1_461ck1750 FIND v(dout1_461) AT=880.025n

.meas tran vdout1_462ck1750 FIND v(dout1_462) AT=880.025n

.meas tran vdout1_463ck1750 FIND v(dout1_463) AT=880.025n

.meas tran vdout1_464ck1750 FIND v(dout1_464) AT=880.025n

.meas tran vdout1_465ck1750 FIND v(dout1_465) AT=880.025n

.meas tran vdout1_466ck1750 FIND v(dout1_466) AT=880.025n

.meas tran vdout1_467ck1750 FIND v(dout1_467) AT=880.025n

.meas tran vdout1_468ck1750 FIND v(dout1_468) AT=880.025n

.meas tran vdout1_469ck1750 FIND v(dout1_469) AT=880.025n

.meas tran vdout1_470ck1750 FIND v(dout1_470) AT=880.025n

.meas tran vdout1_471ck1750 FIND v(dout1_471) AT=880.025n

.meas tran vdout1_472ck1750 FIND v(dout1_472) AT=880.025n

.meas tran vdout1_473ck1750 FIND v(dout1_473) AT=880.025n

.meas tran vdout1_474ck1750 FIND v(dout1_474) AT=880.025n

.meas tran vdout1_475ck1750 FIND v(dout1_475) AT=880.025n

.meas tran vdout1_476ck1750 FIND v(dout1_476) AT=880.025n

.meas tran vdout1_477ck1750 FIND v(dout1_477) AT=880.025n

.meas tran vdout1_478ck1750 FIND v(dout1_478) AT=880.025n

.meas tran vdout1_479ck1750 FIND v(dout1_479) AT=880.025n

.meas tran vdout1_480ck1750 FIND v(dout1_480) AT=880.025n

.meas tran vdout1_481ck1750 FIND v(dout1_481) AT=880.025n

.meas tran vdout1_482ck1750 FIND v(dout1_482) AT=880.025n

.meas tran vdout1_483ck1750 FIND v(dout1_483) AT=880.025n

.meas tran vdout1_484ck1750 FIND v(dout1_484) AT=880.025n

.meas tran vdout1_485ck1750 FIND v(dout1_485) AT=880.025n

.meas tran vdout1_486ck1750 FIND v(dout1_486) AT=880.025n

.meas tran vdout1_487ck1750 FIND v(dout1_487) AT=880.025n

.meas tran vdout1_488ck1750 FIND v(dout1_488) AT=880.025n

.meas tran vdout1_489ck1750 FIND v(dout1_489) AT=880.025n

.meas tran vdout1_490ck1750 FIND v(dout1_490) AT=880.025n

.meas tran vdout1_491ck1750 FIND v(dout1_491) AT=880.025n

.meas tran vdout1_492ck1750 FIND v(dout1_492) AT=880.025n

.meas tran vdout1_493ck1750 FIND v(dout1_493) AT=880.025n

.meas tran vdout1_494ck1750 FIND v(dout1_494) AT=880.025n

.meas tran vdout1_495ck1750 FIND v(dout1_495) AT=880.025n

.meas tran vdout1_496ck1750 FIND v(dout1_496) AT=880.025n

.meas tran vdout1_497ck1750 FIND v(dout1_497) AT=880.025n

.meas tran vdout1_498ck1750 FIND v(dout1_498) AT=880.025n

.meas tran vdout1_499ck1750 FIND v(dout1_499) AT=880.025n

.meas tran vdout1_500ck1750 FIND v(dout1_500) AT=880.025n

.meas tran vdout1_501ck1750 FIND v(dout1_501) AT=880.025n

.meas tran vdout1_502ck1750 FIND v(dout1_502) AT=880.025n

.meas tran vdout1_503ck1750 FIND v(dout1_503) AT=880.025n

.meas tran vdout1_504ck1750 FIND v(dout1_504) AT=880.025n

.meas tran vdout1_505ck1750 FIND v(dout1_505) AT=880.025n

.meas tran vdout1_506ck1750 FIND v(dout1_506) AT=880.025n

.meas tran vdout1_507ck1750 FIND v(dout1_507) AT=880.025n

.meas tran vdout1_508ck1750 FIND v(dout1_508) AT=880.025n

.meas tran vdout1_509ck1750 FIND v(dout1_509) AT=880.025n

.meas tran vdout1_510ck1750 FIND v(dout1_510) AT=880.025n

.meas tran vdout1_511ck1750 FIND v(dout1_511) AT=880.025n

.meas tran vdout1_0ck1800 FIND v(dout1_0) AT=905.025n

.meas tran vdout1_1ck1800 FIND v(dout1_1) AT=905.025n

.meas tran vdout1_2ck1800 FIND v(dout1_2) AT=905.025n

.meas tran vdout1_3ck1800 FIND v(dout1_3) AT=905.025n

.meas tran vdout1_4ck1800 FIND v(dout1_4) AT=905.025n

.meas tran vdout1_5ck1800 FIND v(dout1_5) AT=905.025n

.meas tran vdout1_6ck1800 FIND v(dout1_6) AT=905.025n

.meas tran vdout1_7ck1800 FIND v(dout1_7) AT=905.025n

.meas tran vdout1_8ck1800 FIND v(dout1_8) AT=905.025n

.meas tran vdout1_9ck1800 FIND v(dout1_9) AT=905.025n

.meas tran vdout1_10ck1800 FIND v(dout1_10) AT=905.025n

.meas tran vdout1_11ck1800 FIND v(dout1_11) AT=905.025n

.meas tran vdout1_12ck1800 FIND v(dout1_12) AT=905.025n

.meas tran vdout1_13ck1800 FIND v(dout1_13) AT=905.025n

.meas tran vdout1_14ck1800 FIND v(dout1_14) AT=905.025n

.meas tran vdout1_15ck1800 FIND v(dout1_15) AT=905.025n

.meas tran vdout1_16ck1800 FIND v(dout1_16) AT=905.025n

.meas tran vdout1_17ck1800 FIND v(dout1_17) AT=905.025n

.meas tran vdout1_18ck1800 FIND v(dout1_18) AT=905.025n

.meas tran vdout1_19ck1800 FIND v(dout1_19) AT=905.025n

.meas tran vdout1_20ck1800 FIND v(dout1_20) AT=905.025n

.meas tran vdout1_21ck1800 FIND v(dout1_21) AT=905.025n

.meas tran vdout1_22ck1800 FIND v(dout1_22) AT=905.025n

.meas tran vdout1_23ck1800 FIND v(dout1_23) AT=905.025n

.meas tran vdout1_24ck1800 FIND v(dout1_24) AT=905.025n

.meas tran vdout1_25ck1800 FIND v(dout1_25) AT=905.025n

.meas tran vdout1_26ck1800 FIND v(dout1_26) AT=905.025n

.meas tran vdout1_27ck1800 FIND v(dout1_27) AT=905.025n

.meas tran vdout1_28ck1800 FIND v(dout1_28) AT=905.025n

.meas tran vdout1_29ck1800 FIND v(dout1_29) AT=905.025n

.meas tran vdout1_30ck1800 FIND v(dout1_30) AT=905.025n

.meas tran vdout1_31ck1800 FIND v(dout1_31) AT=905.025n

.meas tran vdout1_32ck1800 FIND v(dout1_32) AT=905.025n

.meas tran vdout1_33ck1800 FIND v(dout1_33) AT=905.025n

.meas tran vdout1_34ck1800 FIND v(dout1_34) AT=905.025n

.meas tran vdout1_35ck1800 FIND v(dout1_35) AT=905.025n

.meas tran vdout1_36ck1800 FIND v(dout1_36) AT=905.025n

.meas tran vdout1_37ck1800 FIND v(dout1_37) AT=905.025n

.meas tran vdout1_38ck1800 FIND v(dout1_38) AT=905.025n

.meas tran vdout1_39ck1800 FIND v(dout1_39) AT=905.025n

.meas tran vdout1_40ck1800 FIND v(dout1_40) AT=905.025n

.meas tran vdout1_41ck1800 FIND v(dout1_41) AT=905.025n

.meas tran vdout1_42ck1800 FIND v(dout1_42) AT=905.025n

.meas tran vdout1_43ck1800 FIND v(dout1_43) AT=905.025n

.meas tran vdout1_44ck1800 FIND v(dout1_44) AT=905.025n

.meas tran vdout1_45ck1800 FIND v(dout1_45) AT=905.025n

.meas tran vdout1_46ck1800 FIND v(dout1_46) AT=905.025n

.meas tran vdout1_47ck1800 FIND v(dout1_47) AT=905.025n

.meas tran vdout1_48ck1800 FIND v(dout1_48) AT=905.025n

.meas tran vdout1_49ck1800 FIND v(dout1_49) AT=905.025n

.meas tran vdout1_50ck1800 FIND v(dout1_50) AT=905.025n

.meas tran vdout1_51ck1800 FIND v(dout1_51) AT=905.025n

.meas tran vdout1_52ck1800 FIND v(dout1_52) AT=905.025n

.meas tran vdout1_53ck1800 FIND v(dout1_53) AT=905.025n

.meas tran vdout1_54ck1800 FIND v(dout1_54) AT=905.025n

.meas tran vdout1_55ck1800 FIND v(dout1_55) AT=905.025n

.meas tran vdout1_56ck1800 FIND v(dout1_56) AT=905.025n

.meas tran vdout1_57ck1800 FIND v(dout1_57) AT=905.025n

.meas tran vdout1_58ck1800 FIND v(dout1_58) AT=905.025n

.meas tran vdout1_59ck1800 FIND v(dout1_59) AT=905.025n

.meas tran vdout1_60ck1800 FIND v(dout1_60) AT=905.025n

.meas tran vdout1_61ck1800 FIND v(dout1_61) AT=905.025n

.meas tran vdout1_62ck1800 FIND v(dout1_62) AT=905.025n

.meas tran vdout1_63ck1800 FIND v(dout1_63) AT=905.025n

.meas tran vdout1_64ck1800 FIND v(dout1_64) AT=905.025n

.meas tran vdout1_65ck1800 FIND v(dout1_65) AT=905.025n

.meas tran vdout1_66ck1800 FIND v(dout1_66) AT=905.025n

.meas tran vdout1_67ck1800 FIND v(dout1_67) AT=905.025n

.meas tran vdout1_68ck1800 FIND v(dout1_68) AT=905.025n

.meas tran vdout1_69ck1800 FIND v(dout1_69) AT=905.025n

.meas tran vdout1_70ck1800 FIND v(dout1_70) AT=905.025n

.meas tran vdout1_71ck1800 FIND v(dout1_71) AT=905.025n

.meas tran vdout1_72ck1800 FIND v(dout1_72) AT=905.025n

.meas tran vdout1_73ck1800 FIND v(dout1_73) AT=905.025n

.meas tran vdout1_74ck1800 FIND v(dout1_74) AT=905.025n

.meas tran vdout1_75ck1800 FIND v(dout1_75) AT=905.025n

.meas tran vdout1_76ck1800 FIND v(dout1_76) AT=905.025n

.meas tran vdout1_77ck1800 FIND v(dout1_77) AT=905.025n

.meas tran vdout1_78ck1800 FIND v(dout1_78) AT=905.025n

.meas tran vdout1_79ck1800 FIND v(dout1_79) AT=905.025n

.meas tran vdout1_80ck1800 FIND v(dout1_80) AT=905.025n

.meas tran vdout1_81ck1800 FIND v(dout1_81) AT=905.025n

.meas tran vdout1_82ck1800 FIND v(dout1_82) AT=905.025n

.meas tran vdout1_83ck1800 FIND v(dout1_83) AT=905.025n

.meas tran vdout1_84ck1800 FIND v(dout1_84) AT=905.025n

.meas tran vdout1_85ck1800 FIND v(dout1_85) AT=905.025n

.meas tran vdout1_86ck1800 FIND v(dout1_86) AT=905.025n

.meas tran vdout1_87ck1800 FIND v(dout1_87) AT=905.025n

.meas tran vdout1_88ck1800 FIND v(dout1_88) AT=905.025n

.meas tran vdout1_89ck1800 FIND v(dout1_89) AT=905.025n

.meas tran vdout1_90ck1800 FIND v(dout1_90) AT=905.025n

.meas tran vdout1_91ck1800 FIND v(dout1_91) AT=905.025n

.meas tran vdout1_92ck1800 FIND v(dout1_92) AT=905.025n

.meas tran vdout1_93ck1800 FIND v(dout1_93) AT=905.025n

.meas tran vdout1_94ck1800 FIND v(dout1_94) AT=905.025n

.meas tran vdout1_95ck1800 FIND v(dout1_95) AT=905.025n

.meas tran vdout1_96ck1800 FIND v(dout1_96) AT=905.025n

.meas tran vdout1_97ck1800 FIND v(dout1_97) AT=905.025n

.meas tran vdout1_98ck1800 FIND v(dout1_98) AT=905.025n

.meas tran vdout1_99ck1800 FIND v(dout1_99) AT=905.025n

.meas tran vdout1_100ck1800 FIND v(dout1_100) AT=905.025n

.meas tran vdout1_101ck1800 FIND v(dout1_101) AT=905.025n

.meas tran vdout1_102ck1800 FIND v(dout1_102) AT=905.025n

.meas tran vdout1_103ck1800 FIND v(dout1_103) AT=905.025n

.meas tran vdout1_104ck1800 FIND v(dout1_104) AT=905.025n

.meas tran vdout1_105ck1800 FIND v(dout1_105) AT=905.025n

.meas tran vdout1_106ck1800 FIND v(dout1_106) AT=905.025n

.meas tran vdout1_107ck1800 FIND v(dout1_107) AT=905.025n

.meas tran vdout1_108ck1800 FIND v(dout1_108) AT=905.025n

.meas tran vdout1_109ck1800 FIND v(dout1_109) AT=905.025n

.meas tran vdout1_110ck1800 FIND v(dout1_110) AT=905.025n

.meas tran vdout1_111ck1800 FIND v(dout1_111) AT=905.025n

.meas tran vdout1_112ck1800 FIND v(dout1_112) AT=905.025n

.meas tran vdout1_113ck1800 FIND v(dout1_113) AT=905.025n

.meas tran vdout1_114ck1800 FIND v(dout1_114) AT=905.025n

.meas tran vdout1_115ck1800 FIND v(dout1_115) AT=905.025n

.meas tran vdout1_116ck1800 FIND v(dout1_116) AT=905.025n

.meas tran vdout1_117ck1800 FIND v(dout1_117) AT=905.025n

.meas tran vdout1_118ck1800 FIND v(dout1_118) AT=905.025n

.meas tran vdout1_119ck1800 FIND v(dout1_119) AT=905.025n

.meas tran vdout1_120ck1800 FIND v(dout1_120) AT=905.025n

.meas tran vdout1_121ck1800 FIND v(dout1_121) AT=905.025n

.meas tran vdout1_122ck1800 FIND v(dout1_122) AT=905.025n

.meas tran vdout1_123ck1800 FIND v(dout1_123) AT=905.025n

.meas tran vdout1_124ck1800 FIND v(dout1_124) AT=905.025n

.meas tran vdout1_125ck1800 FIND v(dout1_125) AT=905.025n

.meas tran vdout1_126ck1800 FIND v(dout1_126) AT=905.025n

.meas tran vdout1_127ck1800 FIND v(dout1_127) AT=905.025n

.meas tran vdout1_128ck1800 FIND v(dout1_128) AT=905.025n

.meas tran vdout1_129ck1800 FIND v(dout1_129) AT=905.025n

.meas tran vdout1_130ck1800 FIND v(dout1_130) AT=905.025n

.meas tran vdout1_131ck1800 FIND v(dout1_131) AT=905.025n

.meas tran vdout1_132ck1800 FIND v(dout1_132) AT=905.025n

.meas tran vdout1_133ck1800 FIND v(dout1_133) AT=905.025n

.meas tran vdout1_134ck1800 FIND v(dout1_134) AT=905.025n

.meas tran vdout1_135ck1800 FIND v(dout1_135) AT=905.025n

.meas tran vdout1_136ck1800 FIND v(dout1_136) AT=905.025n

.meas tran vdout1_137ck1800 FIND v(dout1_137) AT=905.025n

.meas tran vdout1_138ck1800 FIND v(dout1_138) AT=905.025n

.meas tran vdout1_139ck1800 FIND v(dout1_139) AT=905.025n

.meas tran vdout1_140ck1800 FIND v(dout1_140) AT=905.025n

.meas tran vdout1_141ck1800 FIND v(dout1_141) AT=905.025n

.meas tran vdout1_142ck1800 FIND v(dout1_142) AT=905.025n

.meas tran vdout1_143ck1800 FIND v(dout1_143) AT=905.025n

.meas tran vdout1_144ck1800 FIND v(dout1_144) AT=905.025n

.meas tran vdout1_145ck1800 FIND v(dout1_145) AT=905.025n

.meas tran vdout1_146ck1800 FIND v(dout1_146) AT=905.025n

.meas tran vdout1_147ck1800 FIND v(dout1_147) AT=905.025n

.meas tran vdout1_148ck1800 FIND v(dout1_148) AT=905.025n

.meas tran vdout1_149ck1800 FIND v(dout1_149) AT=905.025n

.meas tran vdout1_150ck1800 FIND v(dout1_150) AT=905.025n

.meas tran vdout1_151ck1800 FIND v(dout1_151) AT=905.025n

.meas tran vdout1_152ck1800 FIND v(dout1_152) AT=905.025n

.meas tran vdout1_153ck1800 FIND v(dout1_153) AT=905.025n

.meas tran vdout1_154ck1800 FIND v(dout1_154) AT=905.025n

.meas tran vdout1_155ck1800 FIND v(dout1_155) AT=905.025n

.meas tran vdout1_156ck1800 FIND v(dout1_156) AT=905.025n

.meas tran vdout1_157ck1800 FIND v(dout1_157) AT=905.025n

.meas tran vdout1_158ck1800 FIND v(dout1_158) AT=905.025n

.meas tran vdout1_159ck1800 FIND v(dout1_159) AT=905.025n

.meas tran vdout1_160ck1800 FIND v(dout1_160) AT=905.025n

.meas tran vdout1_161ck1800 FIND v(dout1_161) AT=905.025n

.meas tran vdout1_162ck1800 FIND v(dout1_162) AT=905.025n

.meas tran vdout1_163ck1800 FIND v(dout1_163) AT=905.025n

.meas tran vdout1_164ck1800 FIND v(dout1_164) AT=905.025n

.meas tran vdout1_165ck1800 FIND v(dout1_165) AT=905.025n

.meas tran vdout1_166ck1800 FIND v(dout1_166) AT=905.025n

.meas tran vdout1_167ck1800 FIND v(dout1_167) AT=905.025n

.meas tran vdout1_168ck1800 FIND v(dout1_168) AT=905.025n

.meas tran vdout1_169ck1800 FIND v(dout1_169) AT=905.025n

.meas tran vdout1_170ck1800 FIND v(dout1_170) AT=905.025n

.meas tran vdout1_171ck1800 FIND v(dout1_171) AT=905.025n

.meas tran vdout1_172ck1800 FIND v(dout1_172) AT=905.025n

.meas tran vdout1_173ck1800 FIND v(dout1_173) AT=905.025n

.meas tran vdout1_174ck1800 FIND v(dout1_174) AT=905.025n

.meas tran vdout1_175ck1800 FIND v(dout1_175) AT=905.025n

.meas tran vdout1_176ck1800 FIND v(dout1_176) AT=905.025n

.meas tran vdout1_177ck1800 FIND v(dout1_177) AT=905.025n

.meas tran vdout1_178ck1800 FIND v(dout1_178) AT=905.025n

.meas tran vdout1_179ck1800 FIND v(dout1_179) AT=905.025n

.meas tran vdout1_180ck1800 FIND v(dout1_180) AT=905.025n

.meas tran vdout1_181ck1800 FIND v(dout1_181) AT=905.025n

.meas tran vdout1_182ck1800 FIND v(dout1_182) AT=905.025n

.meas tran vdout1_183ck1800 FIND v(dout1_183) AT=905.025n

.meas tran vdout1_184ck1800 FIND v(dout1_184) AT=905.025n

.meas tran vdout1_185ck1800 FIND v(dout1_185) AT=905.025n

.meas tran vdout1_186ck1800 FIND v(dout1_186) AT=905.025n

.meas tran vdout1_187ck1800 FIND v(dout1_187) AT=905.025n

.meas tran vdout1_188ck1800 FIND v(dout1_188) AT=905.025n

.meas tran vdout1_189ck1800 FIND v(dout1_189) AT=905.025n

.meas tran vdout1_190ck1800 FIND v(dout1_190) AT=905.025n

.meas tran vdout1_191ck1800 FIND v(dout1_191) AT=905.025n

.meas tran vdout1_192ck1800 FIND v(dout1_192) AT=905.025n

.meas tran vdout1_193ck1800 FIND v(dout1_193) AT=905.025n

.meas tran vdout1_194ck1800 FIND v(dout1_194) AT=905.025n

.meas tran vdout1_195ck1800 FIND v(dout1_195) AT=905.025n

.meas tran vdout1_196ck1800 FIND v(dout1_196) AT=905.025n

.meas tran vdout1_197ck1800 FIND v(dout1_197) AT=905.025n

.meas tran vdout1_198ck1800 FIND v(dout1_198) AT=905.025n

.meas tran vdout1_199ck1800 FIND v(dout1_199) AT=905.025n

.meas tran vdout1_200ck1800 FIND v(dout1_200) AT=905.025n

.meas tran vdout1_201ck1800 FIND v(dout1_201) AT=905.025n

.meas tran vdout1_202ck1800 FIND v(dout1_202) AT=905.025n

.meas tran vdout1_203ck1800 FIND v(dout1_203) AT=905.025n

.meas tran vdout1_204ck1800 FIND v(dout1_204) AT=905.025n

.meas tran vdout1_205ck1800 FIND v(dout1_205) AT=905.025n

.meas tran vdout1_206ck1800 FIND v(dout1_206) AT=905.025n

.meas tran vdout1_207ck1800 FIND v(dout1_207) AT=905.025n

.meas tran vdout1_208ck1800 FIND v(dout1_208) AT=905.025n

.meas tran vdout1_209ck1800 FIND v(dout1_209) AT=905.025n

.meas tran vdout1_210ck1800 FIND v(dout1_210) AT=905.025n

.meas tran vdout1_211ck1800 FIND v(dout1_211) AT=905.025n

.meas tran vdout1_212ck1800 FIND v(dout1_212) AT=905.025n

.meas tran vdout1_213ck1800 FIND v(dout1_213) AT=905.025n

.meas tran vdout1_214ck1800 FIND v(dout1_214) AT=905.025n

.meas tran vdout1_215ck1800 FIND v(dout1_215) AT=905.025n

.meas tran vdout1_216ck1800 FIND v(dout1_216) AT=905.025n

.meas tran vdout1_217ck1800 FIND v(dout1_217) AT=905.025n

.meas tran vdout1_218ck1800 FIND v(dout1_218) AT=905.025n

.meas tran vdout1_219ck1800 FIND v(dout1_219) AT=905.025n

.meas tran vdout1_220ck1800 FIND v(dout1_220) AT=905.025n

.meas tran vdout1_221ck1800 FIND v(dout1_221) AT=905.025n

.meas tran vdout1_222ck1800 FIND v(dout1_222) AT=905.025n

.meas tran vdout1_223ck1800 FIND v(dout1_223) AT=905.025n

.meas tran vdout1_224ck1800 FIND v(dout1_224) AT=905.025n

.meas tran vdout1_225ck1800 FIND v(dout1_225) AT=905.025n

.meas tran vdout1_226ck1800 FIND v(dout1_226) AT=905.025n

.meas tran vdout1_227ck1800 FIND v(dout1_227) AT=905.025n

.meas tran vdout1_228ck1800 FIND v(dout1_228) AT=905.025n

.meas tran vdout1_229ck1800 FIND v(dout1_229) AT=905.025n

.meas tran vdout1_230ck1800 FIND v(dout1_230) AT=905.025n

.meas tran vdout1_231ck1800 FIND v(dout1_231) AT=905.025n

.meas tran vdout1_232ck1800 FIND v(dout1_232) AT=905.025n

.meas tran vdout1_233ck1800 FIND v(dout1_233) AT=905.025n

.meas tran vdout1_234ck1800 FIND v(dout1_234) AT=905.025n

.meas tran vdout1_235ck1800 FIND v(dout1_235) AT=905.025n

.meas tran vdout1_236ck1800 FIND v(dout1_236) AT=905.025n

.meas tran vdout1_237ck1800 FIND v(dout1_237) AT=905.025n

.meas tran vdout1_238ck1800 FIND v(dout1_238) AT=905.025n

.meas tran vdout1_239ck1800 FIND v(dout1_239) AT=905.025n

.meas tran vdout1_240ck1800 FIND v(dout1_240) AT=905.025n

.meas tran vdout1_241ck1800 FIND v(dout1_241) AT=905.025n

.meas tran vdout1_242ck1800 FIND v(dout1_242) AT=905.025n

.meas tran vdout1_243ck1800 FIND v(dout1_243) AT=905.025n

.meas tran vdout1_244ck1800 FIND v(dout1_244) AT=905.025n

.meas tran vdout1_245ck1800 FIND v(dout1_245) AT=905.025n

.meas tran vdout1_246ck1800 FIND v(dout1_246) AT=905.025n

.meas tran vdout1_247ck1800 FIND v(dout1_247) AT=905.025n

.meas tran vdout1_248ck1800 FIND v(dout1_248) AT=905.025n

.meas tran vdout1_249ck1800 FIND v(dout1_249) AT=905.025n

.meas tran vdout1_250ck1800 FIND v(dout1_250) AT=905.025n

.meas tran vdout1_251ck1800 FIND v(dout1_251) AT=905.025n

.meas tran vdout1_252ck1800 FIND v(dout1_252) AT=905.025n

.meas tran vdout1_253ck1800 FIND v(dout1_253) AT=905.025n

.meas tran vdout1_254ck1800 FIND v(dout1_254) AT=905.025n

.meas tran vdout1_255ck1800 FIND v(dout1_255) AT=905.025n

.meas tran vdout1_256ck1800 FIND v(dout1_256) AT=905.025n

.meas tran vdout1_257ck1800 FIND v(dout1_257) AT=905.025n

.meas tran vdout1_258ck1800 FIND v(dout1_258) AT=905.025n

.meas tran vdout1_259ck1800 FIND v(dout1_259) AT=905.025n

.meas tran vdout1_260ck1800 FIND v(dout1_260) AT=905.025n

.meas tran vdout1_261ck1800 FIND v(dout1_261) AT=905.025n

.meas tran vdout1_262ck1800 FIND v(dout1_262) AT=905.025n

.meas tran vdout1_263ck1800 FIND v(dout1_263) AT=905.025n

.meas tran vdout1_264ck1800 FIND v(dout1_264) AT=905.025n

.meas tran vdout1_265ck1800 FIND v(dout1_265) AT=905.025n

.meas tran vdout1_266ck1800 FIND v(dout1_266) AT=905.025n

.meas tran vdout1_267ck1800 FIND v(dout1_267) AT=905.025n

.meas tran vdout1_268ck1800 FIND v(dout1_268) AT=905.025n

.meas tran vdout1_269ck1800 FIND v(dout1_269) AT=905.025n

.meas tran vdout1_270ck1800 FIND v(dout1_270) AT=905.025n

.meas tran vdout1_271ck1800 FIND v(dout1_271) AT=905.025n

.meas tran vdout1_272ck1800 FIND v(dout1_272) AT=905.025n

.meas tran vdout1_273ck1800 FIND v(dout1_273) AT=905.025n

.meas tran vdout1_274ck1800 FIND v(dout1_274) AT=905.025n

.meas tran vdout1_275ck1800 FIND v(dout1_275) AT=905.025n

.meas tran vdout1_276ck1800 FIND v(dout1_276) AT=905.025n

.meas tran vdout1_277ck1800 FIND v(dout1_277) AT=905.025n

.meas tran vdout1_278ck1800 FIND v(dout1_278) AT=905.025n

.meas tran vdout1_279ck1800 FIND v(dout1_279) AT=905.025n

.meas tran vdout1_280ck1800 FIND v(dout1_280) AT=905.025n

.meas tran vdout1_281ck1800 FIND v(dout1_281) AT=905.025n

.meas tran vdout1_282ck1800 FIND v(dout1_282) AT=905.025n

.meas tran vdout1_283ck1800 FIND v(dout1_283) AT=905.025n

.meas tran vdout1_284ck1800 FIND v(dout1_284) AT=905.025n

.meas tran vdout1_285ck1800 FIND v(dout1_285) AT=905.025n

.meas tran vdout1_286ck1800 FIND v(dout1_286) AT=905.025n

.meas tran vdout1_287ck1800 FIND v(dout1_287) AT=905.025n

.meas tran vdout1_288ck1800 FIND v(dout1_288) AT=905.025n

.meas tran vdout1_289ck1800 FIND v(dout1_289) AT=905.025n

.meas tran vdout1_290ck1800 FIND v(dout1_290) AT=905.025n

.meas tran vdout1_291ck1800 FIND v(dout1_291) AT=905.025n

.meas tran vdout1_292ck1800 FIND v(dout1_292) AT=905.025n

.meas tran vdout1_293ck1800 FIND v(dout1_293) AT=905.025n

.meas tran vdout1_294ck1800 FIND v(dout1_294) AT=905.025n

.meas tran vdout1_295ck1800 FIND v(dout1_295) AT=905.025n

.meas tran vdout1_296ck1800 FIND v(dout1_296) AT=905.025n

.meas tran vdout1_297ck1800 FIND v(dout1_297) AT=905.025n

.meas tran vdout1_298ck1800 FIND v(dout1_298) AT=905.025n

.meas tran vdout1_299ck1800 FIND v(dout1_299) AT=905.025n

.meas tran vdout1_300ck1800 FIND v(dout1_300) AT=905.025n

.meas tran vdout1_301ck1800 FIND v(dout1_301) AT=905.025n

.meas tran vdout1_302ck1800 FIND v(dout1_302) AT=905.025n

.meas tran vdout1_303ck1800 FIND v(dout1_303) AT=905.025n

.meas tran vdout1_304ck1800 FIND v(dout1_304) AT=905.025n

.meas tran vdout1_305ck1800 FIND v(dout1_305) AT=905.025n

.meas tran vdout1_306ck1800 FIND v(dout1_306) AT=905.025n

.meas tran vdout1_307ck1800 FIND v(dout1_307) AT=905.025n

.meas tran vdout1_308ck1800 FIND v(dout1_308) AT=905.025n

.meas tran vdout1_309ck1800 FIND v(dout1_309) AT=905.025n

.meas tran vdout1_310ck1800 FIND v(dout1_310) AT=905.025n

.meas tran vdout1_311ck1800 FIND v(dout1_311) AT=905.025n

.meas tran vdout1_312ck1800 FIND v(dout1_312) AT=905.025n

.meas tran vdout1_313ck1800 FIND v(dout1_313) AT=905.025n

.meas tran vdout1_314ck1800 FIND v(dout1_314) AT=905.025n

.meas tran vdout1_315ck1800 FIND v(dout1_315) AT=905.025n

.meas tran vdout1_316ck1800 FIND v(dout1_316) AT=905.025n

.meas tran vdout1_317ck1800 FIND v(dout1_317) AT=905.025n

.meas tran vdout1_318ck1800 FIND v(dout1_318) AT=905.025n

.meas tran vdout1_319ck1800 FIND v(dout1_319) AT=905.025n

.meas tran vdout1_320ck1800 FIND v(dout1_320) AT=905.025n

.meas tran vdout1_321ck1800 FIND v(dout1_321) AT=905.025n

.meas tran vdout1_322ck1800 FIND v(dout1_322) AT=905.025n

.meas tran vdout1_323ck1800 FIND v(dout1_323) AT=905.025n

.meas tran vdout1_324ck1800 FIND v(dout1_324) AT=905.025n

.meas tran vdout1_325ck1800 FIND v(dout1_325) AT=905.025n

.meas tran vdout1_326ck1800 FIND v(dout1_326) AT=905.025n

.meas tran vdout1_327ck1800 FIND v(dout1_327) AT=905.025n

.meas tran vdout1_328ck1800 FIND v(dout1_328) AT=905.025n

.meas tran vdout1_329ck1800 FIND v(dout1_329) AT=905.025n

.meas tran vdout1_330ck1800 FIND v(dout1_330) AT=905.025n

.meas tran vdout1_331ck1800 FIND v(dout1_331) AT=905.025n

.meas tran vdout1_332ck1800 FIND v(dout1_332) AT=905.025n

.meas tran vdout1_333ck1800 FIND v(dout1_333) AT=905.025n

.meas tran vdout1_334ck1800 FIND v(dout1_334) AT=905.025n

.meas tran vdout1_335ck1800 FIND v(dout1_335) AT=905.025n

.meas tran vdout1_336ck1800 FIND v(dout1_336) AT=905.025n

.meas tran vdout1_337ck1800 FIND v(dout1_337) AT=905.025n

.meas tran vdout1_338ck1800 FIND v(dout1_338) AT=905.025n

.meas tran vdout1_339ck1800 FIND v(dout1_339) AT=905.025n

.meas tran vdout1_340ck1800 FIND v(dout1_340) AT=905.025n

.meas tran vdout1_341ck1800 FIND v(dout1_341) AT=905.025n

.meas tran vdout1_342ck1800 FIND v(dout1_342) AT=905.025n

.meas tran vdout1_343ck1800 FIND v(dout1_343) AT=905.025n

.meas tran vdout1_344ck1800 FIND v(dout1_344) AT=905.025n

.meas tran vdout1_345ck1800 FIND v(dout1_345) AT=905.025n

.meas tran vdout1_346ck1800 FIND v(dout1_346) AT=905.025n

.meas tran vdout1_347ck1800 FIND v(dout1_347) AT=905.025n

.meas tran vdout1_348ck1800 FIND v(dout1_348) AT=905.025n

.meas tran vdout1_349ck1800 FIND v(dout1_349) AT=905.025n

.meas tran vdout1_350ck1800 FIND v(dout1_350) AT=905.025n

.meas tran vdout1_351ck1800 FIND v(dout1_351) AT=905.025n

.meas tran vdout1_352ck1800 FIND v(dout1_352) AT=905.025n

.meas tran vdout1_353ck1800 FIND v(dout1_353) AT=905.025n

.meas tran vdout1_354ck1800 FIND v(dout1_354) AT=905.025n

.meas tran vdout1_355ck1800 FIND v(dout1_355) AT=905.025n

.meas tran vdout1_356ck1800 FIND v(dout1_356) AT=905.025n

.meas tran vdout1_357ck1800 FIND v(dout1_357) AT=905.025n

.meas tran vdout1_358ck1800 FIND v(dout1_358) AT=905.025n

.meas tran vdout1_359ck1800 FIND v(dout1_359) AT=905.025n

.meas tran vdout1_360ck1800 FIND v(dout1_360) AT=905.025n

.meas tran vdout1_361ck1800 FIND v(dout1_361) AT=905.025n

.meas tran vdout1_362ck1800 FIND v(dout1_362) AT=905.025n

.meas tran vdout1_363ck1800 FIND v(dout1_363) AT=905.025n

.meas tran vdout1_364ck1800 FIND v(dout1_364) AT=905.025n

.meas tran vdout1_365ck1800 FIND v(dout1_365) AT=905.025n

.meas tran vdout1_366ck1800 FIND v(dout1_366) AT=905.025n

.meas tran vdout1_367ck1800 FIND v(dout1_367) AT=905.025n

.meas tran vdout1_368ck1800 FIND v(dout1_368) AT=905.025n

.meas tran vdout1_369ck1800 FIND v(dout1_369) AT=905.025n

.meas tran vdout1_370ck1800 FIND v(dout1_370) AT=905.025n

.meas tran vdout1_371ck1800 FIND v(dout1_371) AT=905.025n

.meas tran vdout1_372ck1800 FIND v(dout1_372) AT=905.025n

.meas tran vdout1_373ck1800 FIND v(dout1_373) AT=905.025n

.meas tran vdout1_374ck1800 FIND v(dout1_374) AT=905.025n

.meas tran vdout1_375ck1800 FIND v(dout1_375) AT=905.025n

.meas tran vdout1_376ck1800 FIND v(dout1_376) AT=905.025n

.meas tran vdout1_377ck1800 FIND v(dout1_377) AT=905.025n

.meas tran vdout1_378ck1800 FIND v(dout1_378) AT=905.025n

.meas tran vdout1_379ck1800 FIND v(dout1_379) AT=905.025n

.meas tran vdout1_380ck1800 FIND v(dout1_380) AT=905.025n

.meas tran vdout1_381ck1800 FIND v(dout1_381) AT=905.025n

.meas tran vdout1_382ck1800 FIND v(dout1_382) AT=905.025n

.meas tran vdout1_383ck1800 FIND v(dout1_383) AT=905.025n

.meas tran vdout1_384ck1800 FIND v(dout1_384) AT=905.025n

.meas tran vdout1_385ck1800 FIND v(dout1_385) AT=905.025n

.meas tran vdout1_386ck1800 FIND v(dout1_386) AT=905.025n

.meas tran vdout1_387ck1800 FIND v(dout1_387) AT=905.025n

.meas tran vdout1_388ck1800 FIND v(dout1_388) AT=905.025n

.meas tran vdout1_389ck1800 FIND v(dout1_389) AT=905.025n

.meas tran vdout1_390ck1800 FIND v(dout1_390) AT=905.025n

.meas tran vdout1_391ck1800 FIND v(dout1_391) AT=905.025n

.meas tran vdout1_392ck1800 FIND v(dout1_392) AT=905.025n

.meas tran vdout1_393ck1800 FIND v(dout1_393) AT=905.025n

.meas tran vdout1_394ck1800 FIND v(dout1_394) AT=905.025n

.meas tran vdout1_395ck1800 FIND v(dout1_395) AT=905.025n

.meas tran vdout1_396ck1800 FIND v(dout1_396) AT=905.025n

.meas tran vdout1_397ck1800 FIND v(dout1_397) AT=905.025n

.meas tran vdout1_398ck1800 FIND v(dout1_398) AT=905.025n

.meas tran vdout1_399ck1800 FIND v(dout1_399) AT=905.025n

.meas tran vdout1_400ck1800 FIND v(dout1_400) AT=905.025n

.meas tran vdout1_401ck1800 FIND v(dout1_401) AT=905.025n

.meas tran vdout1_402ck1800 FIND v(dout1_402) AT=905.025n

.meas tran vdout1_403ck1800 FIND v(dout1_403) AT=905.025n

.meas tran vdout1_404ck1800 FIND v(dout1_404) AT=905.025n

.meas tran vdout1_405ck1800 FIND v(dout1_405) AT=905.025n

.meas tran vdout1_406ck1800 FIND v(dout1_406) AT=905.025n

.meas tran vdout1_407ck1800 FIND v(dout1_407) AT=905.025n

.meas tran vdout1_408ck1800 FIND v(dout1_408) AT=905.025n

.meas tran vdout1_409ck1800 FIND v(dout1_409) AT=905.025n

.meas tran vdout1_410ck1800 FIND v(dout1_410) AT=905.025n

.meas tran vdout1_411ck1800 FIND v(dout1_411) AT=905.025n

.meas tran vdout1_412ck1800 FIND v(dout1_412) AT=905.025n

.meas tran vdout1_413ck1800 FIND v(dout1_413) AT=905.025n

.meas tran vdout1_414ck1800 FIND v(dout1_414) AT=905.025n

.meas tran vdout1_415ck1800 FIND v(dout1_415) AT=905.025n

.meas tran vdout1_416ck1800 FIND v(dout1_416) AT=905.025n

.meas tran vdout1_417ck1800 FIND v(dout1_417) AT=905.025n

.meas tran vdout1_418ck1800 FIND v(dout1_418) AT=905.025n

.meas tran vdout1_419ck1800 FIND v(dout1_419) AT=905.025n

.meas tran vdout1_420ck1800 FIND v(dout1_420) AT=905.025n

.meas tran vdout1_421ck1800 FIND v(dout1_421) AT=905.025n

.meas tran vdout1_422ck1800 FIND v(dout1_422) AT=905.025n

.meas tran vdout1_423ck1800 FIND v(dout1_423) AT=905.025n

.meas tran vdout1_424ck1800 FIND v(dout1_424) AT=905.025n

.meas tran vdout1_425ck1800 FIND v(dout1_425) AT=905.025n

.meas tran vdout1_426ck1800 FIND v(dout1_426) AT=905.025n

.meas tran vdout1_427ck1800 FIND v(dout1_427) AT=905.025n

.meas tran vdout1_428ck1800 FIND v(dout1_428) AT=905.025n

.meas tran vdout1_429ck1800 FIND v(dout1_429) AT=905.025n

.meas tran vdout1_430ck1800 FIND v(dout1_430) AT=905.025n

.meas tran vdout1_431ck1800 FIND v(dout1_431) AT=905.025n

.meas tran vdout1_432ck1800 FIND v(dout1_432) AT=905.025n

.meas tran vdout1_433ck1800 FIND v(dout1_433) AT=905.025n

.meas tran vdout1_434ck1800 FIND v(dout1_434) AT=905.025n

.meas tran vdout1_435ck1800 FIND v(dout1_435) AT=905.025n

.meas tran vdout1_436ck1800 FIND v(dout1_436) AT=905.025n

.meas tran vdout1_437ck1800 FIND v(dout1_437) AT=905.025n

.meas tran vdout1_438ck1800 FIND v(dout1_438) AT=905.025n

.meas tran vdout1_439ck1800 FIND v(dout1_439) AT=905.025n

.meas tran vdout1_440ck1800 FIND v(dout1_440) AT=905.025n

.meas tran vdout1_441ck1800 FIND v(dout1_441) AT=905.025n

.meas tran vdout1_442ck1800 FIND v(dout1_442) AT=905.025n

.meas tran vdout1_443ck1800 FIND v(dout1_443) AT=905.025n

.meas tran vdout1_444ck1800 FIND v(dout1_444) AT=905.025n

.meas tran vdout1_445ck1800 FIND v(dout1_445) AT=905.025n

.meas tran vdout1_446ck1800 FIND v(dout1_446) AT=905.025n

.meas tran vdout1_447ck1800 FIND v(dout1_447) AT=905.025n

.meas tran vdout1_448ck1800 FIND v(dout1_448) AT=905.025n

.meas tran vdout1_449ck1800 FIND v(dout1_449) AT=905.025n

.meas tran vdout1_450ck1800 FIND v(dout1_450) AT=905.025n

.meas tran vdout1_451ck1800 FIND v(dout1_451) AT=905.025n

.meas tran vdout1_452ck1800 FIND v(dout1_452) AT=905.025n

.meas tran vdout1_453ck1800 FIND v(dout1_453) AT=905.025n

.meas tran vdout1_454ck1800 FIND v(dout1_454) AT=905.025n

.meas tran vdout1_455ck1800 FIND v(dout1_455) AT=905.025n

.meas tran vdout1_456ck1800 FIND v(dout1_456) AT=905.025n

.meas tran vdout1_457ck1800 FIND v(dout1_457) AT=905.025n

.meas tran vdout1_458ck1800 FIND v(dout1_458) AT=905.025n

.meas tran vdout1_459ck1800 FIND v(dout1_459) AT=905.025n

.meas tran vdout1_460ck1800 FIND v(dout1_460) AT=905.025n

.meas tran vdout1_461ck1800 FIND v(dout1_461) AT=905.025n

.meas tran vdout1_462ck1800 FIND v(dout1_462) AT=905.025n

.meas tran vdout1_463ck1800 FIND v(dout1_463) AT=905.025n

.meas tran vdout1_464ck1800 FIND v(dout1_464) AT=905.025n

.meas tran vdout1_465ck1800 FIND v(dout1_465) AT=905.025n

.meas tran vdout1_466ck1800 FIND v(dout1_466) AT=905.025n

.meas tran vdout1_467ck1800 FIND v(dout1_467) AT=905.025n

.meas tran vdout1_468ck1800 FIND v(dout1_468) AT=905.025n

.meas tran vdout1_469ck1800 FIND v(dout1_469) AT=905.025n

.meas tran vdout1_470ck1800 FIND v(dout1_470) AT=905.025n

.meas tran vdout1_471ck1800 FIND v(dout1_471) AT=905.025n

.meas tran vdout1_472ck1800 FIND v(dout1_472) AT=905.025n

.meas tran vdout1_473ck1800 FIND v(dout1_473) AT=905.025n

.meas tran vdout1_474ck1800 FIND v(dout1_474) AT=905.025n

.meas tran vdout1_475ck1800 FIND v(dout1_475) AT=905.025n

.meas tran vdout1_476ck1800 FIND v(dout1_476) AT=905.025n

.meas tran vdout1_477ck1800 FIND v(dout1_477) AT=905.025n

.meas tran vdout1_478ck1800 FIND v(dout1_478) AT=905.025n

.meas tran vdout1_479ck1800 FIND v(dout1_479) AT=905.025n

.meas tran vdout1_480ck1800 FIND v(dout1_480) AT=905.025n

.meas tran vdout1_481ck1800 FIND v(dout1_481) AT=905.025n

.meas tran vdout1_482ck1800 FIND v(dout1_482) AT=905.025n

.meas tran vdout1_483ck1800 FIND v(dout1_483) AT=905.025n

.meas tran vdout1_484ck1800 FIND v(dout1_484) AT=905.025n

.meas tran vdout1_485ck1800 FIND v(dout1_485) AT=905.025n

.meas tran vdout1_486ck1800 FIND v(dout1_486) AT=905.025n

.meas tran vdout1_487ck1800 FIND v(dout1_487) AT=905.025n

.meas tran vdout1_488ck1800 FIND v(dout1_488) AT=905.025n

.meas tran vdout1_489ck1800 FIND v(dout1_489) AT=905.025n

.meas tran vdout1_490ck1800 FIND v(dout1_490) AT=905.025n

.meas tran vdout1_491ck1800 FIND v(dout1_491) AT=905.025n

.meas tran vdout1_492ck1800 FIND v(dout1_492) AT=905.025n

.meas tran vdout1_493ck1800 FIND v(dout1_493) AT=905.025n

.meas tran vdout1_494ck1800 FIND v(dout1_494) AT=905.025n

.meas tran vdout1_495ck1800 FIND v(dout1_495) AT=905.025n

.meas tran vdout1_496ck1800 FIND v(dout1_496) AT=905.025n

.meas tran vdout1_497ck1800 FIND v(dout1_497) AT=905.025n

.meas tran vdout1_498ck1800 FIND v(dout1_498) AT=905.025n

.meas tran vdout1_499ck1800 FIND v(dout1_499) AT=905.025n

.meas tran vdout1_500ck1800 FIND v(dout1_500) AT=905.025n

.meas tran vdout1_501ck1800 FIND v(dout1_501) AT=905.025n

.meas tran vdout1_502ck1800 FIND v(dout1_502) AT=905.025n

.meas tran vdout1_503ck1800 FIND v(dout1_503) AT=905.025n

.meas tran vdout1_504ck1800 FIND v(dout1_504) AT=905.025n

.meas tran vdout1_505ck1800 FIND v(dout1_505) AT=905.025n

.meas tran vdout1_506ck1800 FIND v(dout1_506) AT=905.025n

.meas tran vdout1_507ck1800 FIND v(dout1_507) AT=905.025n

.meas tran vdout1_508ck1800 FIND v(dout1_508) AT=905.025n

.meas tran vdout1_509ck1800 FIND v(dout1_509) AT=905.025n

.meas tran vdout1_510ck1800 FIND v(dout1_510) AT=905.025n

.meas tran vdout1_511ck1800 FIND v(dout1_511) AT=905.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_17ck1810 FIND v(dout1_17) AT=910.025n

.meas tran vdout1_18ck1810 FIND v(dout1_18) AT=910.025n

.meas tran vdout1_19ck1810 FIND v(dout1_19) AT=910.025n

.meas tran vdout1_20ck1810 FIND v(dout1_20) AT=910.025n

.meas tran vdout1_21ck1810 FIND v(dout1_21) AT=910.025n

.meas tran vdout1_22ck1810 FIND v(dout1_22) AT=910.025n

.meas tran vdout1_23ck1810 FIND v(dout1_23) AT=910.025n

.meas tran vdout1_24ck1810 FIND v(dout1_24) AT=910.025n

.meas tran vdout1_25ck1810 FIND v(dout1_25) AT=910.025n

.meas tran vdout1_26ck1810 FIND v(dout1_26) AT=910.025n

.meas tran vdout1_27ck1810 FIND v(dout1_27) AT=910.025n

.meas tran vdout1_28ck1810 FIND v(dout1_28) AT=910.025n

.meas tran vdout1_29ck1810 FIND v(dout1_29) AT=910.025n

.meas tran vdout1_30ck1810 FIND v(dout1_30) AT=910.025n

.meas tran vdout1_31ck1810 FIND v(dout1_31) AT=910.025n

.meas tran vdout1_32ck1810 FIND v(dout1_32) AT=910.025n

.meas tran vdout1_33ck1810 FIND v(dout1_33) AT=910.025n

.meas tran vdout1_34ck1810 FIND v(dout1_34) AT=910.025n

.meas tran vdout1_35ck1810 FIND v(dout1_35) AT=910.025n

.meas tran vdout1_36ck1810 FIND v(dout1_36) AT=910.025n

.meas tran vdout1_37ck1810 FIND v(dout1_37) AT=910.025n

.meas tran vdout1_38ck1810 FIND v(dout1_38) AT=910.025n

.meas tran vdout1_39ck1810 FIND v(dout1_39) AT=910.025n

.meas tran vdout1_40ck1810 FIND v(dout1_40) AT=910.025n

.meas tran vdout1_41ck1810 FIND v(dout1_41) AT=910.025n

.meas tran vdout1_42ck1810 FIND v(dout1_42) AT=910.025n

.meas tran vdout1_43ck1810 FIND v(dout1_43) AT=910.025n

.meas tran vdout1_44ck1810 FIND v(dout1_44) AT=910.025n

.meas tran vdout1_45ck1810 FIND v(dout1_45) AT=910.025n

.meas tran vdout1_46ck1810 FIND v(dout1_46) AT=910.025n

.meas tran vdout1_47ck1810 FIND v(dout1_47) AT=910.025n

.meas tran vdout1_48ck1810 FIND v(dout1_48) AT=910.025n

.meas tran vdout1_49ck1810 FIND v(dout1_49) AT=910.025n

.meas tran vdout1_50ck1810 FIND v(dout1_50) AT=910.025n

.meas tran vdout1_51ck1810 FIND v(dout1_51) AT=910.025n

.meas tran vdout1_52ck1810 FIND v(dout1_52) AT=910.025n

.meas tran vdout1_53ck1810 FIND v(dout1_53) AT=910.025n

.meas tran vdout1_54ck1810 FIND v(dout1_54) AT=910.025n

.meas tran vdout1_55ck1810 FIND v(dout1_55) AT=910.025n

.meas tran vdout1_56ck1810 FIND v(dout1_56) AT=910.025n

.meas tran vdout1_57ck1810 FIND v(dout1_57) AT=910.025n

.meas tran vdout1_58ck1810 FIND v(dout1_58) AT=910.025n

.meas tran vdout1_59ck1810 FIND v(dout1_59) AT=910.025n

.meas tran vdout1_60ck1810 FIND v(dout1_60) AT=910.025n

.meas tran vdout1_61ck1810 FIND v(dout1_61) AT=910.025n

.meas tran vdout1_62ck1810 FIND v(dout1_62) AT=910.025n

.meas tran vdout1_63ck1810 FIND v(dout1_63) AT=910.025n

.meas tran vdout1_64ck1810 FIND v(dout1_64) AT=910.025n

.meas tran vdout1_65ck1810 FIND v(dout1_65) AT=910.025n

.meas tran vdout1_66ck1810 FIND v(dout1_66) AT=910.025n

.meas tran vdout1_67ck1810 FIND v(dout1_67) AT=910.025n

.meas tran vdout1_68ck1810 FIND v(dout1_68) AT=910.025n

.meas tran vdout1_69ck1810 FIND v(dout1_69) AT=910.025n

.meas tran vdout1_70ck1810 FIND v(dout1_70) AT=910.025n

.meas tran vdout1_71ck1810 FIND v(dout1_71) AT=910.025n

.meas tran vdout1_72ck1810 FIND v(dout1_72) AT=910.025n

.meas tran vdout1_73ck1810 FIND v(dout1_73) AT=910.025n

.meas tran vdout1_74ck1810 FIND v(dout1_74) AT=910.025n

.meas tran vdout1_75ck1810 FIND v(dout1_75) AT=910.025n

.meas tran vdout1_76ck1810 FIND v(dout1_76) AT=910.025n

.meas tran vdout1_77ck1810 FIND v(dout1_77) AT=910.025n

.meas tran vdout1_78ck1810 FIND v(dout1_78) AT=910.025n

.meas tran vdout1_79ck1810 FIND v(dout1_79) AT=910.025n

.meas tran vdout1_80ck1810 FIND v(dout1_80) AT=910.025n

.meas tran vdout1_81ck1810 FIND v(dout1_81) AT=910.025n

.meas tran vdout1_82ck1810 FIND v(dout1_82) AT=910.025n

.meas tran vdout1_83ck1810 FIND v(dout1_83) AT=910.025n

.meas tran vdout1_84ck1810 FIND v(dout1_84) AT=910.025n

.meas tran vdout1_85ck1810 FIND v(dout1_85) AT=910.025n

.meas tran vdout1_86ck1810 FIND v(dout1_86) AT=910.025n

.meas tran vdout1_87ck1810 FIND v(dout1_87) AT=910.025n

.meas tran vdout1_88ck1810 FIND v(dout1_88) AT=910.025n

.meas tran vdout1_89ck1810 FIND v(dout1_89) AT=910.025n

.meas tran vdout1_90ck1810 FIND v(dout1_90) AT=910.025n

.meas tran vdout1_91ck1810 FIND v(dout1_91) AT=910.025n

.meas tran vdout1_92ck1810 FIND v(dout1_92) AT=910.025n

.meas tran vdout1_93ck1810 FIND v(dout1_93) AT=910.025n

.meas tran vdout1_94ck1810 FIND v(dout1_94) AT=910.025n

.meas tran vdout1_95ck1810 FIND v(dout1_95) AT=910.025n

.meas tran vdout1_96ck1810 FIND v(dout1_96) AT=910.025n

.meas tran vdout1_97ck1810 FIND v(dout1_97) AT=910.025n

.meas tran vdout1_98ck1810 FIND v(dout1_98) AT=910.025n

.meas tran vdout1_99ck1810 FIND v(dout1_99) AT=910.025n

.meas tran vdout1_100ck1810 FIND v(dout1_100) AT=910.025n

.meas tran vdout1_101ck1810 FIND v(dout1_101) AT=910.025n

.meas tran vdout1_102ck1810 FIND v(dout1_102) AT=910.025n

.meas tran vdout1_103ck1810 FIND v(dout1_103) AT=910.025n

.meas tran vdout1_104ck1810 FIND v(dout1_104) AT=910.025n

.meas tran vdout1_105ck1810 FIND v(dout1_105) AT=910.025n

.meas tran vdout1_106ck1810 FIND v(dout1_106) AT=910.025n

.meas tran vdout1_107ck1810 FIND v(dout1_107) AT=910.025n

.meas tran vdout1_108ck1810 FIND v(dout1_108) AT=910.025n

.meas tran vdout1_109ck1810 FIND v(dout1_109) AT=910.025n

.meas tran vdout1_110ck1810 FIND v(dout1_110) AT=910.025n

.meas tran vdout1_111ck1810 FIND v(dout1_111) AT=910.025n

.meas tran vdout1_112ck1810 FIND v(dout1_112) AT=910.025n

.meas tran vdout1_113ck1810 FIND v(dout1_113) AT=910.025n

.meas tran vdout1_114ck1810 FIND v(dout1_114) AT=910.025n

.meas tran vdout1_115ck1810 FIND v(dout1_115) AT=910.025n

.meas tran vdout1_116ck1810 FIND v(dout1_116) AT=910.025n

.meas tran vdout1_117ck1810 FIND v(dout1_117) AT=910.025n

.meas tran vdout1_118ck1810 FIND v(dout1_118) AT=910.025n

.meas tran vdout1_119ck1810 FIND v(dout1_119) AT=910.025n

.meas tran vdout1_120ck1810 FIND v(dout1_120) AT=910.025n

.meas tran vdout1_121ck1810 FIND v(dout1_121) AT=910.025n

.meas tran vdout1_122ck1810 FIND v(dout1_122) AT=910.025n

.meas tran vdout1_123ck1810 FIND v(dout1_123) AT=910.025n

.meas tran vdout1_124ck1810 FIND v(dout1_124) AT=910.025n

.meas tran vdout1_125ck1810 FIND v(dout1_125) AT=910.025n

.meas tran vdout1_126ck1810 FIND v(dout1_126) AT=910.025n

.meas tran vdout1_127ck1810 FIND v(dout1_127) AT=910.025n

.meas tran vdout1_128ck1810 FIND v(dout1_128) AT=910.025n

.meas tran vdout1_129ck1810 FIND v(dout1_129) AT=910.025n

.meas tran vdout1_130ck1810 FIND v(dout1_130) AT=910.025n

.meas tran vdout1_131ck1810 FIND v(dout1_131) AT=910.025n

.meas tran vdout1_132ck1810 FIND v(dout1_132) AT=910.025n

.meas tran vdout1_133ck1810 FIND v(dout1_133) AT=910.025n

.meas tran vdout1_134ck1810 FIND v(dout1_134) AT=910.025n

.meas tran vdout1_135ck1810 FIND v(dout1_135) AT=910.025n

.meas tran vdout1_136ck1810 FIND v(dout1_136) AT=910.025n

.meas tran vdout1_137ck1810 FIND v(dout1_137) AT=910.025n

.meas tran vdout1_138ck1810 FIND v(dout1_138) AT=910.025n

.meas tran vdout1_139ck1810 FIND v(dout1_139) AT=910.025n

.meas tran vdout1_140ck1810 FIND v(dout1_140) AT=910.025n

.meas tran vdout1_141ck1810 FIND v(dout1_141) AT=910.025n

.meas tran vdout1_142ck1810 FIND v(dout1_142) AT=910.025n

.meas tran vdout1_143ck1810 FIND v(dout1_143) AT=910.025n

.meas tran vdout1_144ck1810 FIND v(dout1_144) AT=910.025n

.meas tran vdout1_145ck1810 FIND v(dout1_145) AT=910.025n

.meas tran vdout1_146ck1810 FIND v(dout1_146) AT=910.025n

.meas tran vdout1_147ck1810 FIND v(dout1_147) AT=910.025n

.meas tran vdout1_148ck1810 FIND v(dout1_148) AT=910.025n

.meas tran vdout1_149ck1810 FIND v(dout1_149) AT=910.025n

.meas tran vdout1_150ck1810 FIND v(dout1_150) AT=910.025n

.meas tran vdout1_151ck1810 FIND v(dout1_151) AT=910.025n

.meas tran vdout1_152ck1810 FIND v(dout1_152) AT=910.025n

.meas tran vdout1_153ck1810 FIND v(dout1_153) AT=910.025n

.meas tran vdout1_154ck1810 FIND v(dout1_154) AT=910.025n

.meas tran vdout1_155ck1810 FIND v(dout1_155) AT=910.025n

.meas tran vdout1_156ck1810 FIND v(dout1_156) AT=910.025n

.meas tran vdout1_157ck1810 FIND v(dout1_157) AT=910.025n

.meas tran vdout1_158ck1810 FIND v(dout1_158) AT=910.025n

.meas tran vdout1_159ck1810 FIND v(dout1_159) AT=910.025n

.meas tran vdout1_160ck1810 FIND v(dout1_160) AT=910.025n

.meas tran vdout1_161ck1810 FIND v(dout1_161) AT=910.025n

.meas tran vdout1_162ck1810 FIND v(dout1_162) AT=910.025n

.meas tran vdout1_163ck1810 FIND v(dout1_163) AT=910.025n

.meas tran vdout1_164ck1810 FIND v(dout1_164) AT=910.025n

.meas tran vdout1_165ck1810 FIND v(dout1_165) AT=910.025n

.meas tran vdout1_166ck1810 FIND v(dout1_166) AT=910.025n

.meas tran vdout1_167ck1810 FIND v(dout1_167) AT=910.025n

.meas tran vdout1_168ck1810 FIND v(dout1_168) AT=910.025n

.meas tran vdout1_169ck1810 FIND v(dout1_169) AT=910.025n

.meas tran vdout1_170ck1810 FIND v(dout1_170) AT=910.025n

.meas tran vdout1_171ck1810 FIND v(dout1_171) AT=910.025n

.meas tran vdout1_172ck1810 FIND v(dout1_172) AT=910.025n

.meas tran vdout1_173ck1810 FIND v(dout1_173) AT=910.025n

.meas tran vdout1_174ck1810 FIND v(dout1_174) AT=910.025n

.meas tran vdout1_175ck1810 FIND v(dout1_175) AT=910.025n

.meas tran vdout1_176ck1810 FIND v(dout1_176) AT=910.025n

.meas tran vdout1_177ck1810 FIND v(dout1_177) AT=910.025n

.meas tran vdout1_178ck1810 FIND v(dout1_178) AT=910.025n

.meas tran vdout1_179ck1810 FIND v(dout1_179) AT=910.025n

.meas tran vdout1_180ck1810 FIND v(dout1_180) AT=910.025n

.meas tran vdout1_181ck1810 FIND v(dout1_181) AT=910.025n

.meas tran vdout1_182ck1810 FIND v(dout1_182) AT=910.025n

.meas tran vdout1_183ck1810 FIND v(dout1_183) AT=910.025n

.meas tran vdout1_184ck1810 FIND v(dout1_184) AT=910.025n

.meas tran vdout1_185ck1810 FIND v(dout1_185) AT=910.025n

.meas tran vdout1_186ck1810 FIND v(dout1_186) AT=910.025n

.meas tran vdout1_187ck1810 FIND v(dout1_187) AT=910.025n

.meas tran vdout1_188ck1810 FIND v(dout1_188) AT=910.025n

.meas tran vdout1_189ck1810 FIND v(dout1_189) AT=910.025n

.meas tran vdout1_190ck1810 FIND v(dout1_190) AT=910.025n

.meas tran vdout1_191ck1810 FIND v(dout1_191) AT=910.025n

.meas tran vdout1_192ck1810 FIND v(dout1_192) AT=910.025n

.meas tran vdout1_193ck1810 FIND v(dout1_193) AT=910.025n

.meas tran vdout1_194ck1810 FIND v(dout1_194) AT=910.025n

.meas tran vdout1_195ck1810 FIND v(dout1_195) AT=910.025n

.meas tran vdout1_196ck1810 FIND v(dout1_196) AT=910.025n

.meas tran vdout1_197ck1810 FIND v(dout1_197) AT=910.025n

.meas tran vdout1_198ck1810 FIND v(dout1_198) AT=910.025n

.meas tran vdout1_199ck1810 FIND v(dout1_199) AT=910.025n

.meas tran vdout1_200ck1810 FIND v(dout1_200) AT=910.025n

.meas tran vdout1_201ck1810 FIND v(dout1_201) AT=910.025n

.meas tran vdout1_202ck1810 FIND v(dout1_202) AT=910.025n

.meas tran vdout1_203ck1810 FIND v(dout1_203) AT=910.025n

.meas tran vdout1_204ck1810 FIND v(dout1_204) AT=910.025n

.meas tran vdout1_205ck1810 FIND v(dout1_205) AT=910.025n

.meas tran vdout1_206ck1810 FIND v(dout1_206) AT=910.025n

.meas tran vdout1_207ck1810 FIND v(dout1_207) AT=910.025n

.meas tran vdout1_208ck1810 FIND v(dout1_208) AT=910.025n

.meas tran vdout1_209ck1810 FIND v(dout1_209) AT=910.025n

.meas tran vdout1_210ck1810 FIND v(dout1_210) AT=910.025n

.meas tran vdout1_211ck1810 FIND v(dout1_211) AT=910.025n

.meas tran vdout1_212ck1810 FIND v(dout1_212) AT=910.025n

.meas tran vdout1_213ck1810 FIND v(dout1_213) AT=910.025n

.meas tran vdout1_214ck1810 FIND v(dout1_214) AT=910.025n

.meas tran vdout1_215ck1810 FIND v(dout1_215) AT=910.025n

.meas tran vdout1_216ck1810 FIND v(dout1_216) AT=910.025n

.meas tran vdout1_217ck1810 FIND v(dout1_217) AT=910.025n

.meas tran vdout1_218ck1810 FIND v(dout1_218) AT=910.025n

.meas tran vdout1_219ck1810 FIND v(dout1_219) AT=910.025n

.meas tran vdout1_220ck1810 FIND v(dout1_220) AT=910.025n

.meas tran vdout1_221ck1810 FIND v(dout1_221) AT=910.025n

.meas tran vdout1_222ck1810 FIND v(dout1_222) AT=910.025n

.meas tran vdout1_223ck1810 FIND v(dout1_223) AT=910.025n

.meas tran vdout1_224ck1810 FIND v(dout1_224) AT=910.025n

.meas tran vdout1_225ck1810 FIND v(dout1_225) AT=910.025n

.meas tran vdout1_226ck1810 FIND v(dout1_226) AT=910.025n

.meas tran vdout1_227ck1810 FIND v(dout1_227) AT=910.025n

.meas tran vdout1_228ck1810 FIND v(dout1_228) AT=910.025n

.meas tran vdout1_229ck1810 FIND v(dout1_229) AT=910.025n

.meas tran vdout1_230ck1810 FIND v(dout1_230) AT=910.025n

.meas tran vdout1_231ck1810 FIND v(dout1_231) AT=910.025n

.meas tran vdout1_232ck1810 FIND v(dout1_232) AT=910.025n

.meas tran vdout1_233ck1810 FIND v(dout1_233) AT=910.025n

.meas tran vdout1_234ck1810 FIND v(dout1_234) AT=910.025n

.meas tran vdout1_235ck1810 FIND v(dout1_235) AT=910.025n

.meas tran vdout1_236ck1810 FIND v(dout1_236) AT=910.025n

.meas tran vdout1_237ck1810 FIND v(dout1_237) AT=910.025n

.meas tran vdout1_238ck1810 FIND v(dout1_238) AT=910.025n

.meas tran vdout1_239ck1810 FIND v(dout1_239) AT=910.025n

.meas tran vdout1_240ck1810 FIND v(dout1_240) AT=910.025n

.meas tran vdout1_241ck1810 FIND v(dout1_241) AT=910.025n

.meas tran vdout1_242ck1810 FIND v(dout1_242) AT=910.025n

.meas tran vdout1_243ck1810 FIND v(dout1_243) AT=910.025n

.meas tran vdout1_244ck1810 FIND v(dout1_244) AT=910.025n

.meas tran vdout1_245ck1810 FIND v(dout1_245) AT=910.025n

.meas tran vdout1_246ck1810 FIND v(dout1_246) AT=910.025n

.meas tran vdout1_247ck1810 FIND v(dout1_247) AT=910.025n

.meas tran vdout1_248ck1810 FIND v(dout1_248) AT=910.025n

.meas tran vdout1_249ck1810 FIND v(dout1_249) AT=910.025n

.meas tran vdout1_250ck1810 FIND v(dout1_250) AT=910.025n

.meas tran vdout1_251ck1810 FIND v(dout1_251) AT=910.025n

.meas tran vdout1_252ck1810 FIND v(dout1_252) AT=910.025n

.meas tran vdout1_253ck1810 FIND v(dout1_253) AT=910.025n

.meas tran vdout1_254ck1810 FIND v(dout1_254) AT=910.025n

.meas tran vdout1_255ck1810 FIND v(dout1_255) AT=910.025n

.meas tran vdout1_256ck1810 FIND v(dout1_256) AT=910.025n

.meas tran vdout1_257ck1810 FIND v(dout1_257) AT=910.025n

.meas tran vdout1_258ck1810 FIND v(dout1_258) AT=910.025n

.meas tran vdout1_259ck1810 FIND v(dout1_259) AT=910.025n

.meas tran vdout1_260ck1810 FIND v(dout1_260) AT=910.025n

.meas tran vdout1_261ck1810 FIND v(dout1_261) AT=910.025n

.meas tran vdout1_262ck1810 FIND v(dout1_262) AT=910.025n

.meas tran vdout1_263ck1810 FIND v(dout1_263) AT=910.025n

.meas tran vdout1_264ck1810 FIND v(dout1_264) AT=910.025n

.meas tran vdout1_265ck1810 FIND v(dout1_265) AT=910.025n

.meas tran vdout1_266ck1810 FIND v(dout1_266) AT=910.025n

.meas tran vdout1_267ck1810 FIND v(dout1_267) AT=910.025n

.meas tran vdout1_268ck1810 FIND v(dout1_268) AT=910.025n

.meas tran vdout1_269ck1810 FIND v(dout1_269) AT=910.025n

.meas tran vdout1_270ck1810 FIND v(dout1_270) AT=910.025n

.meas tran vdout1_271ck1810 FIND v(dout1_271) AT=910.025n

.meas tran vdout1_272ck1810 FIND v(dout1_272) AT=910.025n

.meas tran vdout1_273ck1810 FIND v(dout1_273) AT=910.025n

.meas tran vdout1_274ck1810 FIND v(dout1_274) AT=910.025n

.meas tran vdout1_275ck1810 FIND v(dout1_275) AT=910.025n

.meas tran vdout1_276ck1810 FIND v(dout1_276) AT=910.025n

.meas tran vdout1_277ck1810 FIND v(dout1_277) AT=910.025n

.meas tran vdout1_278ck1810 FIND v(dout1_278) AT=910.025n

.meas tran vdout1_279ck1810 FIND v(dout1_279) AT=910.025n

.meas tran vdout1_280ck1810 FIND v(dout1_280) AT=910.025n

.meas tran vdout1_281ck1810 FIND v(dout1_281) AT=910.025n

.meas tran vdout1_282ck1810 FIND v(dout1_282) AT=910.025n

.meas tran vdout1_283ck1810 FIND v(dout1_283) AT=910.025n

.meas tran vdout1_284ck1810 FIND v(dout1_284) AT=910.025n

.meas tran vdout1_285ck1810 FIND v(dout1_285) AT=910.025n

.meas tran vdout1_286ck1810 FIND v(dout1_286) AT=910.025n

.meas tran vdout1_287ck1810 FIND v(dout1_287) AT=910.025n

.meas tran vdout1_288ck1810 FIND v(dout1_288) AT=910.025n

.meas tran vdout1_289ck1810 FIND v(dout1_289) AT=910.025n

.meas tran vdout1_290ck1810 FIND v(dout1_290) AT=910.025n

.meas tran vdout1_291ck1810 FIND v(dout1_291) AT=910.025n

.meas tran vdout1_292ck1810 FIND v(dout1_292) AT=910.025n

.meas tran vdout1_293ck1810 FIND v(dout1_293) AT=910.025n

.meas tran vdout1_294ck1810 FIND v(dout1_294) AT=910.025n

.meas tran vdout1_295ck1810 FIND v(dout1_295) AT=910.025n

.meas tran vdout1_296ck1810 FIND v(dout1_296) AT=910.025n

.meas tran vdout1_297ck1810 FIND v(dout1_297) AT=910.025n

.meas tran vdout1_298ck1810 FIND v(dout1_298) AT=910.025n

.meas tran vdout1_299ck1810 FIND v(dout1_299) AT=910.025n

.meas tran vdout1_300ck1810 FIND v(dout1_300) AT=910.025n

.meas tran vdout1_301ck1810 FIND v(dout1_301) AT=910.025n

.meas tran vdout1_302ck1810 FIND v(dout1_302) AT=910.025n

.meas tran vdout1_303ck1810 FIND v(dout1_303) AT=910.025n

.meas tran vdout1_304ck1810 FIND v(dout1_304) AT=910.025n

.meas tran vdout1_305ck1810 FIND v(dout1_305) AT=910.025n

.meas tran vdout1_306ck1810 FIND v(dout1_306) AT=910.025n

.meas tran vdout1_307ck1810 FIND v(dout1_307) AT=910.025n

.meas tran vdout1_308ck1810 FIND v(dout1_308) AT=910.025n

.meas tran vdout1_309ck1810 FIND v(dout1_309) AT=910.025n

.meas tran vdout1_310ck1810 FIND v(dout1_310) AT=910.025n

.meas tran vdout1_311ck1810 FIND v(dout1_311) AT=910.025n

.meas tran vdout1_312ck1810 FIND v(dout1_312) AT=910.025n

.meas tran vdout1_313ck1810 FIND v(dout1_313) AT=910.025n

.meas tran vdout1_314ck1810 FIND v(dout1_314) AT=910.025n

.meas tran vdout1_315ck1810 FIND v(dout1_315) AT=910.025n

.meas tran vdout1_316ck1810 FIND v(dout1_316) AT=910.025n

.meas tran vdout1_317ck1810 FIND v(dout1_317) AT=910.025n

.meas tran vdout1_318ck1810 FIND v(dout1_318) AT=910.025n

.meas tran vdout1_319ck1810 FIND v(dout1_319) AT=910.025n

.meas tran vdout1_320ck1810 FIND v(dout1_320) AT=910.025n

.meas tran vdout1_321ck1810 FIND v(dout1_321) AT=910.025n

.meas tran vdout1_322ck1810 FIND v(dout1_322) AT=910.025n

.meas tran vdout1_323ck1810 FIND v(dout1_323) AT=910.025n

.meas tran vdout1_324ck1810 FIND v(dout1_324) AT=910.025n

.meas tran vdout1_325ck1810 FIND v(dout1_325) AT=910.025n

.meas tran vdout1_326ck1810 FIND v(dout1_326) AT=910.025n

.meas tran vdout1_327ck1810 FIND v(dout1_327) AT=910.025n

.meas tran vdout1_328ck1810 FIND v(dout1_328) AT=910.025n

.meas tran vdout1_329ck1810 FIND v(dout1_329) AT=910.025n

.meas tran vdout1_330ck1810 FIND v(dout1_330) AT=910.025n

.meas tran vdout1_331ck1810 FIND v(dout1_331) AT=910.025n

.meas tran vdout1_332ck1810 FIND v(dout1_332) AT=910.025n

.meas tran vdout1_333ck1810 FIND v(dout1_333) AT=910.025n

.meas tran vdout1_334ck1810 FIND v(dout1_334) AT=910.025n

.meas tran vdout1_335ck1810 FIND v(dout1_335) AT=910.025n

.meas tran vdout1_336ck1810 FIND v(dout1_336) AT=910.025n

.meas tran vdout1_337ck1810 FIND v(dout1_337) AT=910.025n

.meas tran vdout1_338ck1810 FIND v(dout1_338) AT=910.025n

.meas tran vdout1_339ck1810 FIND v(dout1_339) AT=910.025n

.meas tran vdout1_340ck1810 FIND v(dout1_340) AT=910.025n

.meas tran vdout1_341ck1810 FIND v(dout1_341) AT=910.025n

.meas tran vdout1_342ck1810 FIND v(dout1_342) AT=910.025n

.meas tran vdout1_343ck1810 FIND v(dout1_343) AT=910.025n

.meas tran vdout1_344ck1810 FIND v(dout1_344) AT=910.025n

.meas tran vdout1_345ck1810 FIND v(dout1_345) AT=910.025n

.meas tran vdout1_346ck1810 FIND v(dout1_346) AT=910.025n

.meas tran vdout1_347ck1810 FIND v(dout1_347) AT=910.025n

.meas tran vdout1_348ck1810 FIND v(dout1_348) AT=910.025n

.meas tran vdout1_349ck1810 FIND v(dout1_349) AT=910.025n

.meas tran vdout1_350ck1810 FIND v(dout1_350) AT=910.025n

.meas tran vdout1_351ck1810 FIND v(dout1_351) AT=910.025n

.meas tran vdout1_352ck1810 FIND v(dout1_352) AT=910.025n

.meas tran vdout1_353ck1810 FIND v(dout1_353) AT=910.025n

.meas tran vdout1_354ck1810 FIND v(dout1_354) AT=910.025n

.meas tran vdout1_355ck1810 FIND v(dout1_355) AT=910.025n

.meas tran vdout1_356ck1810 FIND v(dout1_356) AT=910.025n

.meas tran vdout1_357ck1810 FIND v(dout1_357) AT=910.025n

.meas tran vdout1_358ck1810 FIND v(dout1_358) AT=910.025n

.meas tran vdout1_359ck1810 FIND v(dout1_359) AT=910.025n

.meas tran vdout1_360ck1810 FIND v(dout1_360) AT=910.025n

.meas tran vdout1_361ck1810 FIND v(dout1_361) AT=910.025n

.meas tran vdout1_362ck1810 FIND v(dout1_362) AT=910.025n

.meas tran vdout1_363ck1810 FIND v(dout1_363) AT=910.025n

.meas tran vdout1_364ck1810 FIND v(dout1_364) AT=910.025n

.meas tran vdout1_365ck1810 FIND v(dout1_365) AT=910.025n

.meas tran vdout1_366ck1810 FIND v(dout1_366) AT=910.025n

.meas tran vdout1_367ck1810 FIND v(dout1_367) AT=910.025n

.meas tran vdout1_368ck1810 FIND v(dout1_368) AT=910.025n

.meas tran vdout1_369ck1810 FIND v(dout1_369) AT=910.025n

.meas tran vdout1_370ck1810 FIND v(dout1_370) AT=910.025n

.meas tran vdout1_371ck1810 FIND v(dout1_371) AT=910.025n

.meas tran vdout1_372ck1810 FIND v(dout1_372) AT=910.025n

.meas tran vdout1_373ck1810 FIND v(dout1_373) AT=910.025n

.meas tran vdout1_374ck1810 FIND v(dout1_374) AT=910.025n

.meas tran vdout1_375ck1810 FIND v(dout1_375) AT=910.025n

.meas tran vdout1_376ck1810 FIND v(dout1_376) AT=910.025n

.meas tran vdout1_377ck1810 FIND v(dout1_377) AT=910.025n

.meas tran vdout1_378ck1810 FIND v(dout1_378) AT=910.025n

.meas tran vdout1_379ck1810 FIND v(dout1_379) AT=910.025n

.meas tran vdout1_380ck1810 FIND v(dout1_380) AT=910.025n

.meas tran vdout1_381ck1810 FIND v(dout1_381) AT=910.025n

.meas tran vdout1_382ck1810 FIND v(dout1_382) AT=910.025n

.meas tran vdout1_383ck1810 FIND v(dout1_383) AT=910.025n

.meas tran vdout1_384ck1810 FIND v(dout1_384) AT=910.025n

.meas tran vdout1_385ck1810 FIND v(dout1_385) AT=910.025n

.meas tran vdout1_386ck1810 FIND v(dout1_386) AT=910.025n

.meas tran vdout1_387ck1810 FIND v(dout1_387) AT=910.025n

.meas tran vdout1_388ck1810 FIND v(dout1_388) AT=910.025n

.meas tran vdout1_389ck1810 FIND v(dout1_389) AT=910.025n

.meas tran vdout1_390ck1810 FIND v(dout1_390) AT=910.025n

.meas tran vdout1_391ck1810 FIND v(dout1_391) AT=910.025n

.meas tran vdout1_392ck1810 FIND v(dout1_392) AT=910.025n

.meas tran vdout1_393ck1810 FIND v(dout1_393) AT=910.025n

.meas tran vdout1_394ck1810 FIND v(dout1_394) AT=910.025n

.meas tran vdout1_395ck1810 FIND v(dout1_395) AT=910.025n

.meas tran vdout1_396ck1810 FIND v(dout1_396) AT=910.025n

.meas tran vdout1_397ck1810 FIND v(dout1_397) AT=910.025n

.meas tran vdout1_398ck1810 FIND v(dout1_398) AT=910.025n

.meas tran vdout1_399ck1810 FIND v(dout1_399) AT=910.025n

.meas tran vdout1_400ck1810 FIND v(dout1_400) AT=910.025n

.meas tran vdout1_401ck1810 FIND v(dout1_401) AT=910.025n

.meas tran vdout1_402ck1810 FIND v(dout1_402) AT=910.025n

.meas tran vdout1_403ck1810 FIND v(dout1_403) AT=910.025n

.meas tran vdout1_404ck1810 FIND v(dout1_404) AT=910.025n

.meas tran vdout1_405ck1810 FIND v(dout1_405) AT=910.025n

.meas tran vdout1_406ck1810 FIND v(dout1_406) AT=910.025n

.meas tran vdout1_407ck1810 FIND v(dout1_407) AT=910.025n

.meas tran vdout1_408ck1810 FIND v(dout1_408) AT=910.025n

.meas tran vdout1_409ck1810 FIND v(dout1_409) AT=910.025n

.meas tran vdout1_410ck1810 FIND v(dout1_410) AT=910.025n

.meas tran vdout1_411ck1810 FIND v(dout1_411) AT=910.025n

.meas tran vdout1_412ck1810 FIND v(dout1_412) AT=910.025n

.meas tran vdout1_413ck1810 FIND v(dout1_413) AT=910.025n

.meas tran vdout1_414ck1810 FIND v(dout1_414) AT=910.025n

.meas tran vdout1_415ck1810 FIND v(dout1_415) AT=910.025n

.meas tran vdout1_416ck1810 FIND v(dout1_416) AT=910.025n

.meas tran vdout1_417ck1810 FIND v(dout1_417) AT=910.025n

.meas tran vdout1_418ck1810 FIND v(dout1_418) AT=910.025n

.meas tran vdout1_419ck1810 FIND v(dout1_419) AT=910.025n

.meas tran vdout1_420ck1810 FIND v(dout1_420) AT=910.025n

.meas tran vdout1_421ck1810 FIND v(dout1_421) AT=910.025n

.meas tran vdout1_422ck1810 FIND v(dout1_422) AT=910.025n

.meas tran vdout1_423ck1810 FIND v(dout1_423) AT=910.025n

.meas tran vdout1_424ck1810 FIND v(dout1_424) AT=910.025n

.meas tran vdout1_425ck1810 FIND v(dout1_425) AT=910.025n

.meas tran vdout1_426ck1810 FIND v(dout1_426) AT=910.025n

.meas tran vdout1_427ck1810 FIND v(dout1_427) AT=910.025n

.meas tran vdout1_428ck1810 FIND v(dout1_428) AT=910.025n

.meas tran vdout1_429ck1810 FIND v(dout1_429) AT=910.025n

.meas tran vdout1_430ck1810 FIND v(dout1_430) AT=910.025n

.meas tran vdout1_431ck1810 FIND v(dout1_431) AT=910.025n

.meas tran vdout1_432ck1810 FIND v(dout1_432) AT=910.025n

.meas tran vdout1_433ck1810 FIND v(dout1_433) AT=910.025n

.meas tran vdout1_434ck1810 FIND v(dout1_434) AT=910.025n

.meas tran vdout1_435ck1810 FIND v(dout1_435) AT=910.025n

.meas tran vdout1_436ck1810 FIND v(dout1_436) AT=910.025n

.meas tran vdout1_437ck1810 FIND v(dout1_437) AT=910.025n

.meas tran vdout1_438ck1810 FIND v(dout1_438) AT=910.025n

.meas tran vdout1_439ck1810 FIND v(dout1_439) AT=910.025n

.meas tran vdout1_440ck1810 FIND v(dout1_440) AT=910.025n

.meas tran vdout1_441ck1810 FIND v(dout1_441) AT=910.025n

.meas tran vdout1_442ck1810 FIND v(dout1_442) AT=910.025n

.meas tran vdout1_443ck1810 FIND v(dout1_443) AT=910.025n

.meas tran vdout1_444ck1810 FIND v(dout1_444) AT=910.025n

.meas tran vdout1_445ck1810 FIND v(dout1_445) AT=910.025n

.meas tran vdout1_446ck1810 FIND v(dout1_446) AT=910.025n

.meas tran vdout1_447ck1810 FIND v(dout1_447) AT=910.025n

.meas tran vdout1_448ck1810 FIND v(dout1_448) AT=910.025n

.meas tran vdout1_449ck1810 FIND v(dout1_449) AT=910.025n

.meas tran vdout1_450ck1810 FIND v(dout1_450) AT=910.025n

.meas tran vdout1_451ck1810 FIND v(dout1_451) AT=910.025n

.meas tran vdout1_452ck1810 FIND v(dout1_452) AT=910.025n

.meas tran vdout1_453ck1810 FIND v(dout1_453) AT=910.025n

.meas tran vdout1_454ck1810 FIND v(dout1_454) AT=910.025n

.meas tran vdout1_455ck1810 FIND v(dout1_455) AT=910.025n

.meas tran vdout1_456ck1810 FIND v(dout1_456) AT=910.025n

.meas tran vdout1_457ck1810 FIND v(dout1_457) AT=910.025n

.meas tran vdout1_458ck1810 FIND v(dout1_458) AT=910.025n

.meas tran vdout1_459ck1810 FIND v(dout1_459) AT=910.025n

.meas tran vdout1_460ck1810 FIND v(dout1_460) AT=910.025n

.meas tran vdout1_461ck1810 FIND v(dout1_461) AT=910.025n

.meas tran vdout1_462ck1810 FIND v(dout1_462) AT=910.025n

.meas tran vdout1_463ck1810 FIND v(dout1_463) AT=910.025n

.meas tran vdout1_464ck1810 FIND v(dout1_464) AT=910.025n

.meas tran vdout1_465ck1810 FIND v(dout1_465) AT=910.025n

.meas tran vdout1_466ck1810 FIND v(dout1_466) AT=910.025n

.meas tran vdout1_467ck1810 FIND v(dout1_467) AT=910.025n

.meas tran vdout1_468ck1810 FIND v(dout1_468) AT=910.025n

.meas tran vdout1_469ck1810 FIND v(dout1_469) AT=910.025n

.meas tran vdout1_470ck1810 FIND v(dout1_470) AT=910.025n

.meas tran vdout1_471ck1810 FIND v(dout1_471) AT=910.025n

.meas tran vdout1_472ck1810 FIND v(dout1_472) AT=910.025n

.meas tran vdout1_473ck1810 FIND v(dout1_473) AT=910.025n

.meas tran vdout1_474ck1810 FIND v(dout1_474) AT=910.025n

.meas tran vdout1_475ck1810 FIND v(dout1_475) AT=910.025n

.meas tran vdout1_476ck1810 FIND v(dout1_476) AT=910.025n

.meas tran vdout1_477ck1810 FIND v(dout1_477) AT=910.025n

.meas tran vdout1_478ck1810 FIND v(dout1_478) AT=910.025n

.meas tran vdout1_479ck1810 FIND v(dout1_479) AT=910.025n

.meas tran vdout1_480ck1810 FIND v(dout1_480) AT=910.025n

.meas tran vdout1_481ck1810 FIND v(dout1_481) AT=910.025n

.meas tran vdout1_482ck1810 FIND v(dout1_482) AT=910.025n

.meas tran vdout1_483ck1810 FIND v(dout1_483) AT=910.025n

.meas tran vdout1_484ck1810 FIND v(dout1_484) AT=910.025n

.meas tran vdout1_485ck1810 FIND v(dout1_485) AT=910.025n

.meas tran vdout1_486ck1810 FIND v(dout1_486) AT=910.025n

.meas tran vdout1_487ck1810 FIND v(dout1_487) AT=910.025n

.meas tran vdout1_488ck1810 FIND v(dout1_488) AT=910.025n

.meas tran vdout1_489ck1810 FIND v(dout1_489) AT=910.025n

.meas tran vdout1_490ck1810 FIND v(dout1_490) AT=910.025n

.meas tran vdout1_491ck1810 FIND v(dout1_491) AT=910.025n

.meas tran vdout1_492ck1810 FIND v(dout1_492) AT=910.025n

.meas tran vdout1_493ck1810 FIND v(dout1_493) AT=910.025n

.meas tran vdout1_494ck1810 FIND v(dout1_494) AT=910.025n

.meas tran vdout1_495ck1810 FIND v(dout1_495) AT=910.025n

.meas tran vdout1_496ck1810 FIND v(dout1_496) AT=910.025n

.meas tran vdout1_497ck1810 FIND v(dout1_497) AT=910.025n

.meas tran vdout1_498ck1810 FIND v(dout1_498) AT=910.025n

.meas tran vdout1_499ck1810 FIND v(dout1_499) AT=910.025n

.meas tran vdout1_500ck1810 FIND v(dout1_500) AT=910.025n

.meas tran vdout1_501ck1810 FIND v(dout1_501) AT=910.025n

.meas tran vdout1_502ck1810 FIND v(dout1_502) AT=910.025n

.meas tran vdout1_503ck1810 FIND v(dout1_503) AT=910.025n

.meas tran vdout1_504ck1810 FIND v(dout1_504) AT=910.025n

.meas tran vdout1_505ck1810 FIND v(dout1_505) AT=910.025n

.meas tran vdout1_506ck1810 FIND v(dout1_506) AT=910.025n

.meas tran vdout1_507ck1810 FIND v(dout1_507) AT=910.025n

.meas tran vdout1_508ck1810 FIND v(dout1_508) AT=910.025n

.meas tran vdout1_509ck1810 FIND v(dout1_509) AT=910.025n

.meas tran vdout1_510ck1810 FIND v(dout1_510) AT=910.025n

.meas tran vdout1_511ck1810 FIND v(dout1_511) AT=910.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_32ck1840 FIND v(dout1_32) AT=925.025n

.meas tran vdout1_33ck1840 FIND v(dout1_33) AT=925.025n

.meas tran vdout1_34ck1840 FIND v(dout1_34) AT=925.025n

.meas tran vdout1_35ck1840 FIND v(dout1_35) AT=925.025n

.meas tran vdout1_36ck1840 FIND v(dout1_36) AT=925.025n

.meas tran vdout1_37ck1840 FIND v(dout1_37) AT=925.025n

.meas tran vdout1_38ck1840 FIND v(dout1_38) AT=925.025n

.meas tran vdout1_39ck1840 FIND v(dout1_39) AT=925.025n

.meas tran vdout1_40ck1840 FIND v(dout1_40) AT=925.025n

.meas tran vdout1_41ck1840 FIND v(dout1_41) AT=925.025n

.meas tran vdout1_42ck1840 FIND v(dout1_42) AT=925.025n

.meas tran vdout1_43ck1840 FIND v(dout1_43) AT=925.025n

.meas tran vdout1_44ck1840 FIND v(dout1_44) AT=925.025n

.meas tran vdout1_45ck1840 FIND v(dout1_45) AT=925.025n

.meas tran vdout1_46ck1840 FIND v(dout1_46) AT=925.025n

.meas tran vdout1_47ck1840 FIND v(dout1_47) AT=925.025n

.meas tran vdout1_48ck1840 FIND v(dout1_48) AT=925.025n

.meas tran vdout1_49ck1840 FIND v(dout1_49) AT=925.025n

.meas tran vdout1_50ck1840 FIND v(dout1_50) AT=925.025n

.meas tran vdout1_51ck1840 FIND v(dout1_51) AT=925.025n

.meas tran vdout1_52ck1840 FIND v(dout1_52) AT=925.025n

.meas tran vdout1_53ck1840 FIND v(dout1_53) AT=925.025n

.meas tran vdout1_54ck1840 FIND v(dout1_54) AT=925.025n

.meas tran vdout1_55ck1840 FIND v(dout1_55) AT=925.025n

.meas tran vdout1_56ck1840 FIND v(dout1_56) AT=925.025n

.meas tran vdout1_57ck1840 FIND v(dout1_57) AT=925.025n

.meas tran vdout1_58ck1840 FIND v(dout1_58) AT=925.025n

.meas tran vdout1_59ck1840 FIND v(dout1_59) AT=925.025n

.meas tran vdout1_60ck1840 FIND v(dout1_60) AT=925.025n

.meas tran vdout1_61ck1840 FIND v(dout1_61) AT=925.025n

.meas tran vdout1_62ck1840 FIND v(dout1_62) AT=925.025n

.meas tran vdout1_63ck1840 FIND v(dout1_63) AT=925.025n

.meas tran vdout1_64ck1840 FIND v(dout1_64) AT=925.025n

.meas tran vdout1_65ck1840 FIND v(dout1_65) AT=925.025n

.meas tran vdout1_66ck1840 FIND v(dout1_66) AT=925.025n

.meas tran vdout1_67ck1840 FIND v(dout1_67) AT=925.025n

.meas tran vdout1_68ck1840 FIND v(dout1_68) AT=925.025n

.meas tran vdout1_69ck1840 FIND v(dout1_69) AT=925.025n

.meas tran vdout1_70ck1840 FIND v(dout1_70) AT=925.025n

.meas tran vdout1_71ck1840 FIND v(dout1_71) AT=925.025n

.meas tran vdout1_72ck1840 FIND v(dout1_72) AT=925.025n

.meas tran vdout1_73ck1840 FIND v(dout1_73) AT=925.025n

.meas tran vdout1_74ck1840 FIND v(dout1_74) AT=925.025n

.meas tran vdout1_75ck1840 FIND v(dout1_75) AT=925.025n

.meas tran vdout1_76ck1840 FIND v(dout1_76) AT=925.025n

.meas tran vdout1_77ck1840 FIND v(dout1_77) AT=925.025n

.meas tran vdout1_78ck1840 FIND v(dout1_78) AT=925.025n

.meas tran vdout1_79ck1840 FIND v(dout1_79) AT=925.025n

.meas tran vdout1_80ck1840 FIND v(dout1_80) AT=925.025n

.meas tran vdout1_81ck1840 FIND v(dout1_81) AT=925.025n

.meas tran vdout1_82ck1840 FIND v(dout1_82) AT=925.025n

.meas tran vdout1_83ck1840 FIND v(dout1_83) AT=925.025n

.meas tran vdout1_84ck1840 FIND v(dout1_84) AT=925.025n

.meas tran vdout1_85ck1840 FIND v(dout1_85) AT=925.025n

.meas tran vdout1_86ck1840 FIND v(dout1_86) AT=925.025n

.meas tran vdout1_87ck1840 FIND v(dout1_87) AT=925.025n

.meas tran vdout1_88ck1840 FIND v(dout1_88) AT=925.025n

.meas tran vdout1_89ck1840 FIND v(dout1_89) AT=925.025n

.meas tran vdout1_90ck1840 FIND v(dout1_90) AT=925.025n

.meas tran vdout1_91ck1840 FIND v(dout1_91) AT=925.025n

.meas tran vdout1_92ck1840 FIND v(dout1_92) AT=925.025n

.meas tran vdout1_93ck1840 FIND v(dout1_93) AT=925.025n

.meas tran vdout1_94ck1840 FIND v(dout1_94) AT=925.025n

.meas tran vdout1_95ck1840 FIND v(dout1_95) AT=925.025n

.meas tran vdout1_96ck1840 FIND v(dout1_96) AT=925.025n

.meas tran vdout1_97ck1840 FIND v(dout1_97) AT=925.025n

.meas tran vdout1_98ck1840 FIND v(dout1_98) AT=925.025n

.meas tran vdout1_99ck1840 FIND v(dout1_99) AT=925.025n

.meas tran vdout1_100ck1840 FIND v(dout1_100) AT=925.025n

.meas tran vdout1_101ck1840 FIND v(dout1_101) AT=925.025n

.meas tran vdout1_102ck1840 FIND v(dout1_102) AT=925.025n

.meas tran vdout1_103ck1840 FIND v(dout1_103) AT=925.025n

.meas tran vdout1_104ck1840 FIND v(dout1_104) AT=925.025n

.meas tran vdout1_105ck1840 FIND v(dout1_105) AT=925.025n

.meas tran vdout1_106ck1840 FIND v(dout1_106) AT=925.025n

.meas tran vdout1_107ck1840 FIND v(dout1_107) AT=925.025n

.meas tran vdout1_108ck1840 FIND v(dout1_108) AT=925.025n

.meas tran vdout1_109ck1840 FIND v(dout1_109) AT=925.025n

.meas tran vdout1_110ck1840 FIND v(dout1_110) AT=925.025n

.meas tran vdout1_111ck1840 FIND v(dout1_111) AT=925.025n

.meas tran vdout1_112ck1840 FIND v(dout1_112) AT=925.025n

.meas tran vdout1_113ck1840 FIND v(dout1_113) AT=925.025n

.meas tran vdout1_114ck1840 FIND v(dout1_114) AT=925.025n

.meas tran vdout1_115ck1840 FIND v(dout1_115) AT=925.025n

.meas tran vdout1_116ck1840 FIND v(dout1_116) AT=925.025n

.meas tran vdout1_117ck1840 FIND v(dout1_117) AT=925.025n

.meas tran vdout1_118ck1840 FIND v(dout1_118) AT=925.025n

.meas tran vdout1_119ck1840 FIND v(dout1_119) AT=925.025n

.meas tran vdout1_120ck1840 FIND v(dout1_120) AT=925.025n

.meas tran vdout1_121ck1840 FIND v(dout1_121) AT=925.025n

.meas tran vdout1_122ck1840 FIND v(dout1_122) AT=925.025n

.meas tran vdout1_123ck1840 FIND v(dout1_123) AT=925.025n

.meas tran vdout1_124ck1840 FIND v(dout1_124) AT=925.025n

.meas tran vdout1_125ck1840 FIND v(dout1_125) AT=925.025n

.meas tran vdout1_126ck1840 FIND v(dout1_126) AT=925.025n

.meas tran vdout1_127ck1840 FIND v(dout1_127) AT=925.025n

.meas tran vdout1_128ck1840 FIND v(dout1_128) AT=925.025n

.meas tran vdout1_129ck1840 FIND v(dout1_129) AT=925.025n

.meas tran vdout1_130ck1840 FIND v(dout1_130) AT=925.025n

.meas tran vdout1_131ck1840 FIND v(dout1_131) AT=925.025n

.meas tran vdout1_132ck1840 FIND v(dout1_132) AT=925.025n

.meas tran vdout1_133ck1840 FIND v(dout1_133) AT=925.025n

.meas tran vdout1_134ck1840 FIND v(dout1_134) AT=925.025n

.meas tran vdout1_135ck1840 FIND v(dout1_135) AT=925.025n

.meas tran vdout1_136ck1840 FIND v(dout1_136) AT=925.025n

.meas tran vdout1_137ck1840 FIND v(dout1_137) AT=925.025n

.meas tran vdout1_138ck1840 FIND v(dout1_138) AT=925.025n

.meas tran vdout1_139ck1840 FIND v(dout1_139) AT=925.025n

.meas tran vdout1_140ck1840 FIND v(dout1_140) AT=925.025n

.meas tran vdout1_141ck1840 FIND v(dout1_141) AT=925.025n

.meas tran vdout1_142ck1840 FIND v(dout1_142) AT=925.025n

.meas tran vdout1_143ck1840 FIND v(dout1_143) AT=925.025n

.meas tran vdout1_144ck1840 FIND v(dout1_144) AT=925.025n

.meas tran vdout1_145ck1840 FIND v(dout1_145) AT=925.025n

.meas tran vdout1_146ck1840 FIND v(dout1_146) AT=925.025n

.meas tran vdout1_147ck1840 FIND v(dout1_147) AT=925.025n

.meas tran vdout1_148ck1840 FIND v(dout1_148) AT=925.025n

.meas tran vdout1_149ck1840 FIND v(dout1_149) AT=925.025n

.meas tran vdout1_150ck1840 FIND v(dout1_150) AT=925.025n

.meas tran vdout1_151ck1840 FIND v(dout1_151) AT=925.025n

.meas tran vdout1_152ck1840 FIND v(dout1_152) AT=925.025n

.meas tran vdout1_153ck1840 FIND v(dout1_153) AT=925.025n

.meas tran vdout1_154ck1840 FIND v(dout1_154) AT=925.025n

.meas tran vdout1_155ck1840 FIND v(dout1_155) AT=925.025n

.meas tran vdout1_156ck1840 FIND v(dout1_156) AT=925.025n

.meas tran vdout1_157ck1840 FIND v(dout1_157) AT=925.025n

.meas tran vdout1_158ck1840 FIND v(dout1_158) AT=925.025n

.meas tran vdout1_159ck1840 FIND v(dout1_159) AT=925.025n

.meas tran vdout1_160ck1840 FIND v(dout1_160) AT=925.025n

.meas tran vdout1_161ck1840 FIND v(dout1_161) AT=925.025n

.meas tran vdout1_162ck1840 FIND v(dout1_162) AT=925.025n

.meas tran vdout1_163ck1840 FIND v(dout1_163) AT=925.025n

.meas tran vdout1_164ck1840 FIND v(dout1_164) AT=925.025n

.meas tran vdout1_165ck1840 FIND v(dout1_165) AT=925.025n

.meas tran vdout1_166ck1840 FIND v(dout1_166) AT=925.025n

.meas tran vdout1_167ck1840 FIND v(dout1_167) AT=925.025n

.meas tran vdout1_168ck1840 FIND v(dout1_168) AT=925.025n

.meas tran vdout1_169ck1840 FIND v(dout1_169) AT=925.025n

.meas tran vdout1_170ck1840 FIND v(dout1_170) AT=925.025n

.meas tran vdout1_171ck1840 FIND v(dout1_171) AT=925.025n

.meas tran vdout1_172ck1840 FIND v(dout1_172) AT=925.025n

.meas tran vdout1_173ck1840 FIND v(dout1_173) AT=925.025n

.meas tran vdout1_174ck1840 FIND v(dout1_174) AT=925.025n

.meas tran vdout1_175ck1840 FIND v(dout1_175) AT=925.025n

.meas tran vdout1_176ck1840 FIND v(dout1_176) AT=925.025n

.meas tran vdout1_177ck1840 FIND v(dout1_177) AT=925.025n

.meas tran vdout1_178ck1840 FIND v(dout1_178) AT=925.025n

.meas tran vdout1_179ck1840 FIND v(dout1_179) AT=925.025n

.meas tran vdout1_180ck1840 FIND v(dout1_180) AT=925.025n

.meas tran vdout1_181ck1840 FIND v(dout1_181) AT=925.025n

.meas tran vdout1_182ck1840 FIND v(dout1_182) AT=925.025n

.meas tran vdout1_183ck1840 FIND v(dout1_183) AT=925.025n

.meas tran vdout1_184ck1840 FIND v(dout1_184) AT=925.025n

.meas tran vdout1_185ck1840 FIND v(dout1_185) AT=925.025n

.meas tran vdout1_186ck1840 FIND v(dout1_186) AT=925.025n

.meas tran vdout1_187ck1840 FIND v(dout1_187) AT=925.025n

.meas tran vdout1_188ck1840 FIND v(dout1_188) AT=925.025n

.meas tran vdout1_189ck1840 FIND v(dout1_189) AT=925.025n

.meas tran vdout1_190ck1840 FIND v(dout1_190) AT=925.025n

.meas tran vdout1_191ck1840 FIND v(dout1_191) AT=925.025n

.meas tran vdout1_192ck1840 FIND v(dout1_192) AT=925.025n

.meas tran vdout1_193ck1840 FIND v(dout1_193) AT=925.025n

.meas tran vdout1_194ck1840 FIND v(dout1_194) AT=925.025n

.meas tran vdout1_195ck1840 FIND v(dout1_195) AT=925.025n

.meas tran vdout1_196ck1840 FIND v(dout1_196) AT=925.025n

.meas tran vdout1_197ck1840 FIND v(dout1_197) AT=925.025n

.meas tran vdout1_198ck1840 FIND v(dout1_198) AT=925.025n

.meas tran vdout1_199ck1840 FIND v(dout1_199) AT=925.025n

.meas tran vdout1_200ck1840 FIND v(dout1_200) AT=925.025n

.meas tran vdout1_201ck1840 FIND v(dout1_201) AT=925.025n

.meas tran vdout1_202ck1840 FIND v(dout1_202) AT=925.025n

.meas tran vdout1_203ck1840 FIND v(dout1_203) AT=925.025n

.meas tran vdout1_204ck1840 FIND v(dout1_204) AT=925.025n

.meas tran vdout1_205ck1840 FIND v(dout1_205) AT=925.025n

.meas tran vdout1_206ck1840 FIND v(dout1_206) AT=925.025n

.meas tran vdout1_207ck1840 FIND v(dout1_207) AT=925.025n

.meas tran vdout1_208ck1840 FIND v(dout1_208) AT=925.025n

.meas tran vdout1_209ck1840 FIND v(dout1_209) AT=925.025n

.meas tran vdout1_210ck1840 FIND v(dout1_210) AT=925.025n

.meas tran vdout1_211ck1840 FIND v(dout1_211) AT=925.025n

.meas tran vdout1_212ck1840 FIND v(dout1_212) AT=925.025n

.meas tran vdout1_213ck1840 FIND v(dout1_213) AT=925.025n

.meas tran vdout1_214ck1840 FIND v(dout1_214) AT=925.025n

.meas tran vdout1_215ck1840 FIND v(dout1_215) AT=925.025n

.meas tran vdout1_216ck1840 FIND v(dout1_216) AT=925.025n

.meas tran vdout1_217ck1840 FIND v(dout1_217) AT=925.025n

.meas tran vdout1_218ck1840 FIND v(dout1_218) AT=925.025n

.meas tran vdout1_219ck1840 FIND v(dout1_219) AT=925.025n

.meas tran vdout1_220ck1840 FIND v(dout1_220) AT=925.025n

.meas tran vdout1_221ck1840 FIND v(dout1_221) AT=925.025n

.meas tran vdout1_222ck1840 FIND v(dout1_222) AT=925.025n

.meas tran vdout1_223ck1840 FIND v(dout1_223) AT=925.025n

.meas tran vdout1_224ck1840 FIND v(dout1_224) AT=925.025n

.meas tran vdout1_225ck1840 FIND v(dout1_225) AT=925.025n

.meas tran vdout1_226ck1840 FIND v(dout1_226) AT=925.025n

.meas tran vdout1_227ck1840 FIND v(dout1_227) AT=925.025n

.meas tran vdout1_228ck1840 FIND v(dout1_228) AT=925.025n

.meas tran vdout1_229ck1840 FIND v(dout1_229) AT=925.025n

.meas tran vdout1_230ck1840 FIND v(dout1_230) AT=925.025n

.meas tran vdout1_231ck1840 FIND v(dout1_231) AT=925.025n

.meas tran vdout1_232ck1840 FIND v(dout1_232) AT=925.025n

.meas tran vdout1_233ck1840 FIND v(dout1_233) AT=925.025n

.meas tran vdout1_234ck1840 FIND v(dout1_234) AT=925.025n

.meas tran vdout1_235ck1840 FIND v(dout1_235) AT=925.025n

.meas tran vdout1_236ck1840 FIND v(dout1_236) AT=925.025n

.meas tran vdout1_237ck1840 FIND v(dout1_237) AT=925.025n

.meas tran vdout1_238ck1840 FIND v(dout1_238) AT=925.025n

.meas tran vdout1_239ck1840 FIND v(dout1_239) AT=925.025n

.meas tran vdout1_240ck1840 FIND v(dout1_240) AT=925.025n

.meas tran vdout1_241ck1840 FIND v(dout1_241) AT=925.025n

.meas tran vdout1_242ck1840 FIND v(dout1_242) AT=925.025n

.meas tran vdout1_243ck1840 FIND v(dout1_243) AT=925.025n

.meas tran vdout1_244ck1840 FIND v(dout1_244) AT=925.025n

.meas tran vdout1_245ck1840 FIND v(dout1_245) AT=925.025n

.meas tran vdout1_246ck1840 FIND v(dout1_246) AT=925.025n

.meas tran vdout1_247ck1840 FIND v(dout1_247) AT=925.025n

.meas tran vdout1_248ck1840 FIND v(dout1_248) AT=925.025n

.meas tran vdout1_249ck1840 FIND v(dout1_249) AT=925.025n

.meas tran vdout1_250ck1840 FIND v(dout1_250) AT=925.025n

.meas tran vdout1_251ck1840 FIND v(dout1_251) AT=925.025n

.meas tran vdout1_252ck1840 FIND v(dout1_252) AT=925.025n

.meas tran vdout1_253ck1840 FIND v(dout1_253) AT=925.025n

.meas tran vdout1_254ck1840 FIND v(dout1_254) AT=925.025n

.meas tran vdout1_255ck1840 FIND v(dout1_255) AT=925.025n

.meas tran vdout1_256ck1840 FIND v(dout1_256) AT=925.025n

.meas tran vdout1_257ck1840 FIND v(dout1_257) AT=925.025n

.meas tran vdout1_258ck1840 FIND v(dout1_258) AT=925.025n

.meas tran vdout1_259ck1840 FIND v(dout1_259) AT=925.025n

.meas tran vdout1_260ck1840 FIND v(dout1_260) AT=925.025n

.meas tran vdout1_261ck1840 FIND v(dout1_261) AT=925.025n

.meas tran vdout1_262ck1840 FIND v(dout1_262) AT=925.025n

.meas tran vdout1_263ck1840 FIND v(dout1_263) AT=925.025n

.meas tran vdout1_264ck1840 FIND v(dout1_264) AT=925.025n

.meas tran vdout1_265ck1840 FIND v(dout1_265) AT=925.025n

.meas tran vdout1_266ck1840 FIND v(dout1_266) AT=925.025n

.meas tran vdout1_267ck1840 FIND v(dout1_267) AT=925.025n

.meas tran vdout1_268ck1840 FIND v(dout1_268) AT=925.025n

.meas tran vdout1_269ck1840 FIND v(dout1_269) AT=925.025n

.meas tran vdout1_270ck1840 FIND v(dout1_270) AT=925.025n

.meas tran vdout1_271ck1840 FIND v(dout1_271) AT=925.025n

.meas tran vdout1_272ck1840 FIND v(dout1_272) AT=925.025n

.meas tran vdout1_273ck1840 FIND v(dout1_273) AT=925.025n

.meas tran vdout1_274ck1840 FIND v(dout1_274) AT=925.025n

.meas tran vdout1_275ck1840 FIND v(dout1_275) AT=925.025n

.meas tran vdout1_276ck1840 FIND v(dout1_276) AT=925.025n

.meas tran vdout1_277ck1840 FIND v(dout1_277) AT=925.025n

.meas tran vdout1_278ck1840 FIND v(dout1_278) AT=925.025n

.meas tran vdout1_279ck1840 FIND v(dout1_279) AT=925.025n

.meas tran vdout1_280ck1840 FIND v(dout1_280) AT=925.025n

.meas tran vdout1_281ck1840 FIND v(dout1_281) AT=925.025n

.meas tran vdout1_282ck1840 FIND v(dout1_282) AT=925.025n

.meas tran vdout1_283ck1840 FIND v(dout1_283) AT=925.025n

.meas tran vdout1_284ck1840 FIND v(dout1_284) AT=925.025n

.meas tran vdout1_285ck1840 FIND v(dout1_285) AT=925.025n

.meas tran vdout1_286ck1840 FIND v(dout1_286) AT=925.025n

.meas tran vdout1_287ck1840 FIND v(dout1_287) AT=925.025n

.meas tran vdout1_288ck1840 FIND v(dout1_288) AT=925.025n

.meas tran vdout1_289ck1840 FIND v(dout1_289) AT=925.025n

.meas tran vdout1_290ck1840 FIND v(dout1_290) AT=925.025n

.meas tran vdout1_291ck1840 FIND v(dout1_291) AT=925.025n

.meas tran vdout1_292ck1840 FIND v(dout1_292) AT=925.025n

.meas tran vdout1_293ck1840 FIND v(dout1_293) AT=925.025n

.meas tran vdout1_294ck1840 FIND v(dout1_294) AT=925.025n

.meas tran vdout1_295ck1840 FIND v(dout1_295) AT=925.025n

.meas tran vdout1_296ck1840 FIND v(dout1_296) AT=925.025n

.meas tran vdout1_297ck1840 FIND v(dout1_297) AT=925.025n

.meas tran vdout1_298ck1840 FIND v(dout1_298) AT=925.025n

.meas tran vdout1_299ck1840 FIND v(dout1_299) AT=925.025n

.meas tran vdout1_300ck1840 FIND v(dout1_300) AT=925.025n

.meas tran vdout1_301ck1840 FIND v(dout1_301) AT=925.025n

.meas tran vdout1_302ck1840 FIND v(dout1_302) AT=925.025n

.meas tran vdout1_303ck1840 FIND v(dout1_303) AT=925.025n

.meas tran vdout1_304ck1840 FIND v(dout1_304) AT=925.025n

.meas tran vdout1_305ck1840 FIND v(dout1_305) AT=925.025n

.meas tran vdout1_306ck1840 FIND v(dout1_306) AT=925.025n

.meas tran vdout1_307ck1840 FIND v(dout1_307) AT=925.025n

.meas tran vdout1_308ck1840 FIND v(dout1_308) AT=925.025n

.meas tran vdout1_309ck1840 FIND v(dout1_309) AT=925.025n

.meas tran vdout1_310ck1840 FIND v(dout1_310) AT=925.025n

.meas tran vdout1_311ck1840 FIND v(dout1_311) AT=925.025n

.meas tran vdout1_312ck1840 FIND v(dout1_312) AT=925.025n

.meas tran vdout1_313ck1840 FIND v(dout1_313) AT=925.025n

.meas tran vdout1_314ck1840 FIND v(dout1_314) AT=925.025n

.meas tran vdout1_315ck1840 FIND v(dout1_315) AT=925.025n

.meas tran vdout1_316ck1840 FIND v(dout1_316) AT=925.025n

.meas tran vdout1_317ck1840 FIND v(dout1_317) AT=925.025n

.meas tran vdout1_318ck1840 FIND v(dout1_318) AT=925.025n

.meas tran vdout1_319ck1840 FIND v(dout1_319) AT=925.025n

.meas tran vdout1_320ck1840 FIND v(dout1_320) AT=925.025n

.meas tran vdout1_321ck1840 FIND v(dout1_321) AT=925.025n

.meas tran vdout1_322ck1840 FIND v(dout1_322) AT=925.025n

.meas tran vdout1_323ck1840 FIND v(dout1_323) AT=925.025n

.meas tran vdout1_324ck1840 FIND v(dout1_324) AT=925.025n

.meas tran vdout1_325ck1840 FIND v(dout1_325) AT=925.025n

.meas tran vdout1_326ck1840 FIND v(dout1_326) AT=925.025n

.meas tran vdout1_327ck1840 FIND v(dout1_327) AT=925.025n

.meas tran vdout1_328ck1840 FIND v(dout1_328) AT=925.025n

.meas tran vdout1_329ck1840 FIND v(dout1_329) AT=925.025n

.meas tran vdout1_330ck1840 FIND v(dout1_330) AT=925.025n

.meas tran vdout1_331ck1840 FIND v(dout1_331) AT=925.025n

.meas tran vdout1_332ck1840 FIND v(dout1_332) AT=925.025n

.meas tran vdout1_333ck1840 FIND v(dout1_333) AT=925.025n

.meas tran vdout1_334ck1840 FIND v(dout1_334) AT=925.025n

.meas tran vdout1_335ck1840 FIND v(dout1_335) AT=925.025n

.meas tran vdout1_336ck1840 FIND v(dout1_336) AT=925.025n

.meas tran vdout1_337ck1840 FIND v(dout1_337) AT=925.025n

.meas tran vdout1_338ck1840 FIND v(dout1_338) AT=925.025n

.meas tran vdout1_339ck1840 FIND v(dout1_339) AT=925.025n

.meas tran vdout1_340ck1840 FIND v(dout1_340) AT=925.025n

.meas tran vdout1_341ck1840 FIND v(dout1_341) AT=925.025n

.meas tran vdout1_342ck1840 FIND v(dout1_342) AT=925.025n

.meas tran vdout1_343ck1840 FIND v(dout1_343) AT=925.025n

.meas tran vdout1_344ck1840 FIND v(dout1_344) AT=925.025n

.meas tran vdout1_345ck1840 FIND v(dout1_345) AT=925.025n

.meas tran vdout1_346ck1840 FIND v(dout1_346) AT=925.025n

.meas tran vdout1_347ck1840 FIND v(dout1_347) AT=925.025n

.meas tran vdout1_348ck1840 FIND v(dout1_348) AT=925.025n

.meas tran vdout1_349ck1840 FIND v(dout1_349) AT=925.025n

.meas tran vdout1_350ck1840 FIND v(dout1_350) AT=925.025n

.meas tran vdout1_351ck1840 FIND v(dout1_351) AT=925.025n

.meas tran vdout1_352ck1840 FIND v(dout1_352) AT=925.025n

.meas tran vdout1_353ck1840 FIND v(dout1_353) AT=925.025n

.meas tran vdout1_354ck1840 FIND v(dout1_354) AT=925.025n

.meas tran vdout1_355ck1840 FIND v(dout1_355) AT=925.025n

.meas tran vdout1_356ck1840 FIND v(dout1_356) AT=925.025n

.meas tran vdout1_357ck1840 FIND v(dout1_357) AT=925.025n

.meas tran vdout1_358ck1840 FIND v(dout1_358) AT=925.025n

.meas tran vdout1_359ck1840 FIND v(dout1_359) AT=925.025n

.meas tran vdout1_360ck1840 FIND v(dout1_360) AT=925.025n

.meas tran vdout1_361ck1840 FIND v(dout1_361) AT=925.025n

.meas tran vdout1_362ck1840 FIND v(dout1_362) AT=925.025n

.meas tran vdout1_363ck1840 FIND v(dout1_363) AT=925.025n

.meas tran vdout1_364ck1840 FIND v(dout1_364) AT=925.025n

.meas tran vdout1_365ck1840 FIND v(dout1_365) AT=925.025n

.meas tran vdout1_366ck1840 FIND v(dout1_366) AT=925.025n

.meas tran vdout1_367ck1840 FIND v(dout1_367) AT=925.025n

.meas tran vdout1_368ck1840 FIND v(dout1_368) AT=925.025n

.meas tran vdout1_369ck1840 FIND v(dout1_369) AT=925.025n

.meas tran vdout1_370ck1840 FIND v(dout1_370) AT=925.025n

.meas tran vdout1_371ck1840 FIND v(dout1_371) AT=925.025n

.meas tran vdout1_372ck1840 FIND v(dout1_372) AT=925.025n

.meas tran vdout1_373ck1840 FIND v(dout1_373) AT=925.025n

.meas tran vdout1_374ck1840 FIND v(dout1_374) AT=925.025n

.meas tran vdout1_375ck1840 FIND v(dout1_375) AT=925.025n

.meas tran vdout1_376ck1840 FIND v(dout1_376) AT=925.025n

.meas tran vdout1_377ck1840 FIND v(dout1_377) AT=925.025n

.meas tran vdout1_378ck1840 FIND v(dout1_378) AT=925.025n

.meas tran vdout1_379ck1840 FIND v(dout1_379) AT=925.025n

.meas tran vdout1_380ck1840 FIND v(dout1_380) AT=925.025n

.meas tran vdout1_381ck1840 FIND v(dout1_381) AT=925.025n

.meas tran vdout1_382ck1840 FIND v(dout1_382) AT=925.025n

.meas tran vdout1_383ck1840 FIND v(dout1_383) AT=925.025n

.meas tran vdout1_384ck1840 FIND v(dout1_384) AT=925.025n

.meas tran vdout1_385ck1840 FIND v(dout1_385) AT=925.025n

.meas tran vdout1_386ck1840 FIND v(dout1_386) AT=925.025n

.meas tran vdout1_387ck1840 FIND v(dout1_387) AT=925.025n

.meas tran vdout1_388ck1840 FIND v(dout1_388) AT=925.025n

.meas tran vdout1_389ck1840 FIND v(dout1_389) AT=925.025n

.meas tran vdout1_390ck1840 FIND v(dout1_390) AT=925.025n

.meas tran vdout1_391ck1840 FIND v(dout1_391) AT=925.025n

.meas tran vdout1_392ck1840 FIND v(dout1_392) AT=925.025n

.meas tran vdout1_393ck1840 FIND v(dout1_393) AT=925.025n

.meas tran vdout1_394ck1840 FIND v(dout1_394) AT=925.025n

.meas tran vdout1_395ck1840 FIND v(dout1_395) AT=925.025n

.meas tran vdout1_396ck1840 FIND v(dout1_396) AT=925.025n

.meas tran vdout1_397ck1840 FIND v(dout1_397) AT=925.025n

.meas tran vdout1_398ck1840 FIND v(dout1_398) AT=925.025n

.meas tran vdout1_399ck1840 FIND v(dout1_399) AT=925.025n

.meas tran vdout1_400ck1840 FIND v(dout1_400) AT=925.025n

.meas tran vdout1_401ck1840 FIND v(dout1_401) AT=925.025n

.meas tran vdout1_402ck1840 FIND v(dout1_402) AT=925.025n

.meas tran vdout1_403ck1840 FIND v(dout1_403) AT=925.025n

.meas tran vdout1_404ck1840 FIND v(dout1_404) AT=925.025n

.meas tran vdout1_405ck1840 FIND v(dout1_405) AT=925.025n

.meas tran vdout1_406ck1840 FIND v(dout1_406) AT=925.025n

.meas tran vdout1_407ck1840 FIND v(dout1_407) AT=925.025n

.meas tran vdout1_408ck1840 FIND v(dout1_408) AT=925.025n

.meas tran vdout1_409ck1840 FIND v(dout1_409) AT=925.025n

.meas tran vdout1_410ck1840 FIND v(dout1_410) AT=925.025n

.meas tran vdout1_411ck1840 FIND v(dout1_411) AT=925.025n

.meas tran vdout1_412ck1840 FIND v(dout1_412) AT=925.025n

.meas tran vdout1_413ck1840 FIND v(dout1_413) AT=925.025n

.meas tran vdout1_414ck1840 FIND v(dout1_414) AT=925.025n

.meas tran vdout1_415ck1840 FIND v(dout1_415) AT=925.025n

.meas tran vdout1_416ck1840 FIND v(dout1_416) AT=925.025n

.meas tran vdout1_417ck1840 FIND v(dout1_417) AT=925.025n

.meas tran vdout1_418ck1840 FIND v(dout1_418) AT=925.025n

.meas tran vdout1_419ck1840 FIND v(dout1_419) AT=925.025n

.meas tran vdout1_420ck1840 FIND v(dout1_420) AT=925.025n

.meas tran vdout1_421ck1840 FIND v(dout1_421) AT=925.025n

.meas tran vdout1_422ck1840 FIND v(dout1_422) AT=925.025n

.meas tran vdout1_423ck1840 FIND v(dout1_423) AT=925.025n

.meas tran vdout1_424ck1840 FIND v(dout1_424) AT=925.025n

.meas tran vdout1_425ck1840 FIND v(dout1_425) AT=925.025n

.meas tran vdout1_426ck1840 FIND v(dout1_426) AT=925.025n

.meas tran vdout1_427ck1840 FIND v(dout1_427) AT=925.025n

.meas tran vdout1_428ck1840 FIND v(dout1_428) AT=925.025n

.meas tran vdout1_429ck1840 FIND v(dout1_429) AT=925.025n

.meas tran vdout1_430ck1840 FIND v(dout1_430) AT=925.025n

.meas tran vdout1_431ck1840 FIND v(dout1_431) AT=925.025n

.meas tran vdout1_432ck1840 FIND v(dout1_432) AT=925.025n

.meas tran vdout1_433ck1840 FIND v(dout1_433) AT=925.025n

.meas tran vdout1_434ck1840 FIND v(dout1_434) AT=925.025n

.meas tran vdout1_435ck1840 FIND v(dout1_435) AT=925.025n

.meas tran vdout1_436ck1840 FIND v(dout1_436) AT=925.025n

.meas tran vdout1_437ck1840 FIND v(dout1_437) AT=925.025n

.meas tran vdout1_438ck1840 FIND v(dout1_438) AT=925.025n

.meas tran vdout1_439ck1840 FIND v(dout1_439) AT=925.025n

.meas tran vdout1_440ck1840 FIND v(dout1_440) AT=925.025n

.meas tran vdout1_441ck1840 FIND v(dout1_441) AT=925.025n

.meas tran vdout1_442ck1840 FIND v(dout1_442) AT=925.025n

.meas tran vdout1_443ck1840 FIND v(dout1_443) AT=925.025n

.meas tran vdout1_444ck1840 FIND v(dout1_444) AT=925.025n

.meas tran vdout1_445ck1840 FIND v(dout1_445) AT=925.025n

.meas tran vdout1_446ck1840 FIND v(dout1_446) AT=925.025n

.meas tran vdout1_447ck1840 FIND v(dout1_447) AT=925.025n

.meas tran vdout1_448ck1840 FIND v(dout1_448) AT=925.025n

.meas tran vdout1_449ck1840 FIND v(dout1_449) AT=925.025n

.meas tran vdout1_450ck1840 FIND v(dout1_450) AT=925.025n

.meas tran vdout1_451ck1840 FIND v(dout1_451) AT=925.025n

.meas tran vdout1_452ck1840 FIND v(dout1_452) AT=925.025n

.meas tran vdout1_453ck1840 FIND v(dout1_453) AT=925.025n

.meas tran vdout1_454ck1840 FIND v(dout1_454) AT=925.025n

.meas tran vdout1_455ck1840 FIND v(dout1_455) AT=925.025n

.meas tran vdout1_456ck1840 FIND v(dout1_456) AT=925.025n

.meas tran vdout1_457ck1840 FIND v(dout1_457) AT=925.025n

.meas tran vdout1_458ck1840 FIND v(dout1_458) AT=925.025n

.meas tran vdout1_459ck1840 FIND v(dout1_459) AT=925.025n

.meas tran vdout1_460ck1840 FIND v(dout1_460) AT=925.025n

.meas tran vdout1_461ck1840 FIND v(dout1_461) AT=925.025n

.meas tran vdout1_462ck1840 FIND v(dout1_462) AT=925.025n

.meas tran vdout1_463ck1840 FIND v(dout1_463) AT=925.025n

.meas tran vdout1_464ck1840 FIND v(dout1_464) AT=925.025n

.meas tran vdout1_465ck1840 FIND v(dout1_465) AT=925.025n

.meas tran vdout1_466ck1840 FIND v(dout1_466) AT=925.025n

.meas tran vdout1_467ck1840 FIND v(dout1_467) AT=925.025n

.meas tran vdout1_468ck1840 FIND v(dout1_468) AT=925.025n

.meas tran vdout1_469ck1840 FIND v(dout1_469) AT=925.025n

.meas tran vdout1_470ck1840 FIND v(dout1_470) AT=925.025n

.meas tran vdout1_471ck1840 FIND v(dout1_471) AT=925.025n

.meas tran vdout1_472ck1840 FIND v(dout1_472) AT=925.025n

.meas tran vdout1_473ck1840 FIND v(dout1_473) AT=925.025n

.meas tran vdout1_474ck1840 FIND v(dout1_474) AT=925.025n

.meas tran vdout1_475ck1840 FIND v(dout1_475) AT=925.025n

.meas tran vdout1_476ck1840 FIND v(dout1_476) AT=925.025n

.meas tran vdout1_477ck1840 FIND v(dout1_477) AT=925.025n

.meas tran vdout1_478ck1840 FIND v(dout1_478) AT=925.025n

.meas tran vdout1_479ck1840 FIND v(dout1_479) AT=925.025n

.meas tran vdout1_480ck1840 FIND v(dout1_480) AT=925.025n

.meas tran vdout1_481ck1840 FIND v(dout1_481) AT=925.025n

.meas tran vdout1_482ck1840 FIND v(dout1_482) AT=925.025n

.meas tran vdout1_483ck1840 FIND v(dout1_483) AT=925.025n

.meas tran vdout1_484ck1840 FIND v(dout1_484) AT=925.025n

.meas tran vdout1_485ck1840 FIND v(dout1_485) AT=925.025n

.meas tran vdout1_486ck1840 FIND v(dout1_486) AT=925.025n

.meas tran vdout1_487ck1840 FIND v(dout1_487) AT=925.025n

.meas tran vdout1_488ck1840 FIND v(dout1_488) AT=925.025n

.meas tran vdout1_489ck1840 FIND v(dout1_489) AT=925.025n

.meas tran vdout1_490ck1840 FIND v(dout1_490) AT=925.025n

.meas tran vdout1_491ck1840 FIND v(dout1_491) AT=925.025n

.meas tran vdout1_492ck1840 FIND v(dout1_492) AT=925.025n

.meas tran vdout1_493ck1840 FIND v(dout1_493) AT=925.025n

.meas tran vdout1_494ck1840 FIND v(dout1_494) AT=925.025n

.meas tran vdout1_495ck1840 FIND v(dout1_495) AT=925.025n

.meas tran vdout1_496ck1840 FIND v(dout1_496) AT=925.025n

.meas tran vdout1_497ck1840 FIND v(dout1_497) AT=925.025n

.meas tran vdout1_498ck1840 FIND v(dout1_498) AT=925.025n

.meas tran vdout1_499ck1840 FIND v(dout1_499) AT=925.025n

.meas tran vdout1_500ck1840 FIND v(dout1_500) AT=925.025n

.meas tran vdout1_501ck1840 FIND v(dout1_501) AT=925.025n

.meas tran vdout1_502ck1840 FIND v(dout1_502) AT=925.025n

.meas tran vdout1_503ck1840 FIND v(dout1_503) AT=925.025n

.meas tran vdout1_504ck1840 FIND v(dout1_504) AT=925.025n

.meas tran vdout1_505ck1840 FIND v(dout1_505) AT=925.025n

.meas tran vdout1_506ck1840 FIND v(dout1_506) AT=925.025n

.meas tran vdout1_507ck1840 FIND v(dout1_507) AT=925.025n

.meas tran vdout1_508ck1840 FIND v(dout1_508) AT=925.025n

.meas tran vdout1_509ck1840 FIND v(dout1_509) AT=925.025n

.meas tran vdout1_510ck1840 FIND v(dout1_510) AT=925.025n

.meas tran vdout1_511ck1840 FIND v(dout1_511) AT=925.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_17ck1930 FIND v(dout1_17) AT=970.025n

.meas tran vdout1_18ck1930 FIND v(dout1_18) AT=970.025n

.meas tran vdout1_19ck1930 FIND v(dout1_19) AT=970.025n

.meas tran vdout1_20ck1930 FIND v(dout1_20) AT=970.025n

.meas tran vdout1_21ck1930 FIND v(dout1_21) AT=970.025n

.meas tran vdout1_22ck1930 FIND v(dout1_22) AT=970.025n

.meas tran vdout1_23ck1930 FIND v(dout1_23) AT=970.025n

.meas tran vdout1_24ck1930 FIND v(dout1_24) AT=970.025n

.meas tran vdout1_25ck1930 FIND v(dout1_25) AT=970.025n

.meas tran vdout1_26ck1930 FIND v(dout1_26) AT=970.025n

.meas tran vdout1_27ck1930 FIND v(dout1_27) AT=970.025n

.meas tran vdout1_28ck1930 FIND v(dout1_28) AT=970.025n

.meas tran vdout1_29ck1930 FIND v(dout1_29) AT=970.025n

.meas tran vdout1_30ck1930 FIND v(dout1_30) AT=970.025n

.meas tran vdout1_31ck1930 FIND v(dout1_31) AT=970.025n

.meas tran vdout1_32ck1930 FIND v(dout1_32) AT=970.025n

.meas tran vdout1_33ck1930 FIND v(dout1_33) AT=970.025n

.meas tran vdout1_34ck1930 FIND v(dout1_34) AT=970.025n

.meas tran vdout1_35ck1930 FIND v(dout1_35) AT=970.025n

.meas tran vdout1_36ck1930 FIND v(dout1_36) AT=970.025n

.meas tran vdout1_37ck1930 FIND v(dout1_37) AT=970.025n

.meas tran vdout1_38ck1930 FIND v(dout1_38) AT=970.025n

.meas tran vdout1_39ck1930 FIND v(dout1_39) AT=970.025n

.meas tran vdout1_40ck1930 FIND v(dout1_40) AT=970.025n

.meas tran vdout1_41ck1930 FIND v(dout1_41) AT=970.025n

.meas tran vdout1_42ck1930 FIND v(dout1_42) AT=970.025n

.meas tran vdout1_43ck1930 FIND v(dout1_43) AT=970.025n

.meas tran vdout1_44ck1930 FIND v(dout1_44) AT=970.025n

.meas tran vdout1_45ck1930 FIND v(dout1_45) AT=970.025n

.meas tran vdout1_46ck1930 FIND v(dout1_46) AT=970.025n

.meas tran vdout1_47ck1930 FIND v(dout1_47) AT=970.025n

.meas tran vdout1_48ck1930 FIND v(dout1_48) AT=970.025n

.meas tran vdout1_49ck1930 FIND v(dout1_49) AT=970.025n

.meas tran vdout1_50ck1930 FIND v(dout1_50) AT=970.025n

.meas tran vdout1_51ck1930 FIND v(dout1_51) AT=970.025n

.meas tran vdout1_52ck1930 FIND v(dout1_52) AT=970.025n

.meas tran vdout1_53ck1930 FIND v(dout1_53) AT=970.025n

.meas tran vdout1_54ck1930 FIND v(dout1_54) AT=970.025n

.meas tran vdout1_55ck1930 FIND v(dout1_55) AT=970.025n

.meas tran vdout1_56ck1930 FIND v(dout1_56) AT=970.025n

.meas tran vdout1_57ck1930 FIND v(dout1_57) AT=970.025n

.meas tran vdout1_58ck1930 FIND v(dout1_58) AT=970.025n

.meas tran vdout1_59ck1930 FIND v(dout1_59) AT=970.025n

.meas tran vdout1_60ck1930 FIND v(dout1_60) AT=970.025n

.meas tran vdout1_61ck1930 FIND v(dout1_61) AT=970.025n

.meas tran vdout1_62ck1930 FIND v(dout1_62) AT=970.025n

.meas tran vdout1_63ck1930 FIND v(dout1_63) AT=970.025n

.meas tran vdout1_64ck1930 FIND v(dout1_64) AT=970.025n

.meas tran vdout1_65ck1930 FIND v(dout1_65) AT=970.025n

.meas tran vdout1_66ck1930 FIND v(dout1_66) AT=970.025n

.meas tran vdout1_67ck1930 FIND v(dout1_67) AT=970.025n

.meas tran vdout1_68ck1930 FIND v(dout1_68) AT=970.025n

.meas tran vdout1_69ck1930 FIND v(dout1_69) AT=970.025n

.meas tran vdout1_70ck1930 FIND v(dout1_70) AT=970.025n

.meas tran vdout1_71ck1930 FIND v(dout1_71) AT=970.025n

.meas tran vdout1_72ck1930 FIND v(dout1_72) AT=970.025n

.meas tran vdout1_73ck1930 FIND v(dout1_73) AT=970.025n

.meas tran vdout1_74ck1930 FIND v(dout1_74) AT=970.025n

.meas tran vdout1_75ck1930 FIND v(dout1_75) AT=970.025n

.meas tran vdout1_76ck1930 FIND v(dout1_76) AT=970.025n

.meas tran vdout1_77ck1930 FIND v(dout1_77) AT=970.025n

.meas tran vdout1_78ck1930 FIND v(dout1_78) AT=970.025n

.meas tran vdout1_79ck1930 FIND v(dout1_79) AT=970.025n

.meas tran vdout1_80ck1930 FIND v(dout1_80) AT=970.025n

.meas tran vdout1_81ck1930 FIND v(dout1_81) AT=970.025n

.meas tran vdout1_82ck1930 FIND v(dout1_82) AT=970.025n

.meas tran vdout1_83ck1930 FIND v(dout1_83) AT=970.025n

.meas tran vdout1_84ck1930 FIND v(dout1_84) AT=970.025n

.meas tran vdout1_85ck1930 FIND v(dout1_85) AT=970.025n

.meas tran vdout1_86ck1930 FIND v(dout1_86) AT=970.025n

.meas tran vdout1_87ck1930 FIND v(dout1_87) AT=970.025n

.meas tran vdout1_88ck1930 FIND v(dout1_88) AT=970.025n

.meas tran vdout1_89ck1930 FIND v(dout1_89) AT=970.025n

.meas tran vdout1_90ck1930 FIND v(dout1_90) AT=970.025n

.meas tran vdout1_91ck1930 FIND v(dout1_91) AT=970.025n

.meas tran vdout1_92ck1930 FIND v(dout1_92) AT=970.025n

.meas tran vdout1_93ck1930 FIND v(dout1_93) AT=970.025n

.meas tran vdout1_94ck1930 FIND v(dout1_94) AT=970.025n

.meas tran vdout1_95ck1930 FIND v(dout1_95) AT=970.025n

.meas tran vdout1_96ck1930 FIND v(dout1_96) AT=970.025n

.meas tran vdout1_97ck1930 FIND v(dout1_97) AT=970.025n

.meas tran vdout1_98ck1930 FIND v(dout1_98) AT=970.025n

.meas tran vdout1_99ck1930 FIND v(dout1_99) AT=970.025n

.meas tran vdout1_100ck1930 FIND v(dout1_100) AT=970.025n

.meas tran vdout1_101ck1930 FIND v(dout1_101) AT=970.025n

.meas tran vdout1_102ck1930 FIND v(dout1_102) AT=970.025n

.meas tran vdout1_103ck1930 FIND v(dout1_103) AT=970.025n

.meas tran vdout1_104ck1930 FIND v(dout1_104) AT=970.025n

.meas tran vdout1_105ck1930 FIND v(dout1_105) AT=970.025n

.meas tran vdout1_106ck1930 FIND v(dout1_106) AT=970.025n

.meas tran vdout1_107ck1930 FIND v(dout1_107) AT=970.025n

.meas tran vdout1_108ck1930 FIND v(dout1_108) AT=970.025n

.meas tran vdout1_109ck1930 FIND v(dout1_109) AT=970.025n

.meas tran vdout1_110ck1930 FIND v(dout1_110) AT=970.025n

.meas tran vdout1_111ck1930 FIND v(dout1_111) AT=970.025n

.meas tran vdout1_112ck1930 FIND v(dout1_112) AT=970.025n

.meas tran vdout1_113ck1930 FIND v(dout1_113) AT=970.025n

.meas tran vdout1_114ck1930 FIND v(dout1_114) AT=970.025n

.meas tran vdout1_115ck1930 FIND v(dout1_115) AT=970.025n

.meas tran vdout1_116ck1930 FIND v(dout1_116) AT=970.025n

.meas tran vdout1_117ck1930 FIND v(dout1_117) AT=970.025n

.meas tran vdout1_118ck1930 FIND v(dout1_118) AT=970.025n

.meas tran vdout1_119ck1930 FIND v(dout1_119) AT=970.025n

.meas tran vdout1_120ck1930 FIND v(dout1_120) AT=970.025n

.meas tran vdout1_121ck1930 FIND v(dout1_121) AT=970.025n

.meas tran vdout1_122ck1930 FIND v(dout1_122) AT=970.025n

.meas tran vdout1_123ck1930 FIND v(dout1_123) AT=970.025n

.meas tran vdout1_124ck1930 FIND v(dout1_124) AT=970.025n

.meas tran vdout1_125ck1930 FIND v(dout1_125) AT=970.025n

.meas tran vdout1_126ck1930 FIND v(dout1_126) AT=970.025n

.meas tran vdout1_127ck1930 FIND v(dout1_127) AT=970.025n

.meas tran vdout1_128ck1930 FIND v(dout1_128) AT=970.025n

.meas tran vdout1_129ck1930 FIND v(dout1_129) AT=970.025n

.meas tran vdout1_130ck1930 FIND v(dout1_130) AT=970.025n

.meas tran vdout1_131ck1930 FIND v(dout1_131) AT=970.025n

.meas tran vdout1_132ck1930 FIND v(dout1_132) AT=970.025n

.meas tran vdout1_133ck1930 FIND v(dout1_133) AT=970.025n

.meas tran vdout1_134ck1930 FIND v(dout1_134) AT=970.025n

.meas tran vdout1_135ck1930 FIND v(dout1_135) AT=970.025n

.meas tran vdout1_136ck1930 FIND v(dout1_136) AT=970.025n

.meas tran vdout1_137ck1930 FIND v(dout1_137) AT=970.025n

.meas tran vdout1_138ck1930 FIND v(dout1_138) AT=970.025n

.meas tran vdout1_139ck1930 FIND v(dout1_139) AT=970.025n

.meas tran vdout1_140ck1930 FIND v(dout1_140) AT=970.025n

.meas tran vdout1_141ck1930 FIND v(dout1_141) AT=970.025n

.meas tran vdout1_142ck1930 FIND v(dout1_142) AT=970.025n

.meas tran vdout1_143ck1930 FIND v(dout1_143) AT=970.025n

.meas tran vdout1_144ck1930 FIND v(dout1_144) AT=970.025n

.meas tran vdout1_145ck1930 FIND v(dout1_145) AT=970.025n

.meas tran vdout1_146ck1930 FIND v(dout1_146) AT=970.025n

.meas tran vdout1_147ck1930 FIND v(dout1_147) AT=970.025n

.meas tran vdout1_148ck1930 FIND v(dout1_148) AT=970.025n

.meas tran vdout1_149ck1930 FIND v(dout1_149) AT=970.025n

.meas tran vdout1_150ck1930 FIND v(dout1_150) AT=970.025n

.meas tran vdout1_151ck1930 FIND v(dout1_151) AT=970.025n

.meas tran vdout1_152ck1930 FIND v(dout1_152) AT=970.025n

.meas tran vdout1_153ck1930 FIND v(dout1_153) AT=970.025n

.meas tran vdout1_154ck1930 FIND v(dout1_154) AT=970.025n

.meas tran vdout1_155ck1930 FIND v(dout1_155) AT=970.025n

.meas tran vdout1_156ck1930 FIND v(dout1_156) AT=970.025n

.meas tran vdout1_157ck1930 FIND v(dout1_157) AT=970.025n

.meas tran vdout1_158ck1930 FIND v(dout1_158) AT=970.025n

.meas tran vdout1_159ck1930 FIND v(dout1_159) AT=970.025n

.meas tran vdout1_160ck1930 FIND v(dout1_160) AT=970.025n

.meas tran vdout1_161ck1930 FIND v(dout1_161) AT=970.025n

.meas tran vdout1_162ck1930 FIND v(dout1_162) AT=970.025n

.meas tran vdout1_163ck1930 FIND v(dout1_163) AT=970.025n

.meas tran vdout1_164ck1930 FIND v(dout1_164) AT=970.025n

.meas tran vdout1_165ck1930 FIND v(dout1_165) AT=970.025n

.meas tran vdout1_166ck1930 FIND v(dout1_166) AT=970.025n

.meas tran vdout1_167ck1930 FIND v(dout1_167) AT=970.025n

.meas tran vdout1_168ck1930 FIND v(dout1_168) AT=970.025n

.meas tran vdout1_169ck1930 FIND v(dout1_169) AT=970.025n

.meas tran vdout1_170ck1930 FIND v(dout1_170) AT=970.025n

.meas tran vdout1_171ck1930 FIND v(dout1_171) AT=970.025n

.meas tran vdout1_172ck1930 FIND v(dout1_172) AT=970.025n

.meas tran vdout1_173ck1930 FIND v(dout1_173) AT=970.025n

.meas tran vdout1_174ck1930 FIND v(dout1_174) AT=970.025n

.meas tran vdout1_175ck1930 FIND v(dout1_175) AT=970.025n

.meas tran vdout1_176ck1930 FIND v(dout1_176) AT=970.025n

.meas tran vdout1_177ck1930 FIND v(dout1_177) AT=970.025n

.meas tran vdout1_178ck1930 FIND v(dout1_178) AT=970.025n

.meas tran vdout1_179ck1930 FIND v(dout1_179) AT=970.025n

.meas tran vdout1_180ck1930 FIND v(dout1_180) AT=970.025n

.meas tran vdout1_181ck1930 FIND v(dout1_181) AT=970.025n

.meas tran vdout1_182ck1930 FIND v(dout1_182) AT=970.025n

.meas tran vdout1_183ck1930 FIND v(dout1_183) AT=970.025n

.meas tran vdout1_184ck1930 FIND v(dout1_184) AT=970.025n

.meas tran vdout1_185ck1930 FIND v(dout1_185) AT=970.025n

.meas tran vdout1_186ck1930 FIND v(dout1_186) AT=970.025n

.meas tran vdout1_187ck1930 FIND v(dout1_187) AT=970.025n

.meas tran vdout1_188ck1930 FIND v(dout1_188) AT=970.025n

.meas tran vdout1_189ck1930 FIND v(dout1_189) AT=970.025n

.meas tran vdout1_190ck1930 FIND v(dout1_190) AT=970.025n

.meas tran vdout1_191ck1930 FIND v(dout1_191) AT=970.025n

.meas tran vdout1_192ck1930 FIND v(dout1_192) AT=970.025n

.meas tran vdout1_193ck1930 FIND v(dout1_193) AT=970.025n

.meas tran vdout1_194ck1930 FIND v(dout1_194) AT=970.025n

.meas tran vdout1_195ck1930 FIND v(dout1_195) AT=970.025n

.meas tran vdout1_196ck1930 FIND v(dout1_196) AT=970.025n

.meas tran vdout1_197ck1930 FIND v(dout1_197) AT=970.025n

.meas tran vdout1_198ck1930 FIND v(dout1_198) AT=970.025n

.meas tran vdout1_199ck1930 FIND v(dout1_199) AT=970.025n

.meas tran vdout1_200ck1930 FIND v(dout1_200) AT=970.025n

.meas tran vdout1_201ck1930 FIND v(dout1_201) AT=970.025n

.meas tran vdout1_202ck1930 FIND v(dout1_202) AT=970.025n

.meas tran vdout1_203ck1930 FIND v(dout1_203) AT=970.025n

.meas tran vdout1_204ck1930 FIND v(dout1_204) AT=970.025n

.meas tran vdout1_205ck1930 FIND v(dout1_205) AT=970.025n

.meas tran vdout1_206ck1930 FIND v(dout1_206) AT=970.025n

.meas tran vdout1_207ck1930 FIND v(dout1_207) AT=970.025n

.meas tran vdout1_208ck1930 FIND v(dout1_208) AT=970.025n

.meas tran vdout1_209ck1930 FIND v(dout1_209) AT=970.025n

.meas tran vdout1_210ck1930 FIND v(dout1_210) AT=970.025n

.meas tran vdout1_211ck1930 FIND v(dout1_211) AT=970.025n

.meas tran vdout1_212ck1930 FIND v(dout1_212) AT=970.025n

.meas tran vdout1_213ck1930 FIND v(dout1_213) AT=970.025n

.meas tran vdout1_214ck1930 FIND v(dout1_214) AT=970.025n

.meas tran vdout1_215ck1930 FIND v(dout1_215) AT=970.025n

.meas tran vdout1_216ck1930 FIND v(dout1_216) AT=970.025n

.meas tran vdout1_217ck1930 FIND v(dout1_217) AT=970.025n

.meas tran vdout1_218ck1930 FIND v(dout1_218) AT=970.025n

.meas tran vdout1_219ck1930 FIND v(dout1_219) AT=970.025n

.meas tran vdout1_220ck1930 FIND v(dout1_220) AT=970.025n

.meas tran vdout1_221ck1930 FIND v(dout1_221) AT=970.025n

.meas tran vdout1_222ck1930 FIND v(dout1_222) AT=970.025n

.meas tran vdout1_223ck1930 FIND v(dout1_223) AT=970.025n

.meas tran vdout1_224ck1930 FIND v(dout1_224) AT=970.025n

.meas tran vdout1_225ck1930 FIND v(dout1_225) AT=970.025n

.meas tran vdout1_226ck1930 FIND v(dout1_226) AT=970.025n

.meas tran vdout1_227ck1930 FIND v(dout1_227) AT=970.025n

.meas tran vdout1_228ck1930 FIND v(dout1_228) AT=970.025n

.meas tran vdout1_229ck1930 FIND v(dout1_229) AT=970.025n

.meas tran vdout1_230ck1930 FIND v(dout1_230) AT=970.025n

.meas tran vdout1_231ck1930 FIND v(dout1_231) AT=970.025n

.meas tran vdout1_232ck1930 FIND v(dout1_232) AT=970.025n

.meas tran vdout1_233ck1930 FIND v(dout1_233) AT=970.025n

.meas tran vdout1_234ck1930 FIND v(dout1_234) AT=970.025n

.meas tran vdout1_235ck1930 FIND v(dout1_235) AT=970.025n

.meas tran vdout1_236ck1930 FIND v(dout1_236) AT=970.025n

.meas tran vdout1_237ck1930 FIND v(dout1_237) AT=970.025n

.meas tran vdout1_238ck1930 FIND v(dout1_238) AT=970.025n

.meas tran vdout1_239ck1930 FIND v(dout1_239) AT=970.025n

.meas tran vdout1_240ck1930 FIND v(dout1_240) AT=970.025n

.meas tran vdout1_241ck1930 FIND v(dout1_241) AT=970.025n

.meas tran vdout1_242ck1930 FIND v(dout1_242) AT=970.025n

.meas tran vdout1_243ck1930 FIND v(dout1_243) AT=970.025n

.meas tran vdout1_244ck1930 FIND v(dout1_244) AT=970.025n

.meas tran vdout1_245ck1930 FIND v(dout1_245) AT=970.025n

.meas tran vdout1_246ck1930 FIND v(dout1_246) AT=970.025n

.meas tran vdout1_247ck1930 FIND v(dout1_247) AT=970.025n

.meas tran vdout1_248ck1930 FIND v(dout1_248) AT=970.025n

.meas tran vdout1_249ck1930 FIND v(dout1_249) AT=970.025n

.meas tran vdout1_250ck1930 FIND v(dout1_250) AT=970.025n

.meas tran vdout1_251ck1930 FIND v(dout1_251) AT=970.025n

.meas tran vdout1_252ck1930 FIND v(dout1_252) AT=970.025n

.meas tran vdout1_253ck1930 FIND v(dout1_253) AT=970.025n

.meas tran vdout1_254ck1930 FIND v(dout1_254) AT=970.025n

.meas tran vdout1_255ck1930 FIND v(dout1_255) AT=970.025n

.meas tran vdout1_256ck1930 FIND v(dout1_256) AT=970.025n

.meas tran vdout1_257ck1930 FIND v(dout1_257) AT=970.025n

.meas tran vdout1_258ck1930 FIND v(dout1_258) AT=970.025n

.meas tran vdout1_259ck1930 FIND v(dout1_259) AT=970.025n

.meas tran vdout1_260ck1930 FIND v(dout1_260) AT=970.025n

.meas tran vdout1_261ck1930 FIND v(dout1_261) AT=970.025n

.meas tran vdout1_262ck1930 FIND v(dout1_262) AT=970.025n

.meas tran vdout1_263ck1930 FIND v(dout1_263) AT=970.025n

.meas tran vdout1_264ck1930 FIND v(dout1_264) AT=970.025n

.meas tran vdout1_265ck1930 FIND v(dout1_265) AT=970.025n

.meas tran vdout1_266ck1930 FIND v(dout1_266) AT=970.025n

.meas tran vdout1_267ck1930 FIND v(dout1_267) AT=970.025n

.meas tran vdout1_268ck1930 FIND v(dout1_268) AT=970.025n

.meas tran vdout1_269ck1930 FIND v(dout1_269) AT=970.025n

.meas tran vdout1_270ck1930 FIND v(dout1_270) AT=970.025n

.meas tran vdout1_271ck1930 FIND v(dout1_271) AT=970.025n

.meas tran vdout1_272ck1930 FIND v(dout1_272) AT=970.025n

.meas tran vdout1_273ck1930 FIND v(dout1_273) AT=970.025n

.meas tran vdout1_274ck1930 FIND v(dout1_274) AT=970.025n

.meas tran vdout1_275ck1930 FIND v(dout1_275) AT=970.025n

.meas tran vdout1_276ck1930 FIND v(dout1_276) AT=970.025n

.meas tran vdout1_277ck1930 FIND v(dout1_277) AT=970.025n

.meas tran vdout1_278ck1930 FIND v(dout1_278) AT=970.025n

.meas tran vdout1_279ck1930 FIND v(dout1_279) AT=970.025n

.meas tran vdout1_280ck1930 FIND v(dout1_280) AT=970.025n

.meas tran vdout1_281ck1930 FIND v(dout1_281) AT=970.025n

.meas tran vdout1_282ck1930 FIND v(dout1_282) AT=970.025n

.meas tran vdout1_283ck1930 FIND v(dout1_283) AT=970.025n

.meas tran vdout1_284ck1930 FIND v(dout1_284) AT=970.025n

.meas tran vdout1_285ck1930 FIND v(dout1_285) AT=970.025n

.meas tran vdout1_286ck1930 FIND v(dout1_286) AT=970.025n

.meas tran vdout1_287ck1930 FIND v(dout1_287) AT=970.025n

.meas tran vdout1_288ck1930 FIND v(dout1_288) AT=970.025n

.meas tran vdout1_289ck1930 FIND v(dout1_289) AT=970.025n

.meas tran vdout1_290ck1930 FIND v(dout1_290) AT=970.025n

.meas tran vdout1_291ck1930 FIND v(dout1_291) AT=970.025n

.meas tran vdout1_292ck1930 FIND v(dout1_292) AT=970.025n

.meas tran vdout1_293ck1930 FIND v(dout1_293) AT=970.025n

.meas tran vdout1_294ck1930 FIND v(dout1_294) AT=970.025n

.meas tran vdout1_295ck1930 FIND v(dout1_295) AT=970.025n

.meas tran vdout1_296ck1930 FIND v(dout1_296) AT=970.025n

.meas tran vdout1_297ck1930 FIND v(dout1_297) AT=970.025n

.meas tran vdout1_298ck1930 FIND v(dout1_298) AT=970.025n

.meas tran vdout1_299ck1930 FIND v(dout1_299) AT=970.025n

.meas tran vdout1_300ck1930 FIND v(dout1_300) AT=970.025n

.meas tran vdout1_301ck1930 FIND v(dout1_301) AT=970.025n

.meas tran vdout1_302ck1930 FIND v(dout1_302) AT=970.025n

.meas tran vdout1_303ck1930 FIND v(dout1_303) AT=970.025n

.meas tran vdout1_304ck1930 FIND v(dout1_304) AT=970.025n

.meas tran vdout1_305ck1930 FIND v(dout1_305) AT=970.025n

.meas tran vdout1_306ck1930 FIND v(dout1_306) AT=970.025n

.meas tran vdout1_307ck1930 FIND v(dout1_307) AT=970.025n

.meas tran vdout1_308ck1930 FIND v(dout1_308) AT=970.025n

.meas tran vdout1_309ck1930 FIND v(dout1_309) AT=970.025n

.meas tran vdout1_310ck1930 FIND v(dout1_310) AT=970.025n

.meas tran vdout1_311ck1930 FIND v(dout1_311) AT=970.025n

.meas tran vdout1_312ck1930 FIND v(dout1_312) AT=970.025n

.meas tran vdout1_313ck1930 FIND v(dout1_313) AT=970.025n

.meas tran vdout1_314ck1930 FIND v(dout1_314) AT=970.025n

.meas tran vdout1_315ck1930 FIND v(dout1_315) AT=970.025n

.meas tran vdout1_316ck1930 FIND v(dout1_316) AT=970.025n

.meas tran vdout1_317ck1930 FIND v(dout1_317) AT=970.025n

.meas tran vdout1_318ck1930 FIND v(dout1_318) AT=970.025n

.meas tran vdout1_319ck1930 FIND v(dout1_319) AT=970.025n

.meas tran vdout1_320ck1930 FIND v(dout1_320) AT=970.025n

.meas tran vdout1_321ck1930 FIND v(dout1_321) AT=970.025n

.meas tran vdout1_322ck1930 FIND v(dout1_322) AT=970.025n

.meas tran vdout1_323ck1930 FIND v(dout1_323) AT=970.025n

.meas tran vdout1_324ck1930 FIND v(dout1_324) AT=970.025n

.meas tran vdout1_325ck1930 FIND v(dout1_325) AT=970.025n

.meas tran vdout1_326ck1930 FIND v(dout1_326) AT=970.025n

.meas tran vdout1_327ck1930 FIND v(dout1_327) AT=970.025n

.meas tran vdout1_328ck1930 FIND v(dout1_328) AT=970.025n

.meas tran vdout1_329ck1930 FIND v(dout1_329) AT=970.025n

.meas tran vdout1_330ck1930 FIND v(dout1_330) AT=970.025n

.meas tran vdout1_331ck1930 FIND v(dout1_331) AT=970.025n

.meas tran vdout1_332ck1930 FIND v(dout1_332) AT=970.025n

.meas tran vdout1_333ck1930 FIND v(dout1_333) AT=970.025n

.meas tran vdout1_334ck1930 FIND v(dout1_334) AT=970.025n

.meas tran vdout1_335ck1930 FIND v(dout1_335) AT=970.025n

.meas tran vdout1_336ck1930 FIND v(dout1_336) AT=970.025n

.meas tran vdout1_337ck1930 FIND v(dout1_337) AT=970.025n

.meas tran vdout1_338ck1930 FIND v(dout1_338) AT=970.025n

.meas tran vdout1_339ck1930 FIND v(dout1_339) AT=970.025n

.meas tran vdout1_340ck1930 FIND v(dout1_340) AT=970.025n

.meas tran vdout1_341ck1930 FIND v(dout1_341) AT=970.025n

.meas tran vdout1_342ck1930 FIND v(dout1_342) AT=970.025n

.meas tran vdout1_343ck1930 FIND v(dout1_343) AT=970.025n

.meas tran vdout1_344ck1930 FIND v(dout1_344) AT=970.025n

.meas tran vdout1_345ck1930 FIND v(dout1_345) AT=970.025n

.meas tran vdout1_346ck1930 FIND v(dout1_346) AT=970.025n

.meas tran vdout1_347ck1930 FIND v(dout1_347) AT=970.025n

.meas tran vdout1_348ck1930 FIND v(dout1_348) AT=970.025n

.meas tran vdout1_349ck1930 FIND v(dout1_349) AT=970.025n

.meas tran vdout1_350ck1930 FIND v(dout1_350) AT=970.025n

.meas tran vdout1_351ck1930 FIND v(dout1_351) AT=970.025n

.meas tran vdout1_352ck1930 FIND v(dout1_352) AT=970.025n

.meas tran vdout1_353ck1930 FIND v(dout1_353) AT=970.025n

.meas tran vdout1_354ck1930 FIND v(dout1_354) AT=970.025n

.meas tran vdout1_355ck1930 FIND v(dout1_355) AT=970.025n

.meas tran vdout1_356ck1930 FIND v(dout1_356) AT=970.025n

.meas tran vdout1_357ck1930 FIND v(dout1_357) AT=970.025n

.meas tran vdout1_358ck1930 FIND v(dout1_358) AT=970.025n

.meas tran vdout1_359ck1930 FIND v(dout1_359) AT=970.025n

.meas tran vdout1_360ck1930 FIND v(dout1_360) AT=970.025n

.meas tran vdout1_361ck1930 FIND v(dout1_361) AT=970.025n

.meas tran vdout1_362ck1930 FIND v(dout1_362) AT=970.025n

.meas tran vdout1_363ck1930 FIND v(dout1_363) AT=970.025n

.meas tran vdout1_364ck1930 FIND v(dout1_364) AT=970.025n

.meas tran vdout1_365ck1930 FIND v(dout1_365) AT=970.025n

.meas tran vdout1_366ck1930 FIND v(dout1_366) AT=970.025n

.meas tran vdout1_367ck1930 FIND v(dout1_367) AT=970.025n

.meas tran vdout1_368ck1930 FIND v(dout1_368) AT=970.025n

.meas tran vdout1_369ck1930 FIND v(dout1_369) AT=970.025n

.meas tran vdout1_370ck1930 FIND v(dout1_370) AT=970.025n

.meas tran vdout1_371ck1930 FIND v(dout1_371) AT=970.025n

.meas tran vdout1_372ck1930 FIND v(dout1_372) AT=970.025n

.meas tran vdout1_373ck1930 FIND v(dout1_373) AT=970.025n

.meas tran vdout1_374ck1930 FIND v(dout1_374) AT=970.025n

.meas tran vdout1_375ck1930 FIND v(dout1_375) AT=970.025n

.meas tran vdout1_376ck1930 FIND v(dout1_376) AT=970.025n

.meas tran vdout1_377ck1930 FIND v(dout1_377) AT=970.025n

.meas tran vdout1_378ck1930 FIND v(dout1_378) AT=970.025n

.meas tran vdout1_379ck1930 FIND v(dout1_379) AT=970.025n

.meas tran vdout1_380ck1930 FIND v(dout1_380) AT=970.025n

.meas tran vdout1_381ck1930 FIND v(dout1_381) AT=970.025n

.meas tran vdout1_382ck1930 FIND v(dout1_382) AT=970.025n

.meas tran vdout1_383ck1930 FIND v(dout1_383) AT=970.025n

.meas tran vdout1_384ck1930 FIND v(dout1_384) AT=970.025n

.meas tran vdout1_385ck1930 FIND v(dout1_385) AT=970.025n

.meas tran vdout1_386ck1930 FIND v(dout1_386) AT=970.025n

.meas tran vdout1_387ck1930 FIND v(dout1_387) AT=970.025n

.meas tran vdout1_388ck1930 FIND v(dout1_388) AT=970.025n

.meas tran vdout1_389ck1930 FIND v(dout1_389) AT=970.025n

.meas tran vdout1_390ck1930 FIND v(dout1_390) AT=970.025n

.meas tran vdout1_391ck1930 FIND v(dout1_391) AT=970.025n

.meas tran vdout1_392ck1930 FIND v(dout1_392) AT=970.025n

.meas tran vdout1_393ck1930 FIND v(dout1_393) AT=970.025n

.meas tran vdout1_394ck1930 FIND v(dout1_394) AT=970.025n

.meas tran vdout1_395ck1930 FIND v(dout1_395) AT=970.025n

.meas tran vdout1_396ck1930 FIND v(dout1_396) AT=970.025n

.meas tran vdout1_397ck1930 FIND v(dout1_397) AT=970.025n

.meas tran vdout1_398ck1930 FIND v(dout1_398) AT=970.025n

.meas tran vdout1_399ck1930 FIND v(dout1_399) AT=970.025n

.meas tran vdout1_400ck1930 FIND v(dout1_400) AT=970.025n

.meas tran vdout1_401ck1930 FIND v(dout1_401) AT=970.025n

.meas tran vdout1_402ck1930 FIND v(dout1_402) AT=970.025n

.meas tran vdout1_403ck1930 FIND v(dout1_403) AT=970.025n

.meas tran vdout1_404ck1930 FIND v(dout1_404) AT=970.025n

.meas tran vdout1_405ck1930 FIND v(dout1_405) AT=970.025n

.meas tran vdout1_406ck1930 FIND v(dout1_406) AT=970.025n

.meas tran vdout1_407ck1930 FIND v(dout1_407) AT=970.025n

.meas tran vdout1_408ck1930 FIND v(dout1_408) AT=970.025n

.meas tran vdout1_409ck1930 FIND v(dout1_409) AT=970.025n

.meas tran vdout1_410ck1930 FIND v(dout1_410) AT=970.025n

.meas tran vdout1_411ck1930 FIND v(dout1_411) AT=970.025n

.meas tran vdout1_412ck1930 FIND v(dout1_412) AT=970.025n

.meas tran vdout1_413ck1930 FIND v(dout1_413) AT=970.025n

.meas tran vdout1_414ck1930 FIND v(dout1_414) AT=970.025n

.meas tran vdout1_415ck1930 FIND v(dout1_415) AT=970.025n

.meas tran vdout1_416ck1930 FIND v(dout1_416) AT=970.025n

.meas tran vdout1_417ck1930 FIND v(dout1_417) AT=970.025n

.meas tran vdout1_418ck1930 FIND v(dout1_418) AT=970.025n

.meas tran vdout1_419ck1930 FIND v(dout1_419) AT=970.025n

.meas tran vdout1_420ck1930 FIND v(dout1_420) AT=970.025n

.meas tran vdout1_421ck1930 FIND v(dout1_421) AT=970.025n

.meas tran vdout1_422ck1930 FIND v(dout1_422) AT=970.025n

.meas tran vdout1_423ck1930 FIND v(dout1_423) AT=970.025n

.meas tran vdout1_424ck1930 FIND v(dout1_424) AT=970.025n

.meas tran vdout1_425ck1930 FIND v(dout1_425) AT=970.025n

.meas tran vdout1_426ck1930 FIND v(dout1_426) AT=970.025n

.meas tran vdout1_427ck1930 FIND v(dout1_427) AT=970.025n

.meas tran vdout1_428ck1930 FIND v(dout1_428) AT=970.025n

.meas tran vdout1_429ck1930 FIND v(dout1_429) AT=970.025n

.meas tran vdout1_430ck1930 FIND v(dout1_430) AT=970.025n

.meas tran vdout1_431ck1930 FIND v(dout1_431) AT=970.025n

.meas tran vdout1_432ck1930 FIND v(dout1_432) AT=970.025n

.meas tran vdout1_433ck1930 FIND v(dout1_433) AT=970.025n

.meas tran vdout1_434ck1930 FIND v(dout1_434) AT=970.025n

.meas tran vdout1_435ck1930 FIND v(dout1_435) AT=970.025n

.meas tran vdout1_436ck1930 FIND v(dout1_436) AT=970.025n

.meas tran vdout1_437ck1930 FIND v(dout1_437) AT=970.025n

.meas tran vdout1_438ck1930 FIND v(dout1_438) AT=970.025n

.meas tran vdout1_439ck1930 FIND v(dout1_439) AT=970.025n

.meas tran vdout1_440ck1930 FIND v(dout1_440) AT=970.025n

.meas tran vdout1_441ck1930 FIND v(dout1_441) AT=970.025n

.meas tran vdout1_442ck1930 FIND v(dout1_442) AT=970.025n

.meas tran vdout1_443ck1930 FIND v(dout1_443) AT=970.025n

.meas tran vdout1_444ck1930 FIND v(dout1_444) AT=970.025n

.meas tran vdout1_445ck1930 FIND v(dout1_445) AT=970.025n

.meas tran vdout1_446ck1930 FIND v(dout1_446) AT=970.025n

.meas tran vdout1_447ck1930 FIND v(dout1_447) AT=970.025n

.meas tran vdout1_448ck1930 FIND v(dout1_448) AT=970.025n

.meas tran vdout1_449ck1930 FIND v(dout1_449) AT=970.025n

.meas tran vdout1_450ck1930 FIND v(dout1_450) AT=970.025n

.meas tran vdout1_451ck1930 FIND v(dout1_451) AT=970.025n

.meas tran vdout1_452ck1930 FIND v(dout1_452) AT=970.025n

.meas tran vdout1_453ck1930 FIND v(dout1_453) AT=970.025n

.meas tran vdout1_454ck1930 FIND v(dout1_454) AT=970.025n

.meas tran vdout1_455ck1930 FIND v(dout1_455) AT=970.025n

.meas tran vdout1_456ck1930 FIND v(dout1_456) AT=970.025n

.meas tran vdout1_457ck1930 FIND v(dout1_457) AT=970.025n

.meas tran vdout1_458ck1930 FIND v(dout1_458) AT=970.025n

.meas tran vdout1_459ck1930 FIND v(dout1_459) AT=970.025n

.meas tran vdout1_460ck1930 FIND v(dout1_460) AT=970.025n

.meas tran vdout1_461ck1930 FIND v(dout1_461) AT=970.025n

.meas tran vdout1_462ck1930 FIND v(dout1_462) AT=970.025n

.meas tran vdout1_463ck1930 FIND v(dout1_463) AT=970.025n

.meas tran vdout1_464ck1930 FIND v(dout1_464) AT=970.025n

.meas tran vdout1_465ck1930 FIND v(dout1_465) AT=970.025n

.meas tran vdout1_466ck1930 FIND v(dout1_466) AT=970.025n

.meas tran vdout1_467ck1930 FIND v(dout1_467) AT=970.025n

.meas tran vdout1_468ck1930 FIND v(dout1_468) AT=970.025n

.meas tran vdout1_469ck1930 FIND v(dout1_469) AT=970.025n

.meas tran vdout1_470ck1930 FIND v(dout1_470) AT=970.025n

.meas tran vdout1_471ck1930 FIND v(dout1_471) AT=970.025n

.meas tran vdout1_472ck1930 FIND v(dout1_472) AT=970.025n

.meas tran vdout1_473ck1930 FIND v(dout1_473) AT=970.025n

.meas tran vdout1_474ck1930 FIND v(dout1_474) AT=970.025n

.meas tran vdout1_475ck1930 FIND v(dout1_475) AT=970.025n

.meas tran vdout1_476ck1930 FIND v(dout1_476) AT=970.025n

.meas tran vdout1_477ck1930 FIND v(dout1_477) AT=970.025n

.meas tran vdout1_478ck1930 FIND v(dout1_478) AT=970.025n

.meas tran vdout1_479ck1930 FIND v(dout1_479) AT=970.025n

.meas tran vdout1_480ck1930 FIND v(dout1_480) AT=970.025n

.meas tran vdout1_481ck1930 FIND v(dout1_481) AT=970.025n

.meas tran vdout1_482ck1930 FIND v(dout1_482) AT=970.025n

.meas tran vdout1_483ck1930 FIND v(dout1_483) AT=970.025n

.meas tran vdout1_484ck1930 FIND v(dout1_484) AT=970.025n

.meas tran vdout1_485ck1930 FIND v(dout1_485) AT=970.025n

.meas tran vdout1_486ck1930 FIND v(dout1_486) AT=970.025n

.meas tran vdout1_487ck1930 FIND v(dout1_487) AT=970.025n

.meas tran vdout1_488ck1930 FIND v(dout1_488) AT=970.025n

.meas tran vdout1_489ck1930 FIND v(dout1_489) AT=970.025n

.meas tran vdout1_490ck1930 FIND v(dout1_490) AT=970.025n

.meas tran vdout1_491ck1930 FIND v(dout1_491) AT=970.025n

.meas tran vdout1_492ck1930 FIND v(dout1_492) AT=970.025n

.meas tran vdout1_493ck1930 FIND v(dout1_493) AT=970.025n

.meas tran vdout1_494ck1930 FIND v(dout1_494) AT=970.025n

.meas tran vdout1_495ck1930 FIND v(dout1_495) AT=970.025n

.meas tran vdout1_496ck1930 FIND v(dout1_496) AT=970.025n

.meas tran vdout1_497ck1930 FIND v(dout1_497) AT=970.025n

.meas tran vdout1_498ck1930 FIND v(dout1_498) AT=970.025n

.meas tran vdout1_499ck1930 FIND v(dout1_499) AT=970.025n

.meas tran vdout1_500ck1930 FIND v(dout1_500) AT=970.025n

.meas tran vdout1_501ck1930 FIND v(dout1_501) AT=970.025n

.meas tran vdout1_502ck1930 FIND v(dout1_502) AT=970.025n

.meas tran vdout1_503ck1930 FIND v(dout1_503) AT=970.025n

.meas tran vdout1_504ck1930 FIND v(dout1_504) AT=970.025n

.meas tran vdout1_505ck1930 FIND v(dout1_505) AT=970.025n

.meas tran vdout1_506ck1930 FIND v(dout1_506) AT=970.025n

.meas tran vdout1_507ck1930 FIND v(dout1_507) AT=970.025n

.meas tran vdout1_508ck1930 FIND v(dout1_508) AT=970.025n

.meas tran vdout1_509ck1930 FIND v(dout1_509) AT=970.025n

.meas tran vdout1_510ck1930 FIND v(dout1_510) AT=970.025n

.meas tran vdout1_511ck1930 FIND v(dout1_511) AT=970.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_32ck1940 FIND v(dout1_32) AT=975.025n

.meas tran vdout1_33ck1940 FIND v(dout1_33) AT=975.025n

.meas tran vdout1_34ck1940 FIND v(dout1_34) AT=975.025n

.meas tran vdout1_35ck1940 FIND v(dout1_35) AT=975.025n

.meas tran vdout1_36ck1940 FIND v(dout1_36) AT=975.025n

.meas tran vdout1_37ck1940 FIND v(dout1_37) AT=975.025n

.meas tran vdout1_38ck1940 FIND v(dout1_38) AT=975.025n

.meas tran vdout1_39ck1940 FIND v(dout1_39) AT=975.025n

.meas tran vdout1_40ck1940 FIND v(dout1_40) AT=975.025n

.meas tran vdout1_41ck1940 FIND v(dout1_41) AT=975.025n

.meas tran vdout1_42ck1940 FIND v(dout1_42) AT=975.025n

.meas tran vdout1_43ck1940 FIND v(dout1_43) AT=975.025n

.meas tran vdout1_44ck1940 FIND v(dout1_44) AT=975.025n

.meas tran vdout1_45ck1940 FIND v(dout1_45) AT=975.025n

.meas tran vdout1_46ck1940 FIND v(dout1_46) AT=975.025n

.meas tran vdout1_47ck1940 FIND v(dout1_47) AT=975.025n

.meas tran vdout1_48ck1940 FIND v(dout1_48) AT=975.025n

.meas tran vdout1_49ck1940 FIND v(dout1_49) AT=975.025n

.meas tran vdout1_50ck1940 FIND v(dout1_50) AT=975.025n

.meas tran vdout1_51ck1940 FIND v(dout1_51) AT=975.025n

.meas tran vdout1_52ck1940 FIND v(dout1_52) AT=975.025n

.meas tran vdout1_53ck1940 FIND v(dout1_53) AT=975.025n

.meas tran vdout1_54ck1940 FIND v(dout1_54) AT=975.025n

.meas tran vdout1_55ck1940 FIND v(dout1_55) AT=975.025n

.meas tran vdout1_56ck1940 FIND v(dout1_56) AT=975.025n

.meas tran vdout1_57ck1940 FIND v(dout1_57) AT=975.025n

.meas tran vdout1_58ck1940 FIND v(dout1_58) AT=975.025n

.meas tran vdout1_59ck1940 FIND v(dout1_59) AT=975.025n

.meas tran vdout1_60ck1940 FIND v(dout1_60) AT=975.025n

.meas tran vdout1_61ck1940 FIND v(dout1_61) AT=975.025n

.meas tran vdout1_62ck1940 FIND v(dout1_62) AT=975.025n

.meas tran vdout1_63ck1940 FIND v(dout1_63) AT=975.025n

.meas tran vdout1_64ck1940 FIND v(dout1_64) AT=975.025n

.meas tran vdout1_65ck1940 FIND v(dout1_65) AT=975.025n

.meas tran vdout1_66ck1940 FIND v(dout1_66) AT=975.025n

.meas tran vdout1_67ck1940 FIND v(dout1_67) AT=975.025n

.meas tran vdout1_68ck1940 FIND v(dout1_68) AT=975.025n

.meas tran vdout1_69ck1940 FIND v(dout1_69) AT=975.025n

.meas tran vdout1_70ck1940 FIND v(dout1_70) AT=975.025n

.meas tran vdout1_71ck1940 FIND v(dout1_71) AT=975.025n

.meas tran vdout1_72ck1940 FIND v(dout1_72) AT=975.025n

.meas tran vdout1_73ck1940 FIND v(dout1_73) AT=975.025n

.meas tran vdout1_74ck1940 FIND v(dout1_74) AT=975.025n

.meas tran vdout1_75ck1940 FIND v(dout1_75) AT=975.025n

.meas tran vdout1_76ck1940 FIND v(dout1_76) AT=975.025n

.meas tran vdout1_77ck1940 FIND v(dout1_77) AT=975.025n

.meas tran vdout1_78ck1940 FIND v(dout1_78) AT=975.025n

.meas tran vdout1_79ck1940 FIND v(dout1_79) AT=975.025n

.meas tran vdout1_80ck1940 FIND v(dout1_80) AT=975.025n

.meas tran vdout1_81ck1940 FIND v(dout1_81) AT=975.025n

.meas tran vdout1_82ck1940 FIND v(dout1_82) AT=975.025n

.meas tran vdout1_83ck1940 FIND v(dout1_83) AT=975.025n

.meas tran vdout1_84ck1940 FIND v(dout1_84) AT=975.025n

.meas tran vdout1_85ck1940 FIND v(dout1_85) AT=975.025n

.meas tran vdout1_86ck1940 FIND v(dout1_86) AT=975.025n

.meas tran vdout1_87ck1940 FIND v(dout1_87) AT=975.025n

.meas tran vdout1_88ck1940 FIND v(dout1_88) AT=975.025n

.meas tran vdout1_89ck1940 FIND v(dout1_89) AT=975.025n

.meas tran vdout1_90ck1940 FIND v(dout1_90) AT=975.025n

.meas tran vdout1_91ck1940 FIND v(dout1_91) AT=975.025n

.meas tran vdout1_92ck1940 FIND v(dout1_92) AT=975.025n

.meas tran vdout1_93ck1940 FIND v(dout1_93) AT=975.025n

.meas tran vdout1_94ck1940 FIND v(dout1_94) AT=975.025n

.meas tran vdout1_95ck1940 FIND v(dout1_95) AT=975.025n

.meas tran vdout1_96ck1940 FIND v(dout1_96) AT=975.025n

.meas tran vdout1_97ck1940 FIND v(dout1_97) AT=975.025n

.meas tran vdout1_98ck1940 FIND v(dout1_98) AT=975.025n

.meas tran vdout1_99ck1940 FIND v(dout1_99) AT=975.025n

.meas tran vdout1_100ck1940 FIND v(dout1_100) AT=975.025n

.meas tran vdout1_101ck1940 FIND v(dout1_101) AT=975.025n

.meas tran vdout1_102ck1940 FIND v(dout1_102) AT=975.025n

.meas tran vdout1_103ck1940 FIND v(dout1_103) AT=975.025n

.meas tran vdout1_104ck1940 FIND v(dout1_104) AT=975.025n

.meas tran vdout1_105ck1940 FIND v(dout1_105) AT=975.025n

.meas tran vdout1_106ck1940 FIND v(dout1_106) AT=975.025n

.meas tran vdout1_107ck1940 FIND v(dout1_107) AT=975.025n

.meas tran vdout1_108ck1940 FIND v(dout1_108) AT=975.025n

.meas tran vdout1_109ck1940 FIND v(dout1_109) AT=975.025n

.meas tran vdout1_110ck1940 FIND v(dout1_110) AT=975.025n

.meas tran vdout1_111ck1940 FIND v(dout1_111) AT=975.025n

.meas tran vdout1_112ck1940 FIND v(dout1_112) AT=975.025n

.meas tran vdout1_113ck1940 FIND v(dout1_113) AT=975.025n

.meas tran vdout1_114ck1940 FIND v(dout1_114) AT=975.025n

.meas tran vdout1_115ck1940 FIND v(dout1_115) AT=975.025n

.meas tran vdout1_116ck1940 FIND v(dout1_116) AT=975.025n

.meas tran vdout1_117ck1940 FIND v(dout1_117) AT=975.025n

.meas tran vdout1_118ck1940 FIND v(dout1_118) AT=975.025n

.meas tran vdout1_119ck1940 FIND v(dout1_119) AT=975.025n

.meas tran vdout1_120ck1940 FIND v(dout1_120) AT=975.025n

.meas tran vdout1_121ck1940 FIND v(dout1_121) AT=975.025n

.meas tran vdout1_122ck1940 FIND v(dout1_122) AT=975.025n

.meas tran vdout1_123ck1940 FIND v(dout1_123) AT=975.025n

.meas tran vdout1_124ck1940 FIND v(dout1_124) AT=975.025n

.meas tran vdout1_125ck1940 FIND v(dout1_125) AT=975.025n

.meas tran vdout1_126ck1940 FIND v(dout1_126) AT=975.025n

.meas tran vdout1_127ck1940 FIND v(dout1_127) AT=975.025n

.meas tran vdout1_128ck1940 FIND v(dout1_128) AT=975.025n

.meas tran vdout1_129ck1940 FIND v(dout1_129) AT=975.025n

.meas tran vdout1_130ck1940 FIND v(dout1_130) AT=975.025n

.meas tran vdout1_131ck1940 FIND v(dout1_131) AT=975.025n

.meas tran vdout1_132ck1940 FIND v(dout1_132) AT=975.025n

.meas tran vdout1_133ck1940 FIND v(dout1_133) AT=975.025n

.meas tran vdout1_134ck1940 FIND v(dout1_134) AT=975.025n

.meas tran vdout1_135ck1940 FIND v(dout1_135) AT=975.025n

.meas tran vdout1_136ck1940 FIND v(dout1_136) AT=975.025n

.meas tran vdout1_137ck1940 FIND v(dout1_137) AT=975.025n

.meas tran vdout1_138ck1940 FIND v(dout1_138) AT=975.025n

.meas tran vdout1_139ck1940 FIND v(dout1_139) AT=975.025n

.meas tran vdout1_140ck1940 FIND v(dout1_140) AT=975.025n

.meas tran vdout1_141ck1940 FIND v(dout1_141) AT=975.025n

.meas tran vdout1_142ck1940 FIND v(dout1_142) AT=975.025n

.meas tran vdout1_143ck1940 FIND v(dout1_143) AT=975.025n

.meas tran vdout1_144ck1940 FIND v(dout1_144) AT=975.025n

.meas tran vdout1_145ck1940 FIND v(dout1_145) AT=975.025n

.meas tran vdout1_146ck1940 FIND v(dout1_146) AT=975.025n

.meas tran vdout1_147ck1940 FIND v(dout1_147) AT=975.025n

.meas tran vdout1_148ck1940 FIND v(dout1_148) AT=975.025n

.meas tran vdout1_149ck1940 FIND v(dout1_149) AT=975.025n

.meas tran vdout1_150ck1940 FIND v(dout1_150) AT=975.025n

.meas tran vdout1_151ck1940 FIND v(dout1_151) AT=975.025n

.meas tran vdout1_152ck1940 FIND v(dout1_152) AT=975.025n

.meas tran vdout1_153ck1940 FIND v(dout1_153) AT=975.025n

.meas tran vdout1_154ck1940 FIND v(dout1_154) AT=975.025n

.meas tran vdout1_155ck1940 FIND v(dout1_155) AT=975.025n

.meas tran vdout1_156ck1940 FIND v(dout1_156) AT=975.025n

.meas tran vdout1_157ck1940 FIND v(dout1_157) AT=975.025n

.meas tran vdout1_158ck1940 FIND v(dout1_158) AT=975.025n

.meas tran vdout1_159ck1940 FIND v(dout1_159) AT=975.025n

.meas tran vdout1_160ck1940 FIND v(dout1_160) AT=975.025n

.meas tran vdout1_161ck1940 FIND v(dout1_161) AT=975.025n

.meas tran vdout1_162ck1940 FIND v(dout1_162) AT=975.025n

.meas tran vdout1_163ck1940 FIND v(dout1_163) AT=975.025n

.meas tran vdout1_164ck1940 FIND v(dout1_164) AT=975.025n

.meas tran vdout1_165ck1940 FIND v(dout1_165) AT=975.025n

.meas tran vdout1_166ck1940 FIND v(dout1_166) AT=975.025n

.meas tran vdout1_167ck1940 FIND v(dout1_167) AT=975.025n

.meas tran vdout1_168ck1940 FIND v(dout1_168) AT=975.025n

.meas tran vdout1_169ck1940 FIND v(dout1_169) AT=975.025n

.meas tran vdout1_170ck1940 FIND v(dout1_170) AT=975.025n

.meas tran vdout1_171ck1940 FIND v(dout1_171) AT=975.025n

.meas tran vdout1_172ck1940 FIND v(dout1_172) AT=975.025n

.meas tran vdout1_173ck1940 FIND v(dout1_173) AT=975.025n

.meas tran vdout1_174ck1940 FIND v(dout1_174) AT=975.025n

.meas tran vdout1_175ck1940 FIND v(dout1_175) AT=975.025n

.meas tran vdout1_176ck1940 FIND v(dout1_176) AT=975.025n

.meas tran vdout1_177ck1940 FIND v(dout1_177) AT=975.025n

.meas tran vdout1_178ck1940 FIND v(dout1_178) AT=975.025n

.meas tran vdout1_179ck1940 FIND v(dout1_179) AT=975.025n

.meas tran vdout1_180ck1940 FIND v(dout1_180) AT=975.025n

.meas tran vdout1_181ck1940 FIND v(dout1_181) AT=975.025n

.meas tran vdout1_182ck1940 FIND v(dout1_182) AT=975.025n

.meas tran vdout1_183ck1940 FIND v(dout1_183) AT=975.025n

.meas tran vdout1_184ck1940 FIND v(dout1_184) AT=975.025n

.meas tran vdout1_185ck1940 FIND v(dout1_185) AT=975.025n

.meas tran vdout1_186ck1940 FIND v(dout1_186) AT=975.025n

.meas tran vdout1_187ck1940 FIND v(dout1_187) AT=975.025n

.meas tran vdout1_188ck1940 FIND v(dout1_188) AT=975.025n

.meas tran vdout1_189ck1940 FIND v(dout1_189) AT=975.025n

.meas tran vdout1_190ck1940 FIND v(dout1_190) AT=975.025n

.meas tran vdout1_191ck1940 FIND v(dout1_191) AT=975.025n

.meas tran vdout1_192ck1940 FIND v(dout1_192) AT=975.025n

.meas tran vdout1_193ck1940 FIND v(dout1_193) AT=975.025n

.meas tran vdout1_194ck1940 FIND v(dout1_194) AT=975.025n

.meas tran vdout1_195ck1940 FIND v(dout1_195) AT=975.025n

.meas tran vdout1_196ck1940 FIND v(dout1_196) AT=975.025n

.meas tran vdout1_197ck1940 FIND v(dout1_197) AT=975.025n

.meas tran vdout1_198ck1940 FIND v(dout1_198) AT=975.025n

.meas tran vdout1_199ck1940 FIND v(dout1_199) AT=975.025n

.meas tran vdout1_200ck1940 FIND v(dout1_200) AT=975.025n

.meas tran vdout1_201ck1940 FIND v(dout1_201) AT=975.025n

.meas tran vdout1_202ck1940 FIND v(dout1_202) AT=975.025n

.meas tran vdout1_203ck1940 FIND v(dout1_203) AT=975.025n

.meas tran vdout1_204ck1940 FIND v(dout1_204) AT=975.025n

.meas tran vdout1_205ck1940 FIND v(dout1_205) AT=975.025n

.meas tran vdout1_206ck1940 FIND v(dout1_206) AT=975.025n

.meas tran vdout1_207ck1940 FIND v(dout1_207) AT=975.025n

.meas tran vdout1_208ck1940 FIND v(dout1_208) AT=975.025n

.meas tran vdout1_209ck1940 FIND v(dout1_209) AT=975.025n

.meas tran vdout1_210ck1940 FIND v(dout1_210) AT=975.025n

.meas tran vdout1_211ck1940 FIND v(dout1_211) AT=975.025n

.meas tran vdout1_212ck1940 FIND v(dout1_212) AT=975.025n

.meas tran vdout1_213ck1940 FIND v(dout1_213) AT=975.025n

.meas tran vdout1_214ck1940 FIND v(dout1_214) AT=975.025n

.meas tran vdout1_215ck1940 FIND v(dout1_215) AT=975.025n

.meas tran vdout1_216ck1940 FIND v(dout1_216) AT=975.025n

.meas tran vdout1_217ck1940 FIND v(dout1_217) AT=975.025n

.meas tran vdout1_218ck1940 FIND v(dout1_218) AT=975.025n

.meas tran vdout1_219ck1940 FIND v(dout1_219) AT=975.025n

.meas tran vdout1_220ck1940 FIND v(dout1_220) AT=975.025n

.meas tran vdout1_221ck1940 FIND v(dout1_221) AT=975.025n

.meas tran vdout1_222ck1940 FIND v(dout1_222) AT=975.025n

.meas tran vdout1_223ck1940 FIND v(dout1_223) AT=975.025n

.meas tran vdout1_224ck1940 FIND v(dout1_224) AT=975.025n

.meas tran vdout1_225ck1940 FIND v(dout1_225) AT=975.025n

.meas tran vdout1_226ck1940 FIND v(dout1_226) AT=975.025n

.meas tran vdout1_227ck1940 FIND v(dout1_227) AT=975.025n

.meas tran vdout1_228ck1940 FIND v(dout1_228) AT=975.025n

.meas tran vdout1_229ck1940 FIND v(dout1_229) AT=975.025n

.meas tran vdout1_230ck1940 FIND v(dout1_230) AT=975.025n

.meas tran vdout1_231ck1940 FIND v(dout1_231) AT=975.025n

.meas tran vdout1_232ck1940 FIND v(dout1_232) AT=975.025n

.meas tran vdout1_233ck1940 FIND v(dout1_233) AT=975.025n

.meas tran vdout1_234ck1940 FIND v(dout1_234) AT=975.025n

.meas tran vdout1_235ck1940 FIND v(dout1_235) AT=975.025n

.meas tran vdout1_236ck1940 FIND v(dout1_236) AT=975.025n

.meas tran vdout1_237ck1940 FIND v(dout1_237) AT=975.025n

.meas tran vdout1_238ck1940 FIND v(dout1_238) AT=975.025n

.meas tran vdout1_239ck1940 FIND v(dout1_239) AT=975.025n

.meas tran vdout1_240ck1940 FIND v(dout1_240) AT=975.025n

.meas tran vdout1_241ck1940 FIND v(dout1_241) AT=975.025n

.meas tran vdout1_242ck1940 FIND v(dout1_242) AT=975.025n

.meas tran vdout1_243ck1940 FIND v(dout1_243) AT=975.025n

.meas tran vdout1_244ck1940 FIND v(dout1_244) AT=975.025n

.meas tran vdout1_245ck1940 FIND v(dout1_245) AT=975.025n

.meas tran vdout1_246ck1940 FIND v(dout1_246) AT=975.025n

.meas tran vdout1_247ck1940 FIND v(dout1_247) AT=975.025n

.meas tran vdout1_248ck1940 FIND v(dout1_248) AT=975.025n

.meas tran vdout1_249ck1940 FIND v(dout1_249) AT=975.025n

.meas tran vdout1_250ck1940 FIND v(dout1_250) AT=975.025n

.meas tran vdout1_251ck1940 FIND v(dout1_251) AT=975.025n

.meas tran vdout1_252ck1940 FIND v(dout1_252) AT=975.025n

.meas tran vdout1_253ck1940 FIND v(dout1_253) AT=975.025n

.meas tran vdout1_254ck1940 FIND v(dout1_254) AT=975.025n

.meas tran vdout1_255ck1940 FIND v(dout1_255) AT=975.025n

.meas tran vdout1_256ck1940 FIND v(dout1_256) AT=975.025n

.meas tran vdout1_257ck1940 FIND v(dout1_257) AT=975.025n

.meas tran vdout1_258ck1940 FIND v(dout1_258) AT=975.025n

.meas tran vdout1_259ck1940 FIND v(dout1_259) AT=975.025n

.meas tran vdout1_260ck1940 FIND v(dout1_260) AT=975.025n

.meas tran vdout1_261ck1940 FIND v(dout1_261) AT=975.025n

.meas tran vdout1_262ck1940 FIND v(dout1_262) AT=975.025n

.meas tran vdout1_263ck1940 FIND v(dout1_263) AT=975.025n

.meas tran vdout1_264ck1940 FIND v(dout1_264) AT=975.025n

.meas tran vdout1_265ck1940 FIND v(dout1_265) AT=975.025n

.meas tran vdout1_266ck1940 FIND v(dout1_266) AT=975.025n

.meas tran vdout1_267ck1940 FIND v(dout1_267) AT=975.025n

.meas tran vdout1_268ck1940 FIND v(dout1_268) AT=975.025n

.meas tran vdout1_269ck1940 FIND v(dout1_269) AT=975.025n

.meas tran vdout1_270ck1940 FIND v(dout1_270) AT=975.025n

.meas tran vdout1_271ck1940 FIND v(dout1_271) AT=975.025n

.meas tran vdout1_272ck1940 FIND v(dout1_272) AT=975.025n

.meas tran vdout1_273ck1940 FIND v(dout1_273) AT=975.025n

.meas tran vdout1_274ck1940 FIND v(dout1_274) AT=975.025n

.meas tran vdout1_275ck1940 FIND v(dout1_275) AT=975.025n

.meas tran vdout1_276ck1940 FIND v(dout1_276) AT=975.025n

.meas tran vdout1_277ck1940 FIND v(dout1_277) AT=975.025n

.meas tran vdout1_278ck1940 FIND v(dout1_278) AT=975.025n

.meas tran vdout1_279ck1940 FIND v(dout1_279) AT=975.025n

.meas tran vdout1_280ck1940 FIND v(dout1_280) AT=975.025n

.meas tran vdout1_281ck1940 FIND v(dout1_281) AT=975.025n

.meas tran vdout1_282ck1940 FIND v(dout1_282) AT=975.025n

.meas tran vdout1_283ck1940 FIND v(dout1_283) AT=975.025n

.meas tran vdout1_284ck1940 FIND v(dout1_284) AT=975.025n

.meas tran vdout1_285ck1940 FIND v(dout1_285) AT=975.025n

.meas tran vdout1_286ck1940 FIND v(dout1_286) AT=975.025n

.meas tran vdout1_287ck1940 FIND v(dout1_287) AT=975.025n

.meas tran vdout1_288ck1940 FIND v(dout1_288) AT=975.025n

.meas tran vdout1_289ck1940 FIND v(dout1_289) AT=975.025n

.meas tran vdout1_290ck1940 FIND v(dout1_290) AT=975.025n

.meas tran vdout1_291ck1940 FIND v(dout1_291) AT=975.025n

.meas tran vdout1_292ck1940 FIND v(dout1_292) AT=975.025n

.meas tran vdout1_293ck1940 FIND v(dout1_293) AT=975.025n

.meas tran vdout1_294ck1940 FIND v(dout1_294) AT=975.025n

.meas tran vdout1_295ck1940 FIND v(dout1_295) AT=975.025n

.meas tran vdout1_296ck1940 FIND v(dout1_296) AT=975.025n

.meas tran vdout1_297ck1940 FIND v(dout1_297) AT=975.025n

.meas tran vdout1_298ck1940 FIND v(dout1_298) AT=975.025n

.meas tran vdout1_299ck1940 FIND v(dout1_299) AT=975.025n

.meas tran vdout1_300ck1940 FIND v(dout1_300) AT=975.025n

.meas tran vdout1_301ck1940 FIND v(dout1_301) AT=975.025n

.meas tran vdout1_302ck1940 FIND v(dout1_302) AT=975.025n

.meas tran vdout1_303ck1940 FIND v(dout1_303) AT=975.025n

.meas tran vdout1_304ck1940 FIND v(dout1_304) AT=975.025n

.meas tran vdout1_305ck1940 FIND v(dout1_305) AT=975.025n

.meas tran vdout1_306ck1940 FIND v(dout1_306) AT=975.025n

.meas tran vdout1_307ck1940 FIND v(dout1_307) AT=975.025n

.meas tran vdout1_308ck1940 FIND v(dout1_308) AT=975.025n

.meas tran vdout1_309ck1940 FIND v(dout1_309) AT=975.025n

.meas tran vdout1_310ck1940 FIND v(dout1_310) AT=975.025n

.meas tran vdout1_311ck1940 FIND v(dout1_311) AT=975.025n

.meas tran vdout1_312ck1940 FIND v(dout1_312) AT=975.025n

.meas tran vdout1_313ck1940 FIND v(dout1_313) AT=975.025n

.meas tran vdout1_314ck1940 FIND v(dout1_314) AT=975.025n

.meas tran vdout1_315ck1940 FIND v(dout1_315) AT=975.025n

.meas tran vdout1_316ck1940 FIND v(dout1_316) AT=975.025n

.meas tran vdout1_317ck1940 FIND v(dout1_317) AT=975.025n

.meas tran vdout1_318ck1940 FIND v(dout1_318) AT=975.025n

.meas tran vdout1_319ck1940 FIND v(dout1_319) AT=975.025n

.meas tran vdout1_320ck1940 FIND v(dout1_320) AT=975.025n

.meas tran vdout1_321ck1940 FIND v(dout1_321) AT=975.025n

.meas tran vdout1_322ck1940 FIND v(dout1_322) AT=975.025n

.meas tran vdout1_323ck1940 FIND v(dout1_323) AT=975.025n

.meas tran vdout1_324ck1940 FIND v(dout1_324) AT=975.025n

.meas tran vdout1_325ck1940 FIND v(dout1_325) AT=975.025n

.meas tran vdout1_326ck1940 FIND v(dout1_326) AT=975.025n

.meas tran vdout1_327ck1940 FIND v(dout1_327) AT=975.025n

.meas tran vdout1_328ck1940 FIND v(dout1_328) AT=975.025n

.meas tran vdout1_329ck1940 FIND v(dout1_329) AT=975.025n

.meas tran vdout1_330ck1940 FIND v(dout1_330) AT=975.025n

.meas tran vdout1_331ck1940 FIND v(dout1_331) AT=975.025n

.meas tran vdout1_332ck1940 FIND v(dout1_332) AT=975.025n

.meas tran vdout1_333ck1940 FIND v(dout1_333) AT=975.025n

.meas tran vdout1_334ck1940 FIND v(dout1_334) AT=975.025n

.meas tran vdout1_335ck1940 FIND v(dout1_335) AT=975.025n

.meas tran vdout1_336ck1940 FIND v(dout1_336) AT=975.025n

.meas tran vdout1_337ck1940 FIND v(dout1_337) AT=975.025n

.meas tran vdout1_338ck1940 FIND v(dout1_338) AT=975.025n

.meas tran vdout1_339ck1940 FIND v(dout1_339) AT=975.025n

.meas tran vdout1_340ck1940 FIND v(dout1_340) AT=975.025n

.meas tran vdout1_341ck1940 FIND v(dout1_341) AT=975.025n

.meas tran vdout1_342ck1940 FIND v(dout1_342) AT=975.025n

.meas tran vdout1_343ck1940 FIND v(dout1_343) AT=975.025n

.meas tran vdout1_344ck1940 FIND v(dout1_344) AT=975.025n

.meas tran vdout1_345ck1940 FIND v(dout1_345) AT=975.025n

.meas tran vdout1_346ck1940 FIND v(dout1_346) AT=975.025n

.meas tran vdout1_347ck1940 FIND v(dout1_347) AT=975.025n

.meas tran vdout1_348ck1940 FIND v(dout1_348) AT=975.025n

.meas tran vdout1_349ck1940 FIND v(dout1_349) AT=975.025n

.meas tran vdout1_350ck1940 FIND v(dout1_350) AT=975.025n

.meas tran vdout1_351ck1940 FIND v(dout1_351) AT=975.025n

.meas tran vdout1_352ck1940 FIND v(dout1_352) AT=975.025n

.meas tran vdout1_353ck1940 FIND v(dout1_353) AT=975.025n

.meas tran vdout1_354ck1940 FIND v(dout1_354) AT=975.025n

.meas tran vdout1_355ck1940 FIND v(dout1_355) AT=975.025n

.meas tran vdout1_356ck1940 FIND v(dout1_356) AT=975.025n

.meas tran vdout1_357ck1940 FIND v(dout1_357) AT=975.025n

.meas tran vdout1_358ck1940 FIND v(dout1_358) AT=975.025n

.meas tran vdout1_359ck1940 FIND v(dout1_359) AT=975.025n

.meas tran vdout1_360ck1940 FIND v(dout1_360) AT=975.025n

.meas tran vdout1_361ck1940 FIND v(dout1_361) AT=975.025n

.meas tran vdout1_362ck1940 FIND v(dout1_362) AT=975.025n

.meas tran vdout1_363ck1940 FIND v(dout1_363) AT=975.025n

.meas tran vdout1_364ck1940 FIND v(dout1_364) AT=975.025n

.meas tran vdout1_365ck1940 FIND v(dout1_365) AT=975.025n

.meas tran vdout1_366ck1940 FIND v(dout1_366) AT=975.025n

.meas tran vdout1_367ck1940 FIND v(dout1_367) AT=975.025n

.meas tran vdout1_368ck1940 FIND v(dout1_368) AT=975.025n

.meas tran vdout1_369ck1940 FIND v(dout1_369) AT=975.025n

.meas tran vdout1_370ck1940 FIND v(dout1_370) AT=975.025n

.meas tran vdout1_371ck1940 FIND v(dout1_371) AT=975.025n

.meas tran vdout1_372ck1940 FIND v(dout1_372) AT=975.025n

.meas tran vdout1_373ck1940 FIND v(dout1_373) AT=975.025n

.meas tran vdout1_374ck1940 FIND v(dout1_374) AT=975.025n

.meas tran vdout1_375ck1940 FIND v(dout1_375) AT=975.025n

.meas tran vdout1_376ck1940 FIND v(dout1_376) AT=975.025n

.meas tran vdout1_377ck1940 FIND v(dout1_377) AT=975.025n

.meas tran vdout1_378ck1940 FIND v(dout1_378) AT=975.025n

.meas tran vdout1_379ck1940 FIND v(dout1_379) AT=975.025n

.meas tran vdout1_380ck1940 FIND v(dout1_380) AT=975.025n

.meas tran vdout1_381ck1940 FIND v(dout1_381) AT=975.025n

.meas tran vdout1_382ck1940 FIND v(dout1_382) AT=975.025n

.meas tran vdout1_383ck1940 FIND v(dout1_383) AT=975.025n

.meas tran vdout1_384ck1940 FIND v(dout1_384) AT=975.025n

.meas tran vdout1_385ck1940 FIND v(dout1_385) AT=975.025n

.meas tran vdout1_386ck1940 FIND v(dout1_386) AT=975.025n

.meas tran vdout1_387ck1940 FIND v(dout1_387) AT=975.025n

.meas tran vdout1_388ck1940 FIND v(dout1_388) AT=975.025n

.meas tran vdout1_389ck1940 FIND v(dout1_389) AT=975.025n

.meas tran vdout1_390ck1940 FIND v(dout1_390) AT=975.025n

.meas tran vdout1_391ck1940 FIND v(dout1_391) AT=975.025n

.meas tran vdout1_392ck1940 FIND v(dout1_392) AT=975.025n

.meas tran vdout1_393ck1940 FIND v(dout1_393) AT=975.025n

.meas tran vdout1_394ck1940 FIND v(dout1_394) AT=975.025n

.meas tran vdout1_395ck1940 FIND v(dout1_395) AT=975.025n

.meas tran vdout1_396ck1940 FIND v(dout1_396) AT=975.025n

.meas tran vdout1_397ck1940 FIND v(dout1_397) AT=975.025n

.meas tran vdout1_398ck1940 FIND v(dout1_398) AT=975.025n

.meas tran vdout1_399ck1940 FIND v(dout1_399) AT=975.025n

.meas tran vdout1_400ck1940 FIND v(dout1_400) AT=975.025n

.meas tran vdout1_401ck1940 FIND v(dout1_401) AT=975.025n

.meas tran vdout1_402ck1940 FIND v(dout1_402) AT=975.025n

.meas tran vdout1_403ck1940 FIND v(dout1_403) AT=975.025n

.meas tran vdout1_404ck1940 FIND v(dout1_404) AT=975.025n

.meas tran vdout1_405ck1940 FIND v(dout1_405) AT=975.025n

.meas tran vdout1_406ck1940 FIND v(dout1_406) AT=975.025n

.meas tran vdout1_407ck1940 FIND v(dout1_407) AT=975.025n

.meas tran vdout1_408ck1940 FIND v(dout1_408) AT=975.025n

.meas tran vdout1_409ck1940 FIND v(dout1_409) AT=975.025n

.meas tran vdout1_410ck1940 FIND v(dout1_410) AT=975.025n

.meas tran vdout1_411ck1940 FIND v(dout1_411) AT=975.025n

.meas tran vdout1_412ck1940 FIND v(dout1_412) AT=975.025n

.meas tran vdout1_413ck1940 FIND v(dout1_413) AT=975.025n

.meas tran vdout1_414ck1940 FIND v(dout1_414) AT=975.025n

.meas tran vdout1_415ck1940 FIND v(dout1_415) AT=975.025n

.meas tran vdout1_416ck1940 FIND v(dout1_416) AT=975.025n

.meas tran vdout1_417ck1940 FIND v(dout1_417) AT=975.025n

.meas tran vdout1_418ck1940 FIND v(dout1_418) AT=975.025n

.meas tran vdout1_419ck1940 FIND v(dout1_419) AT=975.025n

.meas tran vdout1_420ck1940 FIND v(dout1_420) AT=975.025n

.meas tran vdout1_421ck1940 FIND v(dout1_421) AT=975.025n

.meas tran vdout1_422ck1940 FIND v(dout1_422) AT=975.025n

.meas tran vdout1_423ck1940 FIND v(dout1_423) AT=975.025n

.meas tran vdout1_424ck1940 FIND v(dout1_424) AT=975.025n

.meas tran vdout1_425ck1940 FIND v(dout1_425) AT=975.025n

.meas tran vdout1_426ck1940 FIND v(dout1_426) AT=975.025n

.meas tran vdout1_427ck1940 FIND v(dout1_427) AT=975.025n

.meas tran vdout1_428ck1940 FIND v(dout1_428) AT=975.025n

.meas tran vdout1_429ck1940 FIND v(dout1_429) AT=975.025n

.meas tran vdout1_430ck1940 FIND v(dout1_430) AT=975.025n

.meas tran vdout1_431ck1940 FIND v(dout1_431) AT=975.025n

.meas tran vdout1_432ck1940 FIND v(dout1_432) AT=975.025n

.meas tran vdout1_433ck1940 FIND v(dout1_433) AT=975.025n

.meas tran vdout1_434ck1940 FIND v(dout1_434) AT=975.025n

.meas tran vdout1_435ck1940 FIND v(dout1_435) AT=975.025n

.meas tran vdout1_436ck1940 FIND v(dout1_436) AT=975.025n

.meas tran vdout1_437ck1940 FIND v(dout1_437) AT=975.025n

.meas tran vdout1_438ck1940 FIND v(dout1_438) AT=975.025n

.meas tran vdout1_439ck1940 FIND v(dout1_439) AT=975.025n

.meas tran vdout1_440ck1940 FIND v(dout1_440) AT=975.025n

.meas tran vdout1_441ck1940 FIND v(dout1_441) AT=975.025n

.meas tran vdout1_442ck1940 FIND v(dout1_442) AT=975.025n

.meas tran vdout1_443ck1940 FIND v(dout1_443) AT=975.025n

.meas tran vdout1_444ck1940 FIND v(dout1_444) AT=975.025n

.meas tran vdout1_445ck1940 FIND v(dout1_445) AT=975.025n

.meas tran vdout1_446ck1940 FIND v(dout1_446) AT=975.025n

.meas tran vdout1_447ck1940 FIND v(dout1_447) AT=975.025n

.meas tran vdout1_448ck1940 FIND v(dout1_448) AT=975.025n

.meas tran vdout1_449ck1940 FIND v(dout1_449) AT=975.025n

.meas tran vdout1_450ck1940 FIND v(dout1_450) AT=975.025n

.meas tran vdout1_451ck1940 FIND v(dout1_451) AT=975.025n

.meas tran vdout1_452ck1940 FIND v(dout1_452) AT=975.025n

.meas tran vdout1_453ck1940 FIND v(dout1_453) AT=975.025n

.meas tran vdout1_454ck1940 FIND v(dout1_454) AT=975.025n

.meas tran vdout1_455ck1940 FIND v(dout1_455) AT=975.025n

.meas tran vdout1_456ck1940 FIND v(dout1_456) AT=975.025n

.meas tran vdout1_457ck1940 FIND v(dout1_457) AT=975.025n

.meas tran vdout1_458ck1940 FIND v(dout1_458) AT=975.025n

.meas tran vdout1_459ck1940 FIND v(dout1_459) AT=975.025n

.meas tran vdout1_460ck1940 FIND v(dout1_460) AT=975.025n

.meas tran vdout1_461ck1940 FIND v(dout1_461) AT=975.025n

.meas tran vdout1_462ck1940 FIND v(dout1_462) AT=975.025n

.meas tran vdout1_463ck1940 FIND v(dout1_463) AT=975.025n

.meas tran vdout1_464ck1940 FIND v(dout1_464) AT=975.025n

.meas tran vdout1_465ck1940 FIND v(dout1_465) AT=975.025n

.meas tran vdout1_466ck1940 FIND v(dout1_466) AT=975.025n

.meas tran vdout1_467ck1940 FIND v(dout1_467) AT=975.025n

.meas tran vdout1_468ck1940 FIND v(dout1_468) AT=975.025n

.meas tran vdout1_469ck1940 FIND v(dout1_469) AT=975.025n

.meas tran vdout1_470ck1940 FIND v(dout1_470) AT=975.025n

.meas tran vdout1_471ck1940 FIND v(dout1_471) AT=975.025n

.meas tran vdout1_472ck1940 FIND v(dout1_472) AT=975.025n

.meas tran vdout1_473ck1940 FIND v(dout1_473) AT=975.025n

.meas tran vdout1_474ck1940 FIND v(dout1_474) AT=975.025n

.meas tran vdout1_475ck1940 FIND v(dout1_475) AT=975.025n

.meas tran vdout1_476ck1940 FIND v(dout1_476) AT=975.025n

.meas tran vdout1_477ck1940 FIND v(dout1_477) AT=975.025n

.meas tran vdout1_478ck1940 FIND v(dout1_478) AT=975.025n

.meas tran vdout1_479ck1940 FIND v(dout1_479) AT=975.025n

.meas tran vdout1_480ck1940 FIND v(dout1_480) AT=975.025n

.meas tran vdout1_481ck1940 FIND v(dout1_481) AT=975.025n

.meas tran vdout1_482ck1940 FIND v(dout1_482) AT=975.025n

.meas tran vdout1_483ck1940 FIND v(dout1_483) AT=975.025n

.meas tran vdout1_484ck1940 FIND v(dout1_484) AT=975.025n

.meas tran vdout1_485ck1940 FIND v(dout1_485) AT=975.025n

.meas tran vdout1_486ck1940 FIND v(dout1_486) AT=975.025n

.meas tran vdout1_487ck1940 FIND v(dout1_487) AT=975.025n

.meas tran vdout1_488ck1940 FIND v(dout1_488) AT=975.025n

.meas tran vdout1_489ck1940 FIND v(dout1_489) AT=975.025n

.meas tran vdout1_490ck1940 FIND v(dout1_490) AT=975.025n

.meas tran vdout1_491ck1940 FIND v(dout1_491) AT=975.025n

.meas tran vdout1_492ck1940 FIND v(dout1_492) AT=975.025n

.meas tran vdout1_493ck1940 FIND v(dout1_493) AT=975.025n

.meas tran vdout1_494ck1940 FIND v(dout1_494) AT=975.025n

.meas tran vdout1_495ck1940 FIND v(dout1_495) AT=975.025n

.meas tran vdout1_496ck1940 FIND v(dout1_496) AT=975.025n

.meas tran vdout1_497ck1940 FIND v(dout1_497) AT=975.025n

.meas tran vdout1_498ck1940 FIND v(dout1_498) AT=975.025n

.meas tran vdout1_499ck1940 FIND v(dout1_499) AT=975.025n

.meas tran vdout1_500ck1940 FIND v(dout1_500) AT=975.025n

.meas tran vdout1_501ck1940 FIND v(dout1_501) AT=975.025n

.meas tran vdout1_502ck1940 FIND v(dout1_502) AT=975.025n

.meas tran vdout1_503ck1940 FIND v(dout1_503) AT=975.025n

.meas tran vdout1_504ck1940 FIND v(dout1_504) AT=975.025n

.meas tran vdout1_505ck1940 FIND v(dout1_505) AT=975.025n

.meas tran vdout1_506ck1940 FIND v(dout1_506) AT=975.025n

.meas tran vdout1_507ck1940 FIND v(dout1_507) AT=975.025n

.meas tran vdout1_508ck1940 FIND v(dout1_508) AT=975.025n

.meas tran vdout1_509ck1940 FIND v(dout1_509) AT=975.025n

.meas tran vdout1_510ck1940 FIND v(dout1_510) AT=975.025n

.meas tran vdout1_511ck1940 FIND v(dout1_511) AT=975.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_22ck1950 FIND v(dout1_22) AT=980.025n

.meas tran vdout1_23ck1950 FIND v(dout1_23) AT=980.025n

.meas tran vdout1_24ck1950 FIND v(dout1_24) AT=980.025n

.meas tran vdout1_25ck1950 FIND v(dout1_25) AT=980.025n

.meas tran vdout1_26ck1950 FIND v(dout1_26) AT=980.025n

.meas tran vdout1_27ck1950 FIND v(dout1_27) AT=980.025n

.meas tran vdout1_28ck1950 FIND v(dout1_28) AT=980.025n

.meas tran vdout1_29ck1950 FIND v(dout1_29) AT=980.025n

.meas tran vdout1_30ck1950 FIND v(dout1_30) AT=980.025n

.meas tran vdout1_31ck1950 FIND v(dout1_31) AT=980.025n

.meas tran vdout1_32ck1950 FIND v(dout1_32) AT=980.025n

.meas tran vdout1_33ck1950 FIND v(dout1_33) AT=980.025n

.meas tran vdout1_34ck1950 FIND v(dout1_34) AT=980.025n

.meas tran vdout1_35ck1950 FIND v(dout1_35) AT=980.025n

.meas tran vdout1_36ck1950 FIND v(dout1_36) AT=980.025n

.meas tran vdout1_37ck1950 FIND v(dout1_37) AT=980.025n

.meas tran vdout1_38ck1950 FIND v(dout1_38) AT=980.025n

.meas tran vdout1_39ck1950 FIND v(dout1_39) AT=980.025n

.meas tran vdout1_40ck1950 FIND v(dout1_40) AT=980.025n

.meas tran vdout1_41ck1950 FIND v(dout1_41) AT=980.025n

.meas tran vdout1_42ck1950 FIND v(dout1_42) AT=980.025n

.meas tran vdout1_43ck1950 FIND v(dout1_43) AT=980.025n

.meas tran vdout1_44ck1950 FIND v(dout1_44) AT=980.025n

.meas tran vdout1_45ck1950 FIND v(dout1_45) AT=980.025n

.meas tran vdout1_46ck1950 FIND v(dout1_46) AT=980.025n

.meas tran vdout1_47ck1950 FIND v(dout1_47) AT=980.025n

.meas tran vdout1_48ck1950 FIND v(dout1_48) AT=980.025n

.meas tran vdout1_49ck1950 FIND v(dout1_49) AT=980.025n

.meas tran vdout1_50ck1950 FIND v(dout1_50) AT=980.025n

.meas tran vdout1_51ck1950 FIND v(dout1_51) AT=980.025n

.meas tran vdout1_52ck1950 FIND v(dout1_52) AT=980.025n

.meas tran vdout1_53ck1950 FIND v(dout1_53) AT=980.025n

.meas tran vdout1_54ck1950 FIND v(dout1_54) AT=980.025n

.meas tran vdout1_55ck1950 FIND v(dout1_55) AT=980.025n

.meas tran vdout1_56ck1950 FIND v(dout1_56) AT=980.025n

.meas tran vdout1_57ck1950 FIND v(dout1_57) AT=980.025n

.meas tran vdout1_58ck1950 FIND v(dout1_58) AT=980.025n

.meas tran vdout1_59ck1950 FIND v(dout1_59) AT=980.025n

.meas tran vdout1_60ck1950 FIND v(dout1_60) AT=980.025n

.meas tran vdout1_61ck1950 FIND v(dout1_61) AT=980.025n

.meas tran vdout1_62ck1950 FIND v(dout1_62) AT=980.025n

.meas tran vdout1_63ck1950 FIND v(dout1_63) AT=980.025n

.meas tran vdout1_64ck1950 FIND v(dout1_64) AT=980.025n

.meas tran vdout1_65ck1950 FIND v(dout1_65) AT=980.025n

.meas tran vdout1_66ck1950 FIND v(dout1_66) AT=980.025n

.meas tran vdout1_67ck1950 FIND v(dout1_67) AT=980.025n

.meas tran vdout1_68ck1950 FIND v(dout1_68) AT=980.025n

.meas tran vdout1_69ck1950 FIND v(dout1_69) AT=980.025n

.meas tran vdout1_70ck1950 FIND v(dout1_70) AT=980.025n

.meas tran vdout1_71ck1950 FIND v(dout1_71) AT=980.025n

.meas tran vdout1_72ck1950 FIND v(dout1_72) AT=980.025n

.meas tran vdout1_73ck1950 FIND v(dout1_73) AT=980.025n

.meas tran vdout1_74ck1950 FIND v(dout1_74) AT=980.025n

.meas tran vdout1_75ck1950 FIND v(dout1_75) AT=980.025n

.meas tran vdout1_76ck1950 FIND v(dout1_76) AT=980.025n

.meas tran vdout1_77ck1950 FIND v(dout1_77) AT=980.025n

.meas tran vdout1_78ck1950 FIND v(dout1_78) AT=980.025n

.meas tran vdout1_79ck1950 FIND v(dout1_79) AT=980.025n

.meas tran vdout1_80ck1950 FIND v(dout1_80) AT=980.025n

.meas tran vdout1_81ck1950 FIND v(dout1_81) AT=980.025n

.meas tran vdout1_82ck1950 FIND v(dout1_82) AT=980.025n

.meas tran vdout1_83ck1950 FIND v(dout1_83) AT=980.025n

.meas tran vdout1_84ck1950 FIND v(dout1_84) AT=980.025n

.meas tran vdout1_85ck1950 FIND v(dout1_85) AT=980.025n

.meas tran vdout1_86ck1950 FIND v(dout1_86) AT=980.025n

.meas tran vdout1_87ck1950 FIND v(dout1_87) AT=980.025n

.meas tran vdout1_88ck1950 FIND v(dout1_88) AT=980.025n

.meas tran vdout1_89ck1950 FIND v(dout1_89) AT=980.025n

.meas tran vdout1_90ck1950 FIND v(dout1_90) AT=980.025n

.meas tran vdout1_91ck1950 FIND v(dout1_91) AT=980.025n

.meas tran vdout1_92ck1950 FIND v(dout1_92) AT=980.025n

.meas tran vdout1_93ck1950 FIND v(dout1_93) AT=980.025n

.meas tran vdout1_94ck1950 FIND v(dout1_94) AT=980.025n

.meas tran vdout1_95ck1950 FIND v(dout1_95) AT=980.025n

.meas tran vdout1_96ck1950 FIND v(dout1_96) AT=980.025n

.meas tran vdout1_97ck1950 FIND v(dout1_97) AT=980.025n

.meas tran vdout1_98ck1950 FIND v(dout1_98) AT=980.025n

.meas tran vdout1_99ck1950 FIND v(dout1_99) AT=980.025n

.meas tran vdout1_100ck1950 FIND v(dout1_100) AT=980.025n

.meas tran vdout1_101ck1950 FIND v(dout1_101) AT=980.025n

.meas tran vdout1_102ck1950 FIND v(dout1_102) AT=980.025n

.meas tran vdout1_103ck1950 FIND v(dout1_103) AT=980.025n

.meas tran vdout1_104ck1950 FIND v(dout1_104) AT=980.025n

.meas tran vdout1_105ck1950 FIND v(dout1_105) AT=980.025n

.meas tran vdout1_106ck1950 FIND v(dout1_106) AT=980.025n

.meas tran vdout1_107ck1950 FIND v(dout1_107) AT=980.025n

.meas tran vdout1_108ck1950 FIND v(dout1_108) AT=980.025n

.meas tran vdout1_109ck1950 FIND v(dout1_109) AT=980.025n

.meas tran vdout1_110ck1950 FIND v(dout1_110) AT=980.025n

.meas tran vdout1_111ck1950 FIND v(dout1_111) AT=980.025n

.meas tran vdout1_112ck1950 FIND v(dout1_112) AT=980.025n

.meas tran vdout1_113ck1950 FIND v(dout1_113) AT=980.025n

.meas tran vdout1_114ck1950 FIND v(dout1_114) AT=980.025n

.meas tran vdout1_115ck1950 FIND v(dout1_115) AT=980.025n

.meas tran vdout1_116ck1950 FIND v(dout1_116) AT=980.025n

.meas tran vdout1_117ck1950 FIND v(dout1_117) AT=980.025n

.meas tran vdout1_118ck1950 FIND v(dout1_118) AT=980.025n

.meas tran vdout1_119ck1950 FIND v(dout1_119) AT=980.025n

.meas tran vdout1_120ck1950 FIND v(dout1_120) AT=980.025n

.meas tran vdout1_121ck1950 FIND v(dout1_121) AT=980.025n

.meas tran vdout1_122ck1950 FIND v(dout1_122) AT=980.025n

.meas tran vdout1_123ck1950 FIND v(dout1_123) AT=980.025n

.meas tran vdout1_124ck1950 FIND v(dout1_124) AT=980.025n

.meas tran vdout1_125ck1950 FIND v(dout1_125) AT=980.025n

.meas tran vdout1_126ck1950 FIND v(dout1_126) AT=980.025n

.meas tran vdout1_127ck1950 FIND v(dout1_127) AT=980.025n

.meas tran vdout1_128ck1950 FIND v(dout1_128) AT=980.025n

.meas tran vdout1_129ck1950 FIND v(dout1_129) AT=980.025n

.meas tran vdout1_130ck1950 FIND v(dout1_130) AT=980.025n

.meas tran vdout1_131ck1950 FIND v(dout1_131) AT=980.025n

.meas tran vdout1_132ck1950 FIND v(dout1_132) AT=980.025n

.meas tran vdout1_133ck1950 FIND v(dout1_133) AT=980.025n

.meas tran vdout1_134ck1950 FIND v(dout1_134) AT=980.025n

.meas tran vdout1_135ck1950 FIND v(dout1_135) AT=980.025n

.meas tran vdout1_136ck1950 FIND v(dout1_136) AT=980.025n

.meas tran vdout1_137ck1950 FIND v(dout1_137) AT=980.025n

.meas tran vdout1_138ck1950 FIND v(dout1_138) AT=980.025n

.meas tran vdout1_139ck1950 FIND v(dout1_139) AT=980.025n

.meas tran vdout1_140ck1950 FIND v(dout1_140) AT=980.025n

.meas tran vdout1_141ck1950 FIND v(dout1_141) AT=980.025n

.meas tran vdout1_142ck1950 FIND v(dout1_142) AT=980.025n

.meas tran vdout1_143ck1950 FIND v(dout1_143) AT=980.025n

.meas tran vdout1_144ck1950 FIND v(dout1_144) AT=980.025n

.meas tran vdout1_145ck1950 FIND v(dout1_145) AT=980.025n

.meas tran vdout1_146ck1950 FIND v(dout1_146) AT=980.025n

.meas tran vdout1_147ck1950 FIND v(dout1_147) AT=980.025n

.meas tran vdout1_148ck1950 FIND v(dout1_148) AT=980.025n

.meas tran vdout1_149ck1950 FIND v(dout1_149) AT=980.025n

.meas tran vdout1_150ck1950 FIND v(dout1_150) AT=980.025n

.meas tran vdout1_151ck1950 FIND v(dout1_151) AT=980.025n

.meas tran vdout1_152ck1950 FIND v(dout1_152) AT=980.025n

.meas tran vdout1_153ck1950 FIND v(dout1_153) AT=980.025n

.meas tran vdout1_154ck1950 FIND v(dout1_154) AT=980.025n

.meas tran vdout1_155ck1950 FIND v(dout1_155) AT=980.025n

.meas tran vdout1_156ck1950 FIND v(dout1_156) AT=980.025n

.meas tran vdout1_157ck1950 FIND v(dout1_157) AT=980.025n

.meas tran vdout1_158ck1950 FIND v(dout1_158) AT=980.025n

.meas tran vdout1_159ck1950 FIND v(dout1_159) AT=980.025n

.meas tran vdout1_160ck1950 FIND v(dout1_160) AT=980.025n

.meas tran vdout1_161ck1950 FIND v(dout1_161) AT=980.025n

.meas tran vdout1_162ck1950 FIND v(dout1_162) AT=980.025n

.meas tran vdout1_163ck1950 FIND v(dout1_163) AT=980.025n

.meas tran vdout1_164ck1950 FIND v(dout1_164) AT=980.025n

.meas tran vdout1_165ck1950 FIND v(dout1_165) AT=980.025n

.meas tran vdout1_166ck1950 FIND v(dout1_166) AT=980.025n

.meas tran vdout1_167ck1950 FIND v(dout1_167) AT=980.025n

.meas tran vdout1_168ck1950 FIND v(dout1_168) AT=980.025n

.meas tran vdout1_169ck1950 FIND v(dout1_169) AT=980.025n

.meas tran vdout1_170ck1950 FIND v(dout1_170) AT=980.025n

.meas tran vdout1_171ck1950 FIND v(dout1_171) AT=980.025n

.meas tran vdout1_172ck1950 FIND v(dout1_172) AT=980.025n

.meas tran vdout1_173ck1950 FIND v(dout1_173) AT=980.025n

.meas tran vdout1_174ck1950 FIND v(dout1_174) AT=980.025n

.meas tran vdout1_175ck1950 FIND v(dout1_175) AT=980.025n

.meas tran vdout1_176ck1950 FIND v(dout1_176) AT=980.025n

.meas tran vdout1_177ck1950 FIND v(dout1_177) AT=980.025n

.meas tran vdout1_178ck1950 FIND v(dout1_178) AT=980.025n

.meas tran vdout1_179ck1950 FIND v(dout1_179) AT=980.025n

.meas tran vdout1_180ck1950 FIND v(dout1_180) AT=980.025n

.meas tran vdout1_181ck1950 FIND v(dout1_181) AT=980.025n

.meas tran vdout1_182ck1950 FIND v(dout1_182) AT=980.025n

.meas tran vdout1_183ck1950 FIND v(dout1_183) AT=980.025n

.meas tran vdout1_184ck1950 FIND v(dout1_184) AT=980.025n

.meas tran vdout1_185ck1950 FIND v(dout1_185) AT=980.025n

.meas tran vdout1_186ck1950 FIND v(dout1_186) AT=980.025n

.meas tran vdout1_187ck1950 FIND v(dout1_187) AT=980.025n

.meas tran vdout1_188ck1950 FIND v(dout1_188) AT=980.025n

.meas tran vdout1_189ck1950 FIND v(dout1_189) AT=980.025n

.meas tran vdout1_190ck1950 FIND v(dout1_190) AT=980.025n

.meas tran vdout1_191ck1950 FIND v(dout1_191) AT=980.025n

.meas tran vdout1_192ck1950 FIND v(dout1_192) AT=980.025n

.meas tran vdout1_193ck1950 FIND v(dout1_193) AT=980.025n

.meas tran vdout1_194ck1950 FIND v(dout1_194) AT=980.025n

.meas tran vdout1_195ck1950 FIND v(dout1_195) AT=980.025n

.meas tran vdout1_196ck1950 FIND v(dout1_196) AT=980.025n

.meas tran vdout1_197ck1950 FIND v(dout1_197) AT=980.025n

.meas tran vdout1_198ck1950 FIND v(dout1_198) AT=980.025n

.meas tran vdout1_199ck1950 FIND v(dout1_199) AT=980.025n

.meas tran vdout1_200ck1950 FIND v(dout1_200) AT=980.025n

.meas tran vdout1_201ck1950 FIND v(dout1_201) AT=980.025n

.meas tran vdout1_202ck1950 FIND v(dout1_202) AT=980.025n

.meas tran vdout1_203ck1950 FIND v(dout1_203) AT=980.025n

.meas tran vdout1_204ck1950 FIND v(dout1_204) AT=980.025n

.meas tran vdout1_205ck1950 FIND v(dout1_205) AT=980.025n

.meas tran vdout1_206ck1950 FIND v(dout1_206) AT=980.025n

.meas tran vdout1_207ck1950 FIND v(dout1_207) AT=980.025n

.meas tran vdout1_208ck1950 FIND v(dout1_208) AT=980.025n

.meas tran vdout1_209ck1950 FIND v(dout1_209) AT=980.025n

.meas tran vdout1_210ck1950 FIND v(dout1_210) AT=980.025n

.meas tran vdout1_211ck1950 FIND v(dout1_211) AT=980.025n

.meas tran vdout1_212ck1950 FIND v(dout1_212) AT=980.025n

.meas tran vdout1_213ck1950 FIND v(dout1_213) AT=980.025n

.meas tran vdout1_214ck1950 FIND v(dout1_214) AT=980.025n

.meas tran vdout1_215ck1950 FIND v(dout1_215) AT=980.025n

.meas tran vdout1_216ck1950 FIND v(dout1_216) AT=980.025n

.meas tran vdout1_217ck1950 FIND v(dout1_217) AT=980.025n

.meas tran vdout1_218ck1950 FIND v(dout1_218) AT=980.025n

.meas tran vdout1_219ck1950 FIND v(dout1_219) AT=980.025n

.meas tran vdout1_220ck1950 FIND v(dout1_220) AT=980.025n

.meas tran vdout1_221ck1950 FIND v(dout1_221) AT=980.025n

.meas tran vdout1_222ck1950 FIND v(dout1_222) AT=980.025n

.meas tran vdout1_223ck1950 FIND v(dout1_223) AT=980.025n

.meas tran vdout1_224ck1950 FIND v(dout1_224) AT=980.025n

.meas tran vdout1_225ck1950 FIND v(dout1_225) AT=980.025n

.meas tran vdout1_226ck1950 FIND v(dout1_226) AT=980.025n

.meas tran vdout1_227ck1950 FIND v(dout1_227) AT=980.025n

.meas tran vdout1_228ck1950 FIND v(dout1_228) AT=980.025n

.meas tran vdout1_229ck1950 FIND v(dout1_229) AT=980.025n

.meas tran vdout1_230ck1950 FIND v(dout1_230) AT=980.025n

.meas tran vdout1_231ck1950 FIND v(dout1_231) AT=980.025n

.meas tran vdout1_232ck1950 FIND v(dout1_232) AT=980.025n

.meas tran vdout1_233ck1950 FIND v(dout1_233) AT=980.025n

.meas tran vdout1_234ck1950 FIND v(dout1_234) AT=980.025n

.meas tran vdout1_235ck1950 FIND v(dout1_235) AT=980.025n

.meas tran vdout1_236ck1950 FIND v(dout1_236) AT=980.025n

.meas tran vdout1_237ck1950 FIND v(dout1_237) AT=980.025n

.meas tran vdout1_238ck1950 FIND v(dout1_238) AT=980.025n

.meas tran vdout1_239ck1950 FIND v(dout1_239) AT=980.025n

.meas tran vdout1_240ck1950 FIND v(dout1_240) AT=980.025n

.meas tran vdout1_241ck1950 FIND v(dout1_241) AT=980.025n

.meas tran vdout1_242ck1950 FIND v(dout1_242) AT=980.025n

.meas tran vdout1_243ck1950 FIND v(dout1_243) AT=980.025n

.meas tran vdout1_244ck1950 FIND v(dout1_244) AT=980.025n

.meas tran vdout1_245ck1950 FIND v(dout1_245) AT=980.025n

.meas tran vdout1_246ck1950 FIND v(dout1_246) AT=980.025n

.meas tran vdout1_247ck1950 FIND v(dout1_247) AT=980.025n

.meas tran vdout1_248ck1950 FIND v(dout1_248) AT=980.025n

.meas tran vdout1_249ck1950 FIND v(dout1_249) AT=980.025n

.meas tran vdout1_250ck1950 FIND v(dout1_250) AT=980.025n

.meas tran vdout1_251ck1950 FIND v(dout1_251) AT=980.025n

.meas tran vdout1_252ck1950 FIND v(dout1_252) AT=980.025n

.meas tran vdout1_253ck1950 FIND v(dout1_253) AT=980.025n

.meas tran vdout1_254ck1950 FIND v(dout1_254) AT=980.025n

.meas tran vdout1_255ck1950 FIND v(dout1_255) AT=980.025n

.meas tran vdout1_256ck1950 FIND v(dout1_256) AT=980.025n

.meas tran vdout1_257ck1950 FIND v(dout1_257) AT=980.025n

.meas tran vdout1_258ck1950 FIND v(dout1_258) AT=980.025n

.meas tran vdout1_259ck1950 FIND v(dout1_259) AT=980.025n

.meas tran vdout1_260ck1950 FIND v(dout1_260) AT=980.025n

.meas tran vdout1_261ck1950 FIND v(dout1_261) AT=980.025n

.meas tran vdout1_262ck1950 FIND v(dout1_262) AT=980.025n

.meas tran vdout1_263ck1950 FIND v(dout1_263) AT=980.025n

.meas tran vdout1_264ck1950 FIND v(dout1_264) AT=980.025n

.meas tran vdout1_265ck1950 FIND v(dout1_265) AT=980.025n

.meas tran vdout1_266ck1950 FIND v(dout1_266) AT=980.025n

.meas tran vdout1_267ck1950 FIND v(dout1_267) AT=980.025n

.meas tran vdout1_268ck1950 FIND v(dout1_268) AT=980.025n

.meas tran vdout1_269ck1950 FIND v(dout1_269) AT=980.025n

.meas tran vdout1_270ck1950 FIND v(dout1_270) AT=980.025n

.meas tran vdout1_271ck1950 FIND v(dout1_271) AT=980.025n

.meas tran vdout1_272ck1950 FIND v(dout1_272) AT=980.025n

.meas tran vdout1_273ck1950 FIND v(dout1_273) AT=980.025n

.meas tran vdout1_274ck1950 FIND v(dout1_274) AT=980.025n

.meas tran vdout1_275ck1950 FIND v(dout1_275) AT=980.025n

.meas tran vdout1_276ck1950 FIND v(dout1_276) AT=980.025n

.meas tran vdout1_277ck1950 FIND v(dout1_277) AT=980.025n

.meas tran vdout1_278ck1950 FIND v(dout1_278) AT=980.025n

.meas tran vdout1_279ck1950 FIND v(dout1_279) AT=980.025n

.meas tran vdout1_280ck1950 FIND v(dout1_280) AT=980.025n

.meas tran vdout1_281ck1950 FIND v(dout1_281) AT=980.025n

.meas tran vdout1_282ck1950 FIND v(dout1_282) AT=980.025n

.meas tran vdout1_283ck1950 FIND v(dout1_283) AT=980.025n

.meas tran vdout1_284ck1950 FIND v(dout1_284) AT=980.025n

.meas tran vdout1_285ck1950 FIND v(dout1_285) AT=980.025n

.meas tran vdout1_286ck1950 FIND v(dout1_286) AT=980.025n

.meas tran vdout1_287ck1950 FIND v(dout1_287) AT=980.025n

.meas tran vdout1_288ck1950 FIND v(dout1_288) AT=980.025n

.meas tran vdout1_289ck1950 FIND v(dout1_289) AT=980.025n

.meas tran vdout1_290ck1950 FIND v(dout1_290) AT=980.025n

.meas tran vdout1_291ck1950 FIND v(dout1_291) AT=980.025n

.meas tran vdout1_292ck1950 FIND v(dout1_292) AT=980.025n

.meas tran vdout1_293ck1950 FIND v(dout1_293) AT=980.025n

.meas tran vdout1_294ck1950 FIND v(dout1_294) AT=980.025n

.meas tran vdout1_295ck1950 FIND v(dout1_295) AT=980.025n

.meas tran vdout1_296ck1950 FIND v(dout1_296) AT=980.025n

.meas tran vdout1_297ck1950 FIND v(dout1_297) AT=980.025n

.meas tran vdout1_298ck1950 FIND v(dout1_298) AT=980.025n

.meas tran vdout1_299ck1950 FIND v(dout1_299) AT=980.025n

.meas tran vdout1_300ck1950 FIND v(dout1_300) AT=980.025n

.meas tran vdout1_301ck1950 FIND v(dout1_301) AT=980.025n

.meas tran vdout1_302ck1950 FIND v(dout1_302) AT=980.025n

.meas tran vdout1_303ck1950 FIND v(dout1_303) AT=980.025n

.meas tran vdout1_304ck1950 FIND v(dout1_304) AT=980.025n

.meas tran vdout1_305ck1950 FIND v(dout1_305) AT=980.025n

.meas tran vdout1_306ck1950 FIND v(dout1_306) AT=980.025n

.meas tran vdout1_307ck1950 FIND v(dout1_307) AT=980.025n

.meas tran vdout1_308ck1950 FIND v(dout1_308) AT=980.025n

.meas tran vdout1_309ck1950 FIND v(dout1_309) AT=980.025n

.meas tran vdout1_310ck1950 FIND v(dout1_310) AT=980.025n

.meas tran vdout1_311ck1950 FIND v(dout1_311) AT=980.025n

.meas tran vdout1_312ck1950 FIND v(dout1_312) AT=980.025n

.meas tran vdout1_313ck1950 FIND v(dout1_313) AT=980.025n

.meas tran vdout1_314ck1950 FIND v(dout1_314) AT=980.025n

.meas tran vdout1_315ck1950 FIND v(dout1_315) AT=980.025n

.meas tran vdout1_316ck1950 FIND v(dout1_316) AT=980.025n

.meas tran vdout1_317ck1950 FIND v(dout1_317) AT=980.025n

.meas tran vdout1_318ck1950 FIND v(dout1_318) AT=980.025n

.meas tran vdout1_319ck1950 FIND v(dout1_319) AT=980.025n

.meas tran vdout1_320ck1950 FIND v(dout1_320) AT=980.025n

.meas tran vdout1_321ck1950 FIND v(dout1_321) AT=980.025n

.meas tran vdout1_322ck1950 FIND v(dout1_322) AT=980.025n

.meas tran vdout1_323ck1950 FIND v(dout1_323) AT=980.025n

.meas tran vdout1_324ck1950 FIND v(dout1_324) AT=980.025n

.meas tran vdout1_325ck1950 FIND v(dout1_325) AT=980.025n

.meas tran vdout1_326ck1950 FIND v(dout1_326) AT=980.025n

.meas tran vdout1_327ck1950 FIND v(dout1_327) AT=980.025n

.meas tran vdout1_328ck1950 FIND v(dout1_328) AT=980.025n

.meas tran vdout1_329ck1950 FIND v(dout1_329) AT=980.025n

.meas tran vdout1_330ck1950 FIND v(dout1_330) AT=980.025n

.meas tran vdout1_331ck1950 FIND v(dout1_331) AT=980.025n

.meas tran vdout1_332ck1950 FIND v(dout1_332) AT=980.025n

.meas tran vdout1_333ck1950 FIND v(dout1_333) AT=980.025n

.meas tran vdout1_334ck1950 FIND v(dout1_334) AT=980.025n

.meas tran vdout1_335ck1950 FIND v(dout1_335) AT=980.025n

.meas tran vdout1_336ck1950 FIND v(dout1_336) AT=980.025n

.meas tran vdout1_337ck1950 FIND v(dout1_337) AT=980.025n

.meas tran vdout1_338ck1950 FIND v(dout1_338) AT=980.025n

.meas tran vdout1_339ck1950 FIND v(dout1_339) AT=980.025n

.meas tran vdout1_340ck1950 FIND v(dout1_340) AT=980.025n

.meas tran vdout1_341ck1950 FIND v(dout1_341) AT=980.025n

.meas tran vdout1_342ck1950 FIND v(dout1_342) AT=980.025n

.meas tran vdout1_343ck1950 FIND v(dout1_343) AT=980.025n

.meas tran vdout1_344ck1950 FIND v(dout1_344) AT=980.025n

.meas tran vdout1_345ck1950 FIND v(dout1_345) AT=980.025n

.meas tran vdout1_346ck1950 FIND v(dout1_346) AT=980.025n

.meas tran vdout1_347ck1950 FIND v(dout1_347) AT=980.025n

.meas tran vdout1_348ck1950 FIND v(dout1_348) AT=980.025n

.meas tran vdout1_349ck1950 FIND v(dout1_349) AT=980.025n

.meas tran vdout1_350ck1950 FIND v(dout1_350) AT=980.025n

.meas tran vdout1_351ck1950 FIND v(dout1_351) AT=980.025n

.meas tran vdout1_352ck1950 FIND v(dout1_352) AT=980.025n

.meas tran vdout1_353ck1950 FIND v(dout1_353) AT=980.025n

.meas tran vdout1_354ck1950 FIND v(dout1_354) AT=980.025n

.meas tran vdout1_355ck1950 FIND v(dout1_355) AT=980.025n

.meas tran vdout1_356ck1950 FIND v(dout1_356) AT=980.025n

.meas tran vdout1_357ck1950 FIND v(dout1_357) AT=980.025n

.meas tran vdout1_358ck1950 FIND v(dout1_358) AT=980.025n

.meas tran vdout1_359ck1950 FIND v(dout1_359) AT=980.025n

.meas tran vdout1_360ck1950 FIND v(dout1_360) AT=980.025n

.meas tran vdout1_361ck1950 FIND v(dout1_361) AT=980.025n

.meas tran vdout1_362ck1950 FIND v(dout1_362) AT=980.025n

.meas tran vdout1_363ck1950 FIND v(dout1_363) AT=980.025n

.meas tran vdout1_364ck1950 FIND v(dout1_364) AT=980.025n

.meas tran vdout1_365ck1950 FIND v(dout1_365) AT=980.025n

.meas tran vdout1_366ck1950 FIND v(dout1_366) AT=980.025n

.meas tran vdout1_367ck1950 FIND v(dout1_367) AT=980.025n

.meas tran vdout1_368ck1950 FIND v(dout1_368) AT=980.025n

.meas tran vdout1_369ck1950 FIND v(dout1_369) AT=980.025n

.meas tran vdout1_370ck1950 FIND v(dout1_370) AT=980.025n

.meas tran vdout1_371ck1950 FIND v(dout1_371) AT=980.025n

.meas tran vdout1_372ck1950 FIND v(dout1_372) AT=980.025n

.meas tran vdout1_373ck1950 FIND v(dout1_373) AT=980.025n

.meas tran vdout1_374ck1950 FIND v(dout1_374) AT=980.025n

.meas tran vdout1_375ck1950 FIND v(dout1_375) AT=980.025n

.meas tran vdout1_376ck1950 FIND v(dout1_376) AT=980.025n

.meas tran vdout1_377ck1950 FIND v(dout1_377) AT=980.025n

.meas tran vdout1_378ck1950 FIND v(dout1_378) AT=980.025n

.meas tran vdout1_379ck1950 FIND v(dout1_379) AT=980.025n

.meas tran vdout1_380ck1950 FIND v(dout1_380) AT=980.025n

.meas tran vdout1_381ck1950 FIND v(dout1_381) AT=980.025n

.meas tran vdout1_382ck1950 FIND v(dout1_382) AT=980.025n

.meas tran vdout1_383ck1950 FIND v(dout1_383) AT=980.025n

.meas tran vdout1_384ck1950 FIND v(dout1_384) AT=980.025n

.meas tran vdout1_385ck1950 FIND v(dout1_385) AT=980.025n

.meas tran vdout1_386ck1950 FIND v(dout1_386) AT=980.025n

.meas tran vdout1_387ck1950 FIND v(dout1_387) AT=980.025n

.meas tran vdout1_388ck1950 FIND v(dout1_388) AT=980.025n

.meas tran vdout1_389ck1950 FIND v(dout1_389) AT=980.025n

.meas tran vdout1_390ck1950 FIND v(dout1_390) AT=980.025n

.meas tran vdout1_391ck1950 FIND v(dout1_391) AT=980.025n

.meas tran vdout1_392ck1950 FIND v(dout1_392) AT=980.025n

.meas tran vdout1_393ck1950 FIND v(dout1_393) AT=980.025n

.meas tran vdout1_394ck1950 FIND v(dout1_394) AT=980.025n

.meas tran vdout1_395ck1950 FIND v(dout1_395) AT=980.025n

.meas tran vdout1_396ck1950 FIND v(dout1_396) AT=980.025n

.meas tran vdout1_397ck1950 FIND v(dout1_397) AT=980.025n

.meas tran vdout1_398ck1950 FIND v(dout1_398) AT=980.025n

.meas tran vdout1_399ck1950 FIND v(dout1_399) AT=980.025n

.meas tran vdout1_400ck1950 FIND v(dout1_400) AT=980.025n

.meas tran vdout1_401ck1950 FIND v(dout1_401) AT=980.025n

.meas tran vdout1_402ck1950 FIND v(dout1_402) AT=980.025n

.meas tran vdout1_403ck1950 FIND v(dout1_403) AT=980.025n

.meas tran vdout1_404ck1950 FIND v(dout1_404) AT=980.025n

.meas tran vdout1_405ck1950 FIND v(dout1_405) AT=980.025n

.meas tran vdout1_406ck1950 FIND v(dout1_406) AT=980.025n

.meas tran vdout1_407ck1950 FIND v(dout1_407) AT=980.025n

.meas tran vdout1_408ck1950 FIND v(dout1_408) AT=980.025n

.meas tran vdout1_409ck1950 FIND v(dout1_409) AT=980.025n

.meas tran vdout1_410ck1950 FIND v(dout1_410) AT=980.025n

.meas tran vdout1_411ck1950 FIND v(dout1_411) AT=980.025n

.meas tran vdout1_412ck1950 FIND v(dout1_412) AT=980.025n

.meas tran vdout1_413ck1950 FIND v(dout1_413) AT=980.025n

.meas tran vdout1_414ck1950 FIND v(dout1_414) AT=980.025n

.meas tran vdout1_415ck1950 FIND v(dout1_415) AT=980.025n

.meas tran vdout1_416ck1950 FIND v(dout1_416) AT=980.025n

.meas tran vdout1_417ck1950 FIND v(dout1_417) AT=980.025n

.meas tran vdout1_418ck1950 FIND v(dout1_418) AT=980.025n

.meas tran vdout1_419ck1950 FIND v(dout1_419) AT=980.025n

.meas tran vdout1_420ck1950 FIND v(dout1_420) AT=980.025n

.meas tran vdout1_421ck1950 FIND v(dout1_421) AT=980.025n

.meas tran vdout1_422ck1950 FIND v(dout1_422) AT=980.025n

.meas tran vdout1_423ck1950 FIND v(dout1_423) AT=980.025n

.meas tran vdout1_424ck1950 FIND v(dout1_424) AT=980.025n

.meas tran vdout1_425ck1950 FIND v(dout1_425) AT=980.025n

.meas tran vdout1_426ck1950 FIND v(dout1_426) AT=980.025n

.meas tran vdout1_427ck1950 FIND v(dout1_427) AT=980.025n

.meas tran vdout1_428ck1950 FIND v(dout1_428) AT=980.025n

.meas tran vdout1_429ck1950 FIND v(dout1_429) AT=980.025n

.meas tran vdout1_430ck1950 FIND v(dout1_430) AT=980.025n

.meas tran vdout1_431ck1950 FIND v(dout1_431) AT=980.025n

.meas tran vdout1_432ck1950 FIND v(dout1_432) AT=980.025n

.meas tran vdout1_433ck1950 FIND v(dout1_433) AT=980.025n

.meas tran vdout1_434ck1950 FIND v(dout1_434) AT=980.025n

.meas tran vdout1_435ck1950 FIND v(dout1_435) AT=980.025n

.meas tran vdout1_436ck1950 FIND v(dout1_436) AT=980.025n

.meas tran vdout1_437ck1950 FIND v(dout1_437) AT=980.025n

.meas tran vdout1_438ck1950 FIND v(dout1_438) AT=980.025n

.meas tran vdout1_439ck1950 FIND v(dout1_439) AT=980.025n

.meas tran vdout1_440ck1950 FIND v(dout1_440) AT=980.025n

.meas tran vdout1_441ck1950 FIND v(dout1_441) AT=980.025n

.meas tran vdout1_442ck1950 FIND v(dout1_442) AT=980.025n

.meas tran vdout1_443ck1950 FIND v(dout1_443) AT=980.025n

.meas tran vdout1_444ck1950 FIND v(dout1_444) AT=980.025n

.meas tran vdout1_445ck1950 FIND v(dout1_445) AT=980.025n

.meas tran vdout1_446ck1950 FIND v(dout1_446) AT=980.025n

.meas tran vdout1_447ck1950 FIND v(dout1_447) AT=980.025n

.meas tran vdout1_448ck1950 FIND v(dout1_448) AT=980.025n

.meas tran vdout1_449ck1950 FIND v(dout1_449) AT=980.025n

.meas tran vdout1_450ck1950 FIND v(dout1_450) AT=980.025n

.meas tran vdout1_451ck1950 FIND v(dout1_451) AT=980.025n

.meas tran vdout1_452ck1950 FIND v(dout1_452) AT=980.025n

.meas tran vdout1_453ck1950 FIND v(dout1_453) AT=980.025n

.meas tran vdout1_454ck1950 FIND v(dout1_454) AT=980.025n

.meas tran vdout1_455ck1950 FIND v(dout1_455) AT=980.025n

.meas tran vdout1_456ck1950 FIND v(dout1_456) AT=980.025n

.meas tran vdout1_457ck1950 FIND v(dout1_457) AT=980.025n

.meas tran vdout1_458ck1950 FIND v(dout1_458) AT=980.025n

.meas tran vdout1_459ck1950 FIND v(dout1_459) AT=980.025n

.meas tran vdout1_460ck1950 FIND v(dout1_460) AT=980.025n

.meas tran vdout1_461ck1950 FIND v(dout1_461) AT=980.025n

.meas tran vdout1_462ck1950 FIND v(dout1_462) AT=980.025n

.meas tran vdout1_463ck1950 FIND v(dout1_463) AT=980.025n

.meas tran vdout1_464ck1950 FIND v(dout1_464) AT=980.025n

.meas tran vdout1_465ck1950 FIND v(dout1_465) AT=980.025n

.meas tran vdout1_466ck1950 FIND v(dout1_466) AT=980.025n

.meas tran vdout1_467ck1950 FIND v(dout1_467) AT=980.025n

.meas tran vdout1_468ck1950 FIND v(dout1_468) AT=980.025n

.meas tran vdout1_469ck1950 FIND v(dout1_469) AT=980.025n

.meas tran vdout1_470ck1950 FIND v(dout1_470) AT=980.025n

.meas tran vdout1_471ck1950 FIND v(dout1_471) AT=980.025n

.meas tran vdout1_472ck1950 FIND v(dout1_472) AT=980.025n

.meas tran vdout1_473ck1950 FIND v(dout1_473) AT=980.025n

.meas tran vdout1_474ck1950 FIND v(dout1_474) AT=980.025n

.meas tran vdout1_475ck1950 FIND v(dout1_475) AT=980.025n

.meas tran vdout1_476ck1950 FIND v(dout1_476) AT=980.025n

.meas tran vdout1_477ck1950 FIND v(dout1_477) AT=980.025n

.meas tran vdout1_478ck1950 FIND v(dout1_478) AT=980.025n

.meas tran vdout1_479ck1950 FIND v(dout1_479) AT=980.025n

.meas tran vdout1_480ck1950 FIND v(dout1_480) AT=980.025n

.meas tran vdout1_481ck1950 FIND v(dout1_481) AT=980.025n

.meas tran vdout1_482ck1950 FIND v(dout1_482) AT=980.025n

.meas tran vdout1_483ck1950 FIND v(dout1_483) AT=980.025n

.meas tran vdout1_484ck1950 FIND v(dout1_484) AT=980.025n

.meas tran vdout1_485ck1950 FIND v(dout1_485) AT=980.025n

.meas tran vdout1_486ck1950 FIND v(dout1_486) AT=980.025n

.meas tran vdout1_487ck1950 FIND v(dout1_487) AT=980.025n

.meas tran vdout1_488ck1950 FIND v(dout1_488) AT=980.025n

.meas tran vdout1_489ck1950 FIND v(dout1_489) AT=980.025n

.meas tran vdout1_490ck1950 FIND v(dout1_490) AT=980.025n

.meas tran vdout1_491ck1950 FIND v(dout1_491) AT=980.025n

.meas tran vdout1_492ck1950 FIND v(dout1_492) AT=980.025n

.meas tran vdout1_493ck1950 FIND v(dout1_493) AT=980.025n

.meas tran vdout1_494ck1950 FIND v(dout1_494) AT=980.025n

.meas tran vdout1_495ck1950 FIND v(dout1_495) AT=980.025n

.meas tran vdout1_496ck1950 FIND v(dout1_496) AT=980.025n

.meas tran vdout1_497ck1950 FIND v(dout1_497) AT=980.025n

.meas tran vdout1_498ck1950 FIND v(dout1_498) AT=980.025n

.meas tran vdout1_499ck1950 FIND v(dout1_499) AT=980.025n

.meas tran vdout1_500ck1950 FIND v(dout1_500) AT=980.025n

.meas tran vdout1_501ck1950 FIND v(dout1_501) AT=980.025n

.meas tran vdout1_502ck1950 FIND v(dout1_502) AT=980.025n

.meas tran vdout1_503ck1950 FIND v(dout1_503) AT=980.025n

.meas tran vdout1_504ck1950 FIND v(dout1_504) AT=980.025n

.meas tran vdout1_505ck1950 FIND v(dout1_505) AT=980.025n

.meas tran vdout1_506ck1950 FIND v(dout1_506) AT=980.025n

.meas tran vdout1_507ck1950 FIND v(dout1_507) AT=980.025n

.meas tran vdout1_508ck1950 FIND v(dout1_508) AT=980.025n

.meas tran vdout1_509ck1950 FIND v(dout1_509) AT=980.025n

.meas tran vdout1_510ck1950 FIND v(dout1_510) AT=980.025n

.meas tran vdout1_511ck1950 FIND v(dout1_511) AT=980.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_17ck2010 FIND v(dout1_17) AT=1010.025n

.meas tran vdout1_18ck2010 FIND v(dout1_18) AT=1010.025n

.meas tran vdout1_19ck2010 FIND v(dout1_19) AT=1010.025n

.meas tran vdout1_20ck2010 FIND v(dout1_20) AT=1010.025n

.meas tran vdout1_21ck2010 FIND v(dout1_21) AT=1010.025n

.meas tran vdout1_22ck2010 FIND v(dout1_22) AT=1010.025n

.meas tran vdout1_23ck2010 FIND v(dout1_23) AT=1010.025n

.meas tran vdout1_24ck2010 FIND v(dout1_24) AT=1010.025n

.meas tran vdout1_25ck2010 FIND v(dout1_25) AT=1010.025n

.meas tran vdout1_26ck2010 FIND v(dout1_26) AT=1010.025n

.meas tran vdout1_27ck2010 FIND v(dout1_27) AT=1010.025n

.meas tran vdout1_28ck2010 FIND v(dout1_28) AT=1010.025n

.meas tran vdout1_29ck2010 FIND v(dout1_29) AT=1010.025n

.meas tran vdout1_30ck2010 FIND v(dout1_30) AT=1010.025n

.meas tran vdout1_31ck2010 FIND v(dout1_31) AT=1010.025n

.meas tran vdout1_32ck2010 FIND v(dout1_32) AT=1010.025n

.meas tran vdout1_33ck2010 FIND v(dout1_33) AT=1010.025n

.meas tran vdout1_34ck2010 FIND v(dout1_34) AT=1010.025n

.meas tran vdout1_35ck2010 FIND v(dout1_35) AT=1010.025n

.meas tran vdout1_36ck2010 FIND v(dout1_36) AT=1010.025n

.meas tran vdout1_37ck2010 FIND v(dout1_37) AT=1010.025n

.meas tran vdout1_38ck2010 FIND v(dout1_38) AT=1010.025n

.meas tran vdout1_39ck2010 FIND v(dout1_39) AT=1010.025n

.meas tran vdout1_40ck2010 FIND v(dout1_40) AT=1010.025n

.meas tran vdout1_41ck2010 FIND v(dout1_41) AT=1010.025n

.meas tran vdout1_42ck2010 FIND v(dout1_42) AT=1010.025n

.meas tran vdout1_43ck2010 FIND v(dout1_43) AT=1010.025n

.meas tran vdout1_44ck2010 FIND v(dout1_44) AT=1010.025n

.meas tran vdout1_45ck2010 FIND v(dout1_45) AT=1010.025n

.meas tran vdout1_46ck2010 FIND v(dout1_46) AT=1010.025n

.meas tran vdout1_47ck2010 FIND v(dout1_47) AT=1010.025n

.meas tran vdout1_48ck2010 FIND v(dout1_48) AT=1010.025n

.meas tran vdout1_49ck2010 FIND v(dout1_49) AT=1010.025n

.meas tran vdout1_50ck2010 FIND v(dout1_50) AT=1010.025n

.meas tran vdout1_51ck2010 FIND v(dout1_51) AT=1010.025n

.meas tran vdout1_52ck2010 FIND v(dout1_52) AT=1010.025n

.meas tran vdout1_53ck2010 FIND v(dout1_53) AT=1010.025n

.meas tran vdout1_54ck2010 FIND v(dout1_54) AT=1010.025n

.meas tran vdout1_55ck2010 FIND v(dout1_55) AT=1010.025n

.meas tran vdout1_56ck2010 FIND v(dout1_56) AT=1010.025n

.meas tran vdout1_57ck2010 FIND v(dout1_57) AT=1010.025n

.meas tran vdout1_58ck2010 FIND v(dout1_58) AT=1010.025n

.meas tran vdout1_59ck2010 FIND v(dout1_59) AT=1010.025n

.meas tran vdout1_60ck2010 FIND v(dout1_60) AT=1010.025n

.meas tran vdout1_61ck2010 FIND v(dout1_61) AT=1010.025n

.meas tran vdout1_62ck2010 FIND v(dout1_62) AT=1010.025n

.meas tran vdout1_63ck2010 FIND v(dout1_63) AT=1010.025n

.meas tran vdout1_64ck2010 FIND v(dout1_64) AT=1010.025n

.meas tran vdout1_65ck2010 FIND v(dout1_65) AT=1010.025n

.meas tran vdout1_66ck2010 FIND v(dout1_66) AT=1010.025n

.meas tran vdout1_67ck2010 FIND v(dout1_67) AT=1010.025n

.meas tran vdout1_68ck2010 FIND v(dout1_68) AT=1010.025n

.meas tran vdout1_69ck2010 FIND v(dout1_69) AT=1010.025n

.meas tran vdout1_70ck2010 FIND v(dout1_70) AT=1010.025n

.meas tran vdout1_71ck2010 FIND v(dout1_71) AT=1010.025n

.meas tran vdout1_72ck2010 FIND v(dout1_72) AT=1010.025n

.meas tran vdout1_73ck2010 FIND v(dout1_73) AT=1010.025n

.meas tran vdout1_74ck2010 FIND v(dout1_74) AT=1010.025n

.meas tran vdout1_75ck2010 FIND v(dout1_75) AT=1010.025n

.meas tran vdout1_76ck2010 FIND v(dout1_76) AT=1010.025n

.meas tran vdout1_77ck2010 FIND v(dout1_77) AT=1010.025n

.meas tran vdout1_78ck2010 FIND v(dout1_78) AT=1010.025n

.meas tran vdout1_79ck2010 FIND v(dout1_79) AT=1010.025n

.meas tran vdout1_80ck2010 FIND v(dout1_80) AT=1010.025n

.meas tran vdout1_81ck2010 FIND v(dout1_81) AT=1010.025n

.meas tran vdout1_82ck2010 FIND v(dout1_82) AT=1010.025n

.meas tran vdout1_83ck2010 FIND v(dout1_83) AT=1010.025n

.meas tran vdout1_84ck2010 FIND v(dout1_84) AT=1010.025n

.meas tran vdout1_85ck2010 FIND v(dout1_85) AT=1010.025n

.meas tran vdout1_86ck2010 FIND v(dout1_86) AT=1010.025n

.meas tran vdout1_87ck2010 FIND v(dout1_87) AT=1010.025n

.meas tran vdout1_88ck2010 FIND v(dout1_88) AT=1010.025n

.meas tran vdout1_89ck2010 FIND v(dout1_89) AT=1010.025n

.meas tran vdout1_90ck2010 FIND v(dout1_90) AT=1010.025n

.meas tran vdout1_91ck2010 FIND v(dout1_91) AT=1010.025n

.meas tran vdout1_92ck2010 FIND v(dout1_92) AT=1010.025n

.meas tran vdout1_93ck2010 FIND v(dout1_93) AT=1010.025n

.meas tran vdout1_94ck2010 FIND v(dout1_94) AT=1010.025n

.meas tran vdout1_95ck2010 FIND v(dout1_95) AT=1010.025n

.meas tran vdout1_96ck2010 FIND v(dout1_96) AT=1010.025n

.meas tran vdout1_97ck2010 FIND v(dout1_97) AT=1010.025n

.meas tran vdout1_98ck2010 FIND v(dout1_98) AT=1010.025n

.meas tran vdout1_99ck2010 FIND v(dout1_99) AT=1010.025n

.meas tran vdout1_100ck2010 FIND v(dout1_100) AT=1010.025n

.meas tran vdout1_101ck2010 FIND v(dout1_101) AT=1010.025n

.meas tran vdout1_102ck2010 FIND v(dout1_102) AT=1010.025n

.meas tran vdout1_103ck2010 FIND v(dout1_103) AT=1010.025n

.meas tran vdout1_104ck2010 FIND v(dout1_104) AT=1010.025n

.meas tran vdout1_105ck2010 FIND v(dout1_105) AT=1010.025n

.meas tran vdout1_106ck2010 FIND v(dout1_106) AT=1010.025n

.meas tran vdout1_107ck2010 FIND v(dout1_107) AT=1010.025n

.meas tran vdout1_108ck2010 FIND v(dout1_108) AT=1010.025n

.meas tran vdout1_109ck2010 FIND v(dout1_109) AT=1010.025n

.meas tran vdout1_110ck2010 FIND v(dout1_110) AT=1010.025n

.meas tran vdout1_111ck2010 FIND v(dout1_111) AT=1010.025n

.meas tran vdout1_112ck2010 FIND v(dout1_112) AT=1010.025n

.meas tran vdout1_113ck2010 FIND v(dout1_113) AT=1010.025n

.meas tran vdout1_114ck2010 FIND v(dout1_114) AT=1010.025n

.meas tran vdout1_115ck2010 FIND v(dout1_115) AT=1010.025n

.meas tran vdout1_116ck2010 FIND v(dout1_116) AT=1010.025n

.meas tran vdout1_117ck2010 FIND v(dout1_117) AT=1010.025n

.meas tran vdout1_118ck2010 FIND v(dout1_118) AT=1010.025n

.meas tran vdout1_119ck2010 FIND v(dout1_119) AT=1010.025n

.meas tran vdout1_120ck2010 FIND v(dout1_120) AT=1010.025n

.meas tran vdout1_121ck2010 FIND v(dout1_121) AT=1010.025n

.meas tran vdout1_122ck2010 FIND v(dout1_122) AT=1010.025n

.meas tran vdout1_123ck2010 FIND v(dout1_123) AT=1010.025n

.meas tran vdout1_124ck2010 FIND v(dout1_124) AT=1010.025n

.meas tran vdout1_125ck2010 FIND v(dout1_125) AT=1010.025n

.meas tran vdout1_126ck2010 FIND v(dout1_126) AT=1010.025n

.meas tran vdout1_127ck2010 FIND v(dout1_127) AT=1010.025n

.meas tran vdout1_128ck2010 FIND v(dout1_128) AT=1010.025n

.meas tran vdout1_129ck2010 FIND v(dout1_129) AT=1010.025n

.meas tran vdout1_130ck2010 FIND v(dout1_130) AT=1010.025n

.meas tran vdout1_131ck2010 FIND v(dout1_131) AT=1010.025n

.meas tran vdout1_132ck2010 FIND v(dout1_132) AT=1010.025n

.meas tran vdout1_133ck2010 FIND v(dout1_133) AT=1010.025n

.meas tran vdout1_134ck2010 FIND v(dout1_134) AT=1010.025n

.meas tran vdout1_135ck2010 FIND v(dout1_135) AT=1010.025n

.meas tran vdout1_136ck2010 FIND v(dout1_136) AT=1010.025n

.meas tran vdout1_137ck2010 FIND v(dout1_137) AT=1010.025n

.meas tran vdout1_138ck2010 FIND v(dout1_138) AT=1010.025n

.meas tran vdout1_139ck2010 FIND v(dout1_139) AT=1010.025n

.meas tran vdout1_140ck2010 FIND v(dout1_140) AT=1010.025n

.meas tran vdout1_141ck2010 FIND v(dout1_141) AT=1010.025n

.meas tran vdout1_142ck2010 FIND v(dout1_142) AT=1010.025n

.meas tran vdout1_143ck2010 FIND v(dout1_143) AT=1010.025n

.meas tran vdout1_144ck2010 FIND v(dout1_144) AT=1010.025n

.meas tran vdout1_145ck2010 FIND v(dout1_145) AT=1010.025n

.meas tran vdout1_146ck2010 FIND v(dout1_146) AT=1010.025n

.meas tran vdout1_147ck2010 FIND v(dout1_147) AT=1010.025n

.meas tran vdout1_148ck2010 FIND v(dout1_148) AT=1010.025n

.meas tran vdout1_149ck2010 FIND v(dout1_149) AT=1010.025n

.meas tran vdout1_150ck2010 FIND v(dout1_150) AT=1010.025n

.meas tran vdout1_151ck2010 FIND v(dout1_151) AT=1010.025n

.meas tran vdout1_152ck2010 FIND v(dout1_152) AT=1010.025n

.meas tran vdout1_153ck2010 FIND v(dout1_153) AT=1010.025n

.meas tran vdout1_154ck2010 FIND v(dout1_154) AT=1010.025n

.meas tran vdout1_155ck2010 FIND v(dout1_155) AT=1010.025n

.meas tran vdout1_156ck2010 FIND v(dout1_156) AT=1010.025n

.meas tran vdout1_157ck2010 FIND v(dout1_157) AT=1010.025n

.meas tran vdout1_158ck2010 FIND v(dout1_158) AT=1010.025n

.meas tran vdout1_159ck2010 FIND v(dout1_159) AT=1010.025n

.meas tran vdout1_160ck2010 FIND v(dout1_160) AT=1010.025n

.meas tran vdout1_161ck2010 FIND v(dout1_161) AT=1010.025n

.meas tran vdout1_162ck2010 FIND v(dout1_162) AT=1010.025n

.meas tran vdout1_163ck2010 FIND v(dout1_163) AT=1010.025n

.meas tran vdout1_164ck2010 FIND v(dout1_164) AT=1010.025n

.meas tran vdout1_165ck2010 FIND v(dout1_165) AT=1010.025n

.meas tran vdout1_166ck2010 FIND v(dout1_166) AT=1010.025n

.meas tran vdout1_167ck2010 FIND v(dout1_167) AT=1010.025n

.meas tran vdout1_168ck2010 FIND v(dout1_168) AT=1010.025n

.meas tran vdout1_169ck2010 FIND v(dout1_169) AT=1010.025n

.meas tran vdout1_170ck2010 FIND v(dout1_170) AT=1010.025n

.meas tran vdout1_171ck2010 FIND v(dout1_171) AT=1010.025n

.meas tran vdout1_172ck2010 FIND v(dout1_172) AT=1010.025n

.meas tran vdout1_173ck2010 FIND v(dout1_173) AT=1010.025n

.meas tran vdout1_174ck2010 FIND v(dout1_174) AT=1010.025n

.meas tran vdout1_175ck2010 FIND v(dout1_175) AT=1010.025n

.meas tran vdout1_176ck2010 FIND v(dout1_176) AT=1010.025n

.meas tran vdout1_177ck2010 FIND v(dout1_177) AT=1010.025n

.meas tran vdout1_178ck2010 FIND v(dout1_178) AT=1010.025n

.meas tran vdout1_179ck2010 FIND v(dout1_179) AT=1010.025n

.meas tran vdout1_180ck2010 FIND v(dout1_180) AT=1010.025n

.meas tran vdout1_181ck2010 FIND v(dout1_181) AT=1010.025n

.meas tran vdout1_182ck2010 FIND v(dout1_182) AT=1010.025n

.meas tran vdout1_183ck2010 FIND v(dout1_183) AT=1010.025n

.meas tran vdout1_184ck2010 FIND v(dout1_184) AT=1010.025n

.meas tran vdout1_185ck2010 FIND v(dout1_185) AT=1010.025n

.meas tran vdout1_186ck2010 FIND v(dout1_186) AT=1010.025n

.meas tran vdout1_187ck2010 FIND v(dout1_187) AT=1010.025n

.meas tran vdout1_188ck2010 FIND v(dout1_188) AT=1010.025n

.meas tran vdout1_189ck2010 FIND v(dout1_189) AT=1010.025n

.meas tran vdout1_190ck2010 FIND v(dout1_190) AT=1010.025n

.meas tran vdout1_191ck2010 FIND v(dout1_191) AT=1010.025n

.meas tran vdout1_192ck2010 FIND v(dout1_192) AT=1010.025n

.meas tran vdout1_193ck2010 FIND v(dout1_193) AT=1010.025n

.meas tran vdout1_194ck2010 FIND v(dout1_194) AT=1010.025n

.meas tran vdout1_195ck2010 FIND v(dout1_195) AT=1010.025n

.meas tran vdout1_196ck2010 FIND v(dout1_196) AT=1010.025n

.meas tran vdout1_197ck2010 FIND v(dout1_197) AT=1010.025n

.meas tran vdout1_198ck2010 FIND v(dout1_198) AT=1010.025n

.meas tran vdout1_199ck2010 FIND v(dout1_199) AT=1010.025n

.meas tran vdout1_200ck2010 FIND v(dout1_200) AT=1010.025n

.meas tran vdout1_201ck2010 FIND v(dout1_201) AT=1010.025n

.meas tran vdout1_202ck2010 FIND v(dout1_202) AT=1010.025n

.meas tran vdout1_203ck2010 FIND v(dout1_203) AT=1010.025n

.meas tran vdout1_204ck2010 FIND v(dout1_204) AT=1010.025n

.meas tran vdout1_205ck2010 FIND v(dout1_205) AT=1010.025n

.meas tran vdout1_206ck2010 FIND v(dout1_206) AT=1010.025n

.meas tran vdout1_207ck2010 FIND v(dout1_207) AT=1010.025n

.meas tran vdout1_208ck2010 FIND v(dout1_208) AT=1010.025n

.meas tran vdout1_209ck2010 FIND v(dout1_209) AT=1010.025n

.meas tran vdout1_210ck2010 FIND v(dout1_210) AT=1010.025n

.meas tran vdout1_211ck2010 FIND v(dout1_211) AT=1010.025n

.meas tran vdout1_212ck2010 FIND v(dout1_212) AT=1010.025n

.meas tran vdout1_213ck2010 FIND v(dout1_213) AT=1010.025n

.meas tran vdout1_214ck2010 FIND v(dout1_214) AT=1010.025n

.meas tran vdout1_215ck2010 FIND v(dout1_215) AT=1010.025n

.meas tran vdout1_216ck2010 FIND v(dout1_216) AT=1010.025n

.meas tran vdout1_217ck2010 FIND v(dout1_217) AT=1010.025n

.meas tran vdout1_218ck2010 FIND v(dout1_218) AT=1010.025n

.meas tran vdout1_219ck2010 FIND v(dout1_219) AT=1010.025n

.meas tran vdout1_220ck2010 FIND v(dout1_220) AT=1010.025n

.meas tran vdout1_221ck2010 FIND v(dout1_221) AT=1010.025n

.meas tran vdout1_222ck2010 FIND v(dout1_222) AT=1010.025n

.meas tran vdout1_223ck2010 FIND v(dout1_223) AT=1010.025n

.meas tran vdout1_224ck2010 FIND v(dout1_224) AT=1010.025n

.meas tran vdout1_225ck2010 FIND v(dout1_225) AT=1010.025n

.meas tran vdout1_226ck2010 FIND v(dout1_226) AT=1010.025n

.meas tran vdout1_227ck2010 FIND v(dout1_227) AT=1010.025n

.meas tran vdout1_228ck2010 FIND v(dout1_228) AT=1010.025n

.meas tran vdout1_229ck2010 FIND v(dout1_229) AT=1010.025n

.meas tran vdout1_230ck2010 FIND v(dout1_230) AT=1010.025n

.meas tran vdout1_231ck2010 FIND v(dout1_231) AT=1010.025n

.meas tran vdout1_232ck2010 FIND v(dout1_232) AT=1010.025n

.meas tran vdout1_233ck2010 FIND v(dout1_233) AT=1010.025n

.meas tran vdout1_234ck2010 FIND v(dout1_234) AT=1010.025n

.meas tran vdout1_235ck2010 FIND v(dout1_235) AT=1010.025n

.meas tran vdout1_236ck2010 FIND v(dout1_236) AT=1010.025n

.meas tran vdout1_237ck2010 FIND v(dout1_237) AT=1010.025n

.meas tran vdout1_238ck2010 FIND v(dout1_238) AT=1010.025n

.meas tran vdout1_239ck2010 FIND v(dout1_239) AT=1010.025n

.meas tran vdout1_240ck2010 FIND v(dout1_240) AT=1010.025n

.meas tran vdout1_241ck2010 FIND v(dout1_241) AT=1010.025n

.meas tran vdout1_242ck2010 FIND v(dout1_242) AT=1010.025n

.meas tran vdout1_243ck2010 FIND v(dout1_243) AT=1010.025n

.meas tran vdout1_244ck2010 FIND v(dout1_244) AT=1010.025n

.meas tran vdout1_245ck2010 FIND v(dout1_245) AT=1010.025n

.meas tran vdout1_246ck2010 FIND v(dout1_246) AT=1010.025n

.meas tran vdout1_247ck2010 FIND v(dout1_247) AT=1010.025n

.meas tran vdout1_248ck2010 FIND v(dout1_248) AT=1010.025n

.meas tran vdout1_249ck2010 FIND v(dout1_249) AT=1010.025n

.meas tran vdout1_250ck2010 FIND v(dout1_250) AT=1010.025n

.meas tran vdout1_251ck2010 FIND v(dout1_251) AT=1010.025n

.meas tran vdout1_252ck2010 FIND v(dout1_252) AT=1010.025n

.meas tran vdout1_253ck2010 FIND v(dout1_253) AT=1010.025n

.meas tran vdout1_254ck2010 FIND v(dout1_254) AT=1010.025n

.meas tran vdout1_255ck2010 FIND v(dout1_255) AT=1010.025n

.meas tran vdout1_256ck2010 FIND v(dout1_256) AT=1010.025n

.meas tran vdout1_257ck2010 FIND v(dout1_257) AT=1010.025n

.meas tran vdout1_258ck2010 FIND v(dout1_258) AT=1010.025n

.meas tran vdout1_259ck2010 FIND v(dout1_259) AT=1010.025n

.meas tran vdout1_260ck2010 FIND v(dout1_260) AT=1010.025n

.meas tran vdout1_261ck2010 FIND v(dout1_261) AT=1010.025n

.meas tran vdout1_262ck2010 FIND v(dout1_262) AT=1010.025n

.meas tran vdout1_263ck2010 FIND v(dout1_263) AT=1010.025n

.meas tran vdout1_264ck2010 FIND v(dout1_264) AT=1010.025n

.meas tran vdout1_265ck2010 FIND v(dout1_265) AT=1010.025n

.meas tran vdout1_266ck2010 FIND v(dout1_266) AT=1010.025n

.meas tran vdout1_267ck2010 FIND v(dout1_267) AT=1010.025n

.meas tran vdout1_268ck2010 FIND v(dout1_268) AT=1010.025n

.meas tran vdout1_269ck2010 FIND v(dout1_269) AT=1010.025n

.meas tran vdout1_270ck2010 FIND v(dout1_270) AT=1010.025n

.meas tran vdout1_271ck2010 FIND v(dout1_271) AT=1010.025n

.meas tran vdout1_272ck2010 FIND v(dout1_272) AT=1010.025n

.meas tran vdout1_273ck2010 FIND v(dout1_273) AT=1010.025n

.meas tran vdout1_274ck2010 FIND v(dout1_274) AT=1010.025n

.meas tran vdout1_275ck2010 FIND v(dout1_275) AT=1010.025n

.meas tran vdout1_276ck2010 FIND v(dout1_276) AT=1010.025n

.meas tran vdout1_277ck2010 FIND v(dout1_277) AT=1010.025n

.meas tran vdout1_278ck2010 FIND v(dout1_278) AT=1010.025n

.meas tran vdout1_279ck2010 FIND v(dout1_279) AT=1010.025n

.meas tran vdout1_280ck2010 FIND v(dout1_280) AT=1010.025n

.meas tran vdout1_281ck2010 FIND v(dout1_281) AT=1010.025n

.meas tran vdout1_282ck2010 FIND v(dout1_282) AT=1010.025n

.meas tran vdout1_283ck2010 FIND v(dout1_283) AT=1010.025n

.meas tran vdout1_284ck2010 FIND v(dout1_284) AT=1010.025n

.meas tran vdout1_285ck2010 FIND v(dout1_285) AT=1010.025n

.meas tran vdout1_286ck2010 FIND v(dout1_286) AT=1010.025n

.meas tran vdout1_287ck2010 FIND v(dout1_287) AT=1010.025n

.meas tran vdout1_288ck2010 FIND v(dout1_288) AT=1010.025n

.meas tran vdout1_289ck2010 FIND v(dout1_289) AT=1010.025n

.meas tran vdout1_290ck2010 FIND v(dout1_290) AT=1010.025n

.meas tran vdout1_291ck2010 FIND v(dout1_291) AT=1010.025n

.meas tran vdout1_292ck2010 FIND v(dout1_292) AT=1010.025n

.meas tran vdout1_293ck2010 FIND v(dout1_293) AT=1010.025n

.meas tran vdout1_294ck2010 FIND v(dout1_294) AT=1010.025n

.meas tran vdout1_295ck2010 FIND v(dout1_295) AT=1010.025n

.meas tran vdout1_296ck2010 FIND v(dout1_296) AT=1010.025n

.meas tran vdout1_297ck2010 FIND v(dout1_297) AT=1010.025n

.meas tran vdout1_298ck2010 FIND v(dout1_298) AT=1010.025n

.meas tran vdout1_299ck2010 FIND v(dout1_299) AT=1010.025n

.meas tran vdout1_300ck2010 FIND v(dout1_300) AT=1010.025n

.meas tran vdout1_301ck2010 FIND v(dout1_301) AT=1010.025n

.meas tran vdout1_302ck2010 FIND v(dout1_302) AT=1010.025n

.meas tran vdout1_303ck2010 FIND v(dout1_303) AT=1010.025n

.meas tran vdout1_304ck2010 FIND v(dout1_304) AT=1010.025n

.meas tran vdout1_305ck2010 FIND v(dout1_305) AT=1010.025n

.meas tran vdout1_306ck2010 FIND v(dout1_306) AT=1010.025n

.meas tran vdout1_307ck2010 FIND v(dout1_307) AT=1010.025n

.meas tran vdout1_308ck2010 FIND v(dout1_308) AT=1010.025n

.meas tran vdout1_309ck2010 FIND v(dout1_309) AT=1010.025n

.meas tran vdout1_310ck2010 FIND v(dout1_310) AT=1010.025n

.meas tran vdout1_311ck2010 FIND v(dout1_311) AT=1010.025n

.meas tran vdout1_312ck2010 FIND v(dout1_312) AT=1010.025n

.meas tran vdout1_313ck2010 FIND v(dout1_313) AT=1010.025n

.meas tran vdout1_314ck2010 FIND v(dout1_314) AT=1010.025n

.meas tran vdout1_315ck2010 FIND v(dout1_315) AT=1010.025n

.meas tran vdout1_316ck2010 FIND v(dout1_316) AT=1010.025n

.meas tran vdout1_317ck2010 FIND v(dout1_317) AT=1010.025n

.meas tran vdout1_318ck2010 FIND v(dout1_318) AT=1010.025n

.meas tran vdout1_319ck2010 FIND v(dout1_319) AT=1010.025n

.meas tran vdout1_320ck2010 FIND v(dout1_320) AT=1010.025n

.meas tran vdout1_321ck2010 FIND v(dout1_321) AT=1010.025n

.meas tran vdout1_322ck2010 FIND v(dout1_322) AT=1010.025n

.meas tran vdout1_323ck2010 FIND v(dout1_323) AT=1010.025n

.meas tran vdout1_324ck2010 FIND v(dout1_324) AT=1010.025n

.meas tran vdout1_325ck2010 FIND v(dout1_325) AT=1010.025n

.meas tran vdout1_326ck2010 FIND v(dout1_326) AT=1010.025n

.meas tran vdout1_327ck2010 FIND v(dout1_327) AT=1010.025n

.meas tran vdout1_328ck2010 FIND v(dout1_328) AT=1010.025n

.meas tran vdout1_329ck2010 FIND v(dout1_329) AT=1010.025n

.meas tran vdout1_330ck2010 FIND v(dout1_330) AT=1010.025n

.meas tran vdout1_331ck2010 FIND v(dout1_331) AT=1010.025n

.meas tran vdout1_332ck2010 FIND v(dout1_332) AT=1010.025n

.meas tran vdout1_333ck2010 FIND v(dout1_333) AT=1010.025n

.meas tran vdout1_334ck2010 FIND v(dout1_334) AT=1010.025n

.meas tran vdout1_335ck2010 FIND v(dout1_335) AT=1010.025n

.meas tran vdout1_336ck2010 FIND v(dout1_336) AT=1010.025n

.meas tran vdout1_337ck2010 FIND v(dout1_337) AT=1010.025n

.meas tran vdout1_338ck2010 FIND v(dout1_338) AT=1010.025n

.meas tran vdout1_339ck2010 FIND v(dout1_339) AT=1010.025n

.meas tran vdout1_340ck2010 FIND v(dout1_340) AT=1010.025n

.meas tran vdout1_341ck2010 FIND v(dout1_341) AT=1010.025n

.meas tran vdout1_342ck2010 FIND v(dout1_342) AT=1010.025n

.meas tran vdout1_343ck2010 FIND v(dout1_343) AT=1010.025n

.meas tran vdout1_344ck2010 FIND v(dout1_344) AT=1010.025n

.meas tran vdout1_345ck2010 FIND v(dout1_345) AT=1010.025n

.meas tran vdout1_346ck2010 FIND v(dout1_346) AT=1010.025n

.meas tran vdout1_347ck2010 FIND v(dout1_347) AT=1010.025n

.meas tran vdout1_348ck2010 FIND v(dout1_348) AT=1010.025n

.meas tran vdout1_349ck2010 FIND v(dout1_349) AT=1010.025n

.meas tran vdout1_350ck2010 FIND v(dout1_350) AT=1010.025n

.meas tran vdout1_351ck2010 FIND v(dout1_351) AT=1010.025n

.meas tran vdout1_352ck2010 FIND v(dout1_352) AT=1010.025n

.meas tran vdout1_353ck2010 FIND v(dout1_353) AT=1010.025n

.meas tran vdout1_354ck2010 FIND v(dout1_354) AT=1010.025n

.meas tran vdout1_355ck2010 FIND v(dout1_355) AT=1010.025n

.meas tran vdout1_356ck2010 FIND v(dout1_356) AT=1010.025n

.meas tran vdout1_357ck2010 FIND v(dout1_357) AT=1010.025n

.meas tran vdout1_358ck2010 FIND v(dout1_358) AT=1010.025n

.meas tran vdout1_359ck2010 FIND v(dout1_359) AT=1010.025n

.meas tran vdout1_360ck2010 FIND v(dout1_360) AT=1010.025n

.meas tran vdout1_361ck2010 FIND v(dout1_361) AT=1010.025n

.meas tran vdout1_362ck2010 FIND v(dout1_362) AT=1010.025n

.meas tran vdout1_363ck2010 FIND v(dout1_363) AT=1010.025n

.meas tran vdout1_364ck2010 FIND v(dout1_364) AT=1010.025n

.meas tran vdout1_365ck2010 FIND v(dout1_365) AT=1010.025n

.meas tran vdout1_366ck2010 FIND v(dout1_366) AT=1010.025n

.meas tran vdout1_367ck2010 FIND v(dout1_367) AT=1010.025n

.meas tran vdout1_368ck2010 FIND v(dout1_368) AT=1010.025n

.meas tran vdout1_369ck2010 FIND v(dout1_369) AT=1010.025n

.meas tran vdout1_370ck2010 FIND v(dout1_370) AT=1010.025n

.meas tran vdout1_371ck2010 FIND v(dout1_371) AT=1010.025n

.meas tran vdout1_372ck2010 FIND v(dout1_372) AT=1010.025n

.meas tran vdout1_373ck2010 FIND v(dout1_373) AT=1010.025n

.meas tran vdout1_374ck2010 FIND v(dout1_374) AT=1010.025n

.meas tran vdout1_375ck2010 FIND v(dout1_375) AT=1010.025n

.meas tran vdout1_376ck2010 FIND v(dout1_376) AT=1010.025n

.meas tran vdout1_377ck2010 FIND v(dout1_377) AT=1010.025n

.meas tran vdout1_378ck2010 FIND v(dout1_378) AT=1010.025n

.meas tran vdout1_379ck2010 FIND v(dout1_379) AT=1010.025n

.meas tran vdout1_380ck2010 FIND v(dout1_380) AT=1010.025n

.meas tran vdout1_381ck2010 FIND v(dout1_381) AT=1010.025n

.meas tran vdout1_382ck2010 FIND v(dout1_382) AT=1010.025n

.meas tran vdout1_383ck2010 FIND v(dout1_383) AT=1010.025n

.meas tran vdout1_384ck2010 FIND v(dout1_384) AT=1010.025n

.meas tran vdout1_385ck2010 FIND v(dout1_385) AT=1010.025n

.meas tran vdout1_386ck2010 FIND v(dout1_386) AT=1010.025n

.meas tran vdout1_387ck2010 FIND v(dout1_387) AT=1010.025n

.meas tran vdout1_388ck2010 FIND v(dout1_388) AT=1010.025n

.meas tran vdout1_389ck2010 FIND v(dout1_389) AT=1010.025n

.meas tran vdout1_390ck2010 FIND v(dout1_390) AT=1010.025n

.meas tran vdout1_391ck2010 FIND v(dout1_391) AT=1010.025n

.meas tran vdout1_392ck2010 FIND v(dout1_392) AT=1010.025n

.meas tran vdout1_393ck2010 FIND v(dout1_393) AT=1010.025n

.meas tran vdout1_394ck2010 FIND v(dout1_394) AT=1010.025n

.meas tran vdout1_395ck2010 FIND v(dout1_395) AT=1010.025n

.meas tran vdout1_396ck2010 FIND v(dout1_396) AT=1010.025n

.meas tran vdout1_397ck2010 FIND v(dout1_397) AT=1010.025n

.meas tran vdout1_398ck2010 FIND v(dout1_398) AT=1010.025n

.meas tran vdout1_399ck2010 FIND v(dout1_399) AT=1010.025n

.meas tran vdout1_400ck2010 FIND v(dout1_400) AT=1010.025n

.meas tran vdout1_401ck2010 FIND v(dout1_401) AT=1010.025n

.meas tran vdout1_402ck2010 FIND v(dout1_402) AT=1010.025n

.meas tran vdout1_403ck2010 FIND v(dout1_403) AT=1010.025n

.meas tran vdout1_404ck2010 FIND v(dout1_404) AT=1010.025n

.meas tran vdout1_405ck2010 FIND v(dout1_405) AT=1010.025n

.meas tran vdout1_406ck2010 FIND v(dout1_406) AT=1010.025n

.meas tran vdout1_407ck2010 FIND v(dout1_407) AT=1010.025n

.meas tran vdout1_408ck2010 FIND v(dout1_408) AT=1010.025n

.meas tran vdout1_409ck2010 FIND v(dout1_409) AT=1010.025n

.meas tran vdout1_410ck2010 FIND v(dout1_410) AT=1010.025n

.meas tran vdout1_411ck2010 FIND v(dout1_411) AT=1010.025n

.meas tran vdout1_412ck2010 FIND v(dout1_412) AT=1010.025n

.meas tran vdout1_413ck2010 FIND v(dout1_413) AT=1010.025n

.meas tran vdout1_414ck2010 FIND v(dout1_414) AT=1010.025n

.meas tran vdout1_415ck2010 FIND v(dout1_415) AT=1010.025n

.meas tran vdout1_416ck2010 FIND v(dout1_416) AT=1010.025n

.meas tran vdout1_417ck2010 FIND v(dout1_417) AT=1010.025n

.meas tran vdout1_418ck2010 FIND v(dout1_418) AT=1010.025n

.meas tran vdout1_419ck2010 FIND v(dout1_419) AT=1010.025n

.meas tran vdout1_420ck2010 FIND v(dout1_420) AT=1010.025n

.meas tran vdout1_421ck2010 FIND v(dout1_421) AT=1010.025n

.meas tran vdout1_422ck2010 FIND v(dout1_422) AT=1010.025n

.meas tran vdout1_423ck2010 FIND v(dout1_423) AT=1010.025n

.meas tran vdout1_424ck2010 FIND v(dout1_424) AT=1010.025n

.meas tran vdout1_425ck2010 FIND v(dout1_425) AT=1010.025n

.meas tran vdout1_426ck2010 FIND v(dout1_426) AT=1010.025n

.meas tran vdout1_427ck2010 FIND v(dout1_427) AT=1010.025n

.meas tran vdout1_428ck2010 FIND v(dout1_428) AT=1010.025n

.meas tran vdout1_429ck2010 FIND v(dout1_429) AT=1010.025n

.meas tran vdout1_430ck2010 FIND v(dout1_430) AT=1010.025n

.meas tran vdout1_431ck2010 FIND v(dout1_431) AT=1010.025n

.meas tran vdout1_432ck2010 FIND v(dout1_432) AT=1010.025n

.meas tran vdout1_433ck2010 FIND v(dout1_433) AT=1010.025n

.meas tran vdout1_434ck2010 FIND v(dout1_434) AT=1010.025n

.meas tran vdout1_435ck2010 FIND v(dout1_435) AT=1010.025n

.meas tran vdout1_436ck2010 FIND v(dout1_436) AT=1010.025n

.meas tran vdout1_437ck2010 FIND v(dout1_437) AT=1010.025n

.meas tran vdout1_438ck2010 FIND v(dout1_438) AT=1010.025n

.meas tran vdout1_439ck2010 FIND v(dout1_439) AT=1010.025n

.meas tran vdout1_440ck2010 FIND v(dout1_440) AT=1010.025n

.meas tran vdout1_441ck2010 FIND v(dout1_441) AT=1010.025n

.meas tran vdout1_442ck2010 FIND v(dout1_442) AT=1010.025n

.meas tran vdout1_443ck2010 FIND v(dout1_443) AT=1010.025n

.meas tran vdout1_444ck2010 FIND v(dout1_444) AT=1010.025n

.meas tran vdout1_445ck2010 FIND v(dout1_445) AT=1010.025n

.meas tran vdout1_446ck2010 FIND v(dout1_446) AT=1010.025n

.meas tran vdout1_447ck2010 FIND v(dout1_447) AT=1010.025n

.meas tran vdout1_448ck2010 FIND v(dout1_448) AT=1010.025n

.meas tran vdout1_449ck2010 FIND v(dout1_449) AT=1010.025n

.meas tran vdout1_450ck2010 FIND v(dout1_450) AT=1010.025n

.meas tran vdout1_451ck2010 FIND v(dout1_451) AT=1010.025n

.meas tran vdout1_452ck2010 FIND v(dout1_452) AT=1010.025n

.meas tran vdout1_453ck2010 FIND v(dout1_453) AT=1010.025n

.meas tran vdout1_454ck2010 FIND v(dout1_454) AT=1010.025n

.meas tran vdout1_455ck2010 FIND v(dout1_455) AT=1010.025n

.meas tran vdout1_456ck2010 FIND v(dout1_456) AT=1010.025n

.meas tran vdout1_457ck2010 FIND v(dout1_457) AT=1010.025n

.meas tran vdout1_458ck2010 FIND v(dout1_458) AT=1010.025n

.meas tran vdout1_459ck2010 FIND v(dout1_459) AT=1010.025n

.meas tran vdout1_460ck2010 FIND v(dout1_460) AT=1010.025n

.meas tran vdout1_461ck2010 FIND v(dout1_461) AT=1010.025n

.meas tran vdout1_462ck2010 FIND v(dout1_462) AT=1010.025n

.meas tran vdout1_463ck2010 FIND v(dout1_463) AT=1010.025n

.meas tran vdout1_464ck2010 FIND v(dout1_464) AT=1010.025n

.meas tran vdout1_465ck2010 FIND v(dout1_465) AT=1010.025n

.meas tran vdout1_466ck2010 FIND v(dout1_466) AT=1010.025n

.meas tran vdout1_467ck2010 FIND v(dout1_467) AT=1010.025n

.meas tran vdout1_468ck2010 FIND v(dout1_468) AT=1010.025n

.meas tran vdout1_469ck2010 FIND v(dout1_469) AT=1010.025n

.meas tran vdout1_470ck2010 FIND v(dout1_470) AT=1010.025n

.meas tran vdout1_471ck2010 FIND v(dout1_471) AT=1010.025n

.meas tran vdout1_472ck2010 FIND v(dout1_472) AT=1010.025n

.meas tran vdout1_473ck2010 FIND v(dout1_473) AT=1010.025n

.meas tran vdout1_474ck2010 FIND v(dout1_474) AT=1010.025n

.meas tran vdout1_475ck2010 FIND v(dout1_475) AT=1010.025n

.meas tran vdout1_476ck2010 FIND v(dout1_476) AT=1010.025n

.meas tran vdout1_477ck2010 FIND v(dout1_477) AT=1010.025n

.meas tran vdout1_478ck2010 FIND v(dout1_478) AT=1010.025n

.meas tran vdout1_479ck2010 FIND v(dout1_479) AT=1010.025n

.meas tran vdout1_480ck2010 FIND v(dout1_480) AT=1010.025n

.meas tran vdout1_481ck2010 FIND v(dout1_481) AT=1010.025n

.meas tran vdout1_482ck2010 FIND v(dout1_482) AT=1010.025n

.meas tran vdout1_483ck2010 FIND v(dout1_483) AT=1010.025n

.meas tran vdout1_484ck2010 FIND v(dout1_484) AT=1010.025n

.meas tran vdout1_485ck2010 FIND v(dout1_485) AT=1010.025n

.meas tran vdout1_486ck2010 FIND v(dout1_486) AT=1010.025n

.meas tran vdout1_487ck2010 FIND v(dout1_487) AT=1010.025n

.meas tran vdout1_488ck2010 FIND v(dout1_488) AT=1010.025n

.meas tran vdout1_489ck2010 FIND v(dout1_489) AT=1010.025n

.meas tran vdout1_490ck2010 FIND v(dout1_490) AT=1010.025n

.meas tran vdout1_491ck2010 FIND v(dout1_491) AT=1010.025n

.meas tran vdout1_492ck2010 FIND v(dout1_492) AT=1010.025n

.meas tran vdout1_493ck2010 FIND v(dout1_493) AT=1010.025n

.meas tran vdout1_494ck2010 FIND v(dout1_494) AT=1010.025n

.meas tran vdout1_495ck2010 FIND v(dout1_495) AT=1010.025n

.meas tran vdout1_496ck2010 FIND v(dout1_496) AT=1010.025n

.meas tran vdout1_497ck2010 FIND v(dout1_497) AT=1010.025n

.meas tran vdout1_498ck2010 FIND v(dout1_498) AT=1010.025n

.meas tran vdout1_499ck2010 FIND v(dout1_499) AT=1010.025n

.meas tran vdout1_500ck2010 FIND v(dout1_500) AT=1010.025n

.meas tran vdout1_501ck2010 FIND v(dout1_501) AT=1010.025n

.meas tran vdout1_502ck2010 FIND v(dout1_502) AT=1010.025n

.meas tran vdout1_503ck2010 FIND v(dout1_503) AT=1010.025n

.meas tran vdout1_504ck2010 FIND v(dout1_504) AT=1010.025n

.meas tran vdout1_505ck2010 FIND v(dout1_505) AT=1010.025n

.meas tran vdout1_506ck2010 FIND v(dout1_506) AT=1010.025n

.meas tran vdout1_507ck2010 FIND v(dout1_507) AT=1010.025n

.meas tran vdout1_508ck2010 FIND v(dout1_508) AT=1010.025n

.meas tran vdout1_509ck2010 FIND v(dout1_509) AT=1010.025n

.meas tran vdout1_510ck2010 FIND v(dout1_510) AT=1010.025n

.meas tran vdout1_511ck2010 FIND v(dout1_511) AT=1010.025n
