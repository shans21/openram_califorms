.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_16ck60 FIND v(dout1_16) AT=35.025n

.meas tran vdout1_17ck60 FIND v(dout1_17) AT=35.025n

.meas tran vdout1_18ck60 FIND v(dout1_18) AT=35.025n

.meas tran vdout1_19ck60 FIND v(dout1_19) AT=35.025n

.meas tran vdout1_20ck60 FIND v(dout1_20) AT=35.025n

.meas tran vdout1_21ck60 FIND v(dout1_21) AT=35.025n

.meas tran vdout1_22ck60 FIND v(dout1_22) AT=35.025n

.meas tran vdout1_23ck60 FIND v(dout1_23) AT=35.025n

.meas tran vdout1_24ck60 FIND v(dout1_24) AT=35.025n

.meas tran vdout1_25ck60 FIND v(dout1_25) AT=35.025n

.meas tran vdout1_26ck60 FIND v(dout1_26) AT=35.025n

.meas tran vdout1_27ck60 FIND v(dout1_27) AT=35.025n

.meas tran vdout1_28ck60 FIND v(dout1_28) AT=35.025n

.meas tran vdout1_29ck60 FIND v(dout1_29) AT=35.025n

.meas tran vdout1_30ck60 FIND v(dout1_30) AT=35.025n

.meas tran vdout1_31ck60 FIND v(dout1_31) AT=35.025n

.meas tran vdout1_0ck70 FIND v(dout1_0) AT=40.025n

.meas tran vdout1_1ck70 FIND v(dout1_1) AT=40.025n

.meas tran vdout1_2ck70 FIND v(dout1_2) AT=40.025n

.meas tran vdout1_3ck70 FIND v(dout1_3) AT=40.025n

.meas tran vdout1_4ck70 FIND v(dout1_4) AT=40.025n

.meas tran vdout1_5ck70 FIND v(dout1_5) AT=40.025n

.meas tran vdout1_6ck70 FIND v(dout1_6) AT=40.025n

.meas tran vdout1_7ck70 FIND v(dout1_7) AT=40.025n

.meas tran vdout1_8ck70 FIND v(dout1_8) AT=40.025n

.meas tran vdout1_9ck70 FIND v(dout1_9) AT=40.025n

.meas tran vdout1_10ck70 FIND v(dout1_10) AT=40.025n

.meas tran vdout1_11ck70 FIND v(dout1_11) AT=40.025n

.meas tran vdout1_12ck70 FIND v(dout1_12) AT=40.025n

.meas tran vdout1_13ck70 FIND v(dout1_13) AT=40.025n

.meas tran vdout1_14ck70 FIND v(dout1_14) AT=40.025n

.meas tran vdout1_15ck70 FIND v(dout1_15) AT=40.025n

.meas tran vdout1_16ck70 FIND v(dout1_16) AT=40.025n

.meas tran vdout1_17ck70 FIND v(dout1_17) AT=40.025n

.meas tran vdout1_18ck70 FIND v(dout1_18) AT=40.025n

.meas tran vdout1_19ck70 FIND v(dout1_19) AT=40.025n

.meas tran vdout1_20ck70 FIND v(dout1_20) AT=40.025n

.meas tran vdout1_21ck70 FIND v(dout1_21) AT=40.025n

.meas tran vdout1_22ck70 FIND v(dout1_22) AT=40.025n

.meas tran vdout1_23ck70 FIND v(dout1_23) AT=40.025n

.meas tran vdout1_24ck70 FIND v(dout1_24) AT=40.025n

.meas tran vdout1_25ck70 FIND v(dout1_25) AT=40.025n

.meas tran vdout1_26ck70 FIND v(dout1_26) AT=40.025n

.meas tran vdout1_27ck70 FIND v(dout1_27) AT=40.025n

.meas tran vdout1_28ck70 FIND v(dout1_28) AT=40.025n

.meas tran vdout1_29ck70 FIND v(dout1_29) AT=40.025n

.meas tran vdout1_30ck70 FIND v(dout1_30) AT=40.025n

.meas tran vdout1_31ck70 FIND v(dout1_31) AT=40.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_17ck90 FIND v(dout1_17) AT=50.025n

.meas tran vdout1_18ck90 FIND v(dout1_18) AT=50.025n

.meas tran vdout1_19ck90 FIND v(dout1_19) AT=50.025n

.meas tran vdout1_20ck90 FIND v(dout1_20) AT=50.025n

.meas tran vdout1_21ck90 FIND v(dout1_21) AT=50.025n

.meas tran vdout1_22ck90 FIND v(dout1_22) AT=50.025n

.meas tran vdout1_23ck90 FIND v(dout1_23) AT=50.025n

.meas tran vdout1_24ck90 FIND v(dout1_24) AT=50.025n

.meas tran vdout1_25ck90 FIND v(dout1_25) AT=50.025n

.meas tran vdout1_26ck90 FIND v(dout1_26) AT=50.025n

.meas tran vdout1_27ck90 FIND v(dout1_27) AT=50.025n

.meas tran vdout1_28ck90 FIND v(dout1_28) AT=50.025n

.meas tran vdout1_29ck90 FIND v(dout1_29) AT=50.025n

.meas tran vdout1_30ck90 FIND v(dout1_30) AT=50.025n

.meas tran vdout1_31ck90 FIND v(dout1_31) AT=50.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_17ck100 FIND v(dout1_17) AT=55.025n

.meas tran vdout1_18ck100 FIND v(dout1_18) AT=55.025n

.meas tran vdout1_19ck100 FIND v(dout1_19) AT=55.025n

.meas tran vdout1_20ck100 FIND v(dout1_20) AT=55.025n

.meas tran vdout1_21ck100 FIND v(dout1_21) AT=55.025n

.meas tran vdout1_22ck100 FIND v(dout1_22) AT=55.025n

.meas tran vdout1_23ck100 FIND v(dout1_23) AT=55.025n

.meas tran vdout1_24ck100 FIND v(dout1_24) AT=55.025n

.meas tran vdout1_25ck100 FIND v(dout1_25) AT=55.025n

.meas tran vdout1_26ck100 FIND v(dout1_26) AT=55.025n

.meas tran vdout1_27ck100 FIND v(dout1_27) AT=55.025n

.meas tran vdout1_28ck100 FIND v(dout1_28) AT=55.025n

.meas tran vdout1_29ck100 FIND v(dout1_29) AT=55.025n

.meas tran vdout1_30ck100 FIND v(dout1_30) AT=55.025n

.meas tran vdout1_31ck100 FIND v(dout1_31) AT=55.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_17ck160 FIND v(dout1_17) AT=85.025n

.meas tran vdout1_18ck160 FIND v(dout1_18) AT=85.025n

.meas tran vdout1_19ck160 FIND v(dout1_19) AT=85.025n

.meas tran vdout1_20ck160 FIND v(dout1_20) AT=85.025n

.meas tran vdout1_21ck160 FIND v(dout1_21) AT=85.025n

.meas tran vdout1_22ck160 FIND v(dout1_22) AT=85.025n

.meas tran vdout1_23ck160 FIND v(dout1_23) AT=85.025n

.meas tran vdout1_24ck160 FIND v(dout1_24) AT=85.025n

.meas tran vdout1_25ck160 FIND v(dout1_25) AT=85.025n

.meas tran vdout1_26ck160 FIND v(dout1_26) AT=85.025n

.meas tran vdout1_27ck160 FIND v(dout1_27) AT=85.025n

.meas tran vdout1_28ck160 FIND v(dout1_28) AT=85.025n

.meas tran vdout1_29ck160 FIND v(dout1_29) AT=85.025n

.meas tran vdout1_30ck160 FIND v(dout1_30) AT=85.025n

.meas tran vdout1_31ck160 FIND v(dout1_31) AT=85.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_22ck180 FIND v(dout1_22) AT=95.025n

.meas tran vdout1_23ck180 FIND v(dout1_23) AT=95.025n

.meas tran vdout1_24ck180 FIND v(dout1_24) AT=95.025n

.meas tran vdout1_25ck180 FIND v(dout1_25) AT=95.025n

.meas tran vdout1_26ck180 FIND v(dout1_26) AT=95.025n

.meas tran vdout1_27ck180 FIND v(dout1_27) AT=95.025n

.meas tran vdout1_28ck180 FIND v(dout1_28) AT=95.025n

.meas tran vdout1_29ck180 FIND v(dout1_29) AT=95.025n

.meas tran vdout1_30ck180 FIND v(dout1_30) AT=95.025n

.meas tran vdout1_31ck180 FIND v(dout1_31) AT=95.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_0ck210 FIND v(dout1_0) AT=110.025n

.meas tran vdout1_1ck210 FIND v(dout1_1) AT=110.025n

.meas tran vdout1_2ck210 FIND v(dout1_2) AT=110.025n

.meas tran vdout1_3ck210 FIND v(dout1_3) AT=110.025n

.meas tran vdout1_4ck210 FIND v(dout1_4) AT=110.025n

.meas tran vdout1_5ck210 FIND v(dout1_5) AT=110.025n

.meas tran vdout1_6ck210 FIND v(dout1_6) AT=110.025n

.meas tran vdout1_7ck210 FIND v(dout1_7) AT=110.025n

.meas tran vdout1_8ck210 FIND v(dout1_8) AT=110.025n

.meas tran vdout1_9ck210 FIND v(dout1_9) AT=110.025n

.meas tran vdout1_10ck210 FIND v(dout1_10) AT=110.025n

.meas tran vdout1_11ck210 FIND v(dout1_11) AT=110.025n

.meas tran vdout1_12ck210 FIND v(dout1_12) AT=110.025n

.meas tran vdout1_13ck210 FIND v(dout1_13) AT=110.025n

.meas tran vdout1_14ck210 FIND v(dout1_14) AT=110.025n

.meas tran vdout1_15ck210 FIND v(dout1_15) AT=110.025n

.meas tran vdout1_16ck210 FIND v(dout1_16) AT=110.025n

.meas tran vdout1_17ck210 FIND v(dout1_17) AT=110.025n

.meas tran vdout1_18ck210 FIND v(dout1_18) AT=110.025n

.meas tran vdout1_19ck210 FIND v(dout1_19) AT=110.025n

.meas tran vdout1_20ck210 FIND v(dout1_20) AT=110.025n

.meas tran vdout1_21ck210 FIND v(dout1_21) AT=110.025n

.meas tran vdout1_22ck210 FIND v(dout1_22) AT=110.025n

.meas tran vdout1_23ck210 FIND v(dout1_23) AT=110.025n

.meas tran vdout1_24ck210 FIND v(dout1_24) AT=110.025n

.meas tran vdout1_25ck210 FIND v(dout1_25) AT=110.025n

.meas tran vdout1_26ck210 FIND v(dout1_26) AT=110.025n

.meas tran vdout1_27ck210 FIND v(dout1_27) AT=110.025n

.meas tran vdout1_28ck210 FIND v(dout1_28) AT=110.025n

.meas tran vdout1_29ck210 FIND v(dout1_29) AT=110.025n

.meas tran vdout1_30ck210 FIND v(dout1_30) AT=110.025n

.meas tran vdout1_31ck210 FIND v(dout1_31) AT=110.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_17ck240 FIND v(dout1_17) AT=125.025n

.meas tran vdout1_18ck240 FIND v(dout1_18) AT=125.025n

.meas tran vdout1_19ck240 FIND v(dout1_19) AT=125.025n

.meas tran vdout1_20ck240 FIND v(dout1_20) AT=125.025n

.meas tran vdout1_21ck240 FIND v(dout1_21) AT=125.025n

.meas tran vdout1_22ck240 FIND v(dout1_22) AT=125.025n

.meas tran vdout1_23ck240 FIND v(dout1_23) AT=125.025n

.meas tran vdout1_24ck240 FIND v(dout1_24) AT=125.025n

.meas tran vdout1_25ck240 FIND v(dout1_25) AT=125.025n

.meas tran vdout1_26ck240 FIND v(dout1_26) AT=125.025n

.meas tran vdout1_27ck240 FIND v(dout1_27) AT=125.025n

.meas tran vdout1_28ck240 FIND v(dout1_28) AT=125.025n

.meas tran vdout1_29ck240 FIND v(dout1_29) AT=125.025n

.meas tran vdout1_30ck240 FIND v(dout1_30) AT=125.025n

.meas tran vdout1_31ck240 FIND v(dout1_31) AT=125.025n

.meas tran vdout1_0ck260 FIND v(dout1_0) AT=135.025n

.meas tran vdout1_1ck260 FIND v(dout1_1) AT=135.025n

.meas tran vdout1_2ck260 FIND v(dout1_2) AT=135.025n

.meas tran vdout1_3ck260 FIND v(dout1_3) AT=135.025n

.meas tran vdout1_4ck260 FIND v(dout1_4) AT=135.025n

.meas tran vdout1_5ck260 FIND v(dout1_5) AT=135.025n

.meas tran vdout1_6ck260 FIND v(dout1_6) AT=135.025n

.meas tran vdout1_7ck260 FIND v(dout1_7) AT=135.025n

.meas tran vdout1_8ck260 FIND v(dout1_8) AT=135.025n

.meas tran vdout1_9ck260 FIND v(dout1_9) AT=135.025n

.meas tran vdout1_10ck260 FIND v(dout1_10) AT=135.025n

.meas tran vdout1_11ck260 FIND v(dout1_11) AT=135.025n

.meas tran vdout1_12ck260 FIND v(dout1_12) AT=135.025n

.meas tran vdout1_13ck260 FIND v(dout1_13) AT=135.025n

.meas tran vdout1_14ck260 FIND v(dout1_14) AT=135.025n

.meas tran vdout1_15ck260 FIND v(dout1_15) AT=135.025n

.meas tran vdout1_16ck260 FIND v(dout1_16) AT=135.025n

.meas tran vdout1_17ck260 FIND v(dout1_17) AT=135.025n

.meas tran vdout1_18ck260 FIND v(dout1_18) AT=135.025n

.meas tran vdout1_19ck260 FIND v(dout1_19) AT=135.025n

.meas tran vdout1_20ck260 FIND v(dout1_20) AT=135.025n

.meas tran vdout1_21ck260 FIND v(dout1_21) AT=135.025n

.meas tran vdout1_22ck260 FIND v(dout1_22) AT=135.025n

.meas tran vdout1_23ck260 FIND v(dout1_23) AT=135.025n

.meas tran vdout1_24ck260 FIND v(dout1_24) AT=135.025n

.meas tran vdout1_25ck260 FIND v(dout1_25) AT=135.025n

.meas tran vdout1_26ck260 FIND v(dout1_26) AT=135.025n

.meas tran vdout1_27ck260 FIND v(dout1_27) AT=135.025n

.meas tran vdout1_28ck260 FIND v(dout1_28) AT=135.025n

.meas tran vdout1_29ck260 FIND v(dout1_29) AT=135.025n

.meas tran vdout1_30ck260 FIND v(dout1_30) AT=135.025n

.meas tran vdout1_31ck260 FIND v(dout1_31) AT=135.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_19ck290 FIND v(dout1_19) AT=150.025n

.meas tran vdout1_20ck290 FIND v(dout1_20) AT=150.025n

.meas tran vdout1_21ck290 FIND v(dout1_21) AT=150.025n

.meas tran vdout1_22ck290 FIND v(dout1_22) AT=150.025n

.meas tran vdout1_23ck290 FIND v(dout1_23) AT=150.025n

.meas tran vdout1_24ck290 FIND v(dout1_24) AT=150.025n

.meas tran vdout1_25ck290 FIND v(dout1_25) AT=150.025n

.meas tran vdout1_26ck290 FIND v(dout1_26) AT=150.025n

.meas tran vdout1_27ck290 FIND v(dout1_27) AT=150.025n

.meas tran vdout1_28ck290 FIND v(dout1_28) AT=150.025n

.meas tran vdout1_29ck290 FIND v(dout1_29) AT=150.025n

.meas tran vdout1_30ck290 FIND v(dout1_30) AT=150.025n

.meas tran vdout1_31ck290 FIND v(dout1_31) AT=150.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_22ck350 FIND v(dout1_22) AT=180.025n

.meas tran vdout1_23ck350 FIND v(dout1_23) AT=180.025n

.meas tran vdout1_24ck350 FIND v(dout1_24) AT=180.025n

.meas tran vdout1_25ck350 FIND v(dout1_25) AT=180.025n

.meas tran vdout1_26ck350 FIND v(dout1_26) AT=180.025n

.meas tran vdout1_27ck350 FIND v(dout1_27) AT=180.025n

.meas tran vdout1_28ck350 FIND v(dout1_28) AT=180.025n

.meas tran vdout1_29ck350 FIND v(dout1_29) AT=180.025n

.meas tran vdout1_30ck350 FIND v(dout1_30) AT=180.025n

.meas tran vdout1_31ck350 FIND v(dout1_31) AT=180.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_22ck370 FIND v(dout1_22) AT=190.025n

.meas tran vdout1_23ck370 FIND v(dout1_23) AT=190.025n

.meas tran vdout1_24ck370 FIND v(dout1_24) AT=190.025n

.meas tran vdout1_25ck370 FIND v(dout1_25) AT=190.025n

.meas tran vdout1_26ck370 FIND v(dout1_26) AT=190.025n

.meas tran vdout1_27ck370 FIND v(dout1_27) AT=190.025n

.meas tran vdout1_28ck370 FIND v(dout1_28) AT=190.025n

.meas tran vdout1_29ck370 FIND v(dout1_29) AT=190.025n

.meas tran vdout1_30ck370 FIND v(dout1_30) AT=190.025n

.meas tran vdout1_31ck370 FIND v(dout1_31) AT=190.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_23ck380 FIND v(dout1_23) AT=195.025n

.meas tran vdout1_24ck380 FIND v(dout1_24) AT=195.025n

.meas tran vdout1_25ck380 FIND v(dout1_25) AT=195.025n

.meas tran vdout1_26ck380 FIND v(dout1_26) AT=195.025n

.meas tran vdout1_27ck380 FIND v(dout1_27) AT=195.025n

.meas tran vdout1_28ck380 FIND v(dout1_28) AT=195.025n

.meas tran vdout1_29ck380 FIND v(dout1_29) AT=195.025n

.meas tran vdout1_30ck380 FIND v(dout1_30) AT=195.025n

.meas tran vdout1_31ck380 FIND v(dout1_31) AT=195.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_17ck410 FIND v(dout1_17) AT=210.025n

.meas tran vdout1_18ck410 FIND v(dout1_18) AT=210.025n

.meas tran vdout1_19ck410 FIND v(dout1_19) AT=210.025n

.meas tran vdout1_20ck410 FIND v(dout1_20) AT=210.025n

.meas tran vdout1_21ck410 FIND v(dout1_21) AT=210.025n

.meas tran vdout1_22ck410 FIND v(dout1_22) AT=210.025n

.meas tran vdout1_23ck410 FIND v(dout1_23) AT=210.025n

.meas tran vdout1_24ck410 FIND v(dout1_24) AT=210.025n

.meas tran vdout1_25ck410 FIND v(dout1_25) AT=210.025n

.meas tran vdout1_26ck410 FIND v(dout1_26) AT=210.025n

.meas tran vdout1_27ck410 FIND v(dout1_27) AT=210.025n

.meas tran vdout1_28ck410 FIND v(dout1_28) AT=210.025n

.meas tran vdout1_29ck410 FIND v(dout1_29) AT=210.025n

.meas tran vdout1_30ck410 FIND v(dout1_30) AT=210.025n

.meas tran vdout1_31ck410 FIND v(dout1_31) AT=210.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_0ck470 FIND v(dout1_0) AT=240.025n

.meas tran vdout1_1ck470 FIND v(dout1_1) AT=240.025n

.meas tran vdout1_2ck470 FIND v(dout1_2) AT=240.025n

.meas tran vdout1_3ck470 FIND v(dout1_3) AT=240.025n

.meas tran vdout1_4ck470 FIND v(dout1_4) AT=240.025n

.meas tran vdout1_5ck470 FIND v(dout1_5) AT=240.025n

.meas tran vdout1_6ck470 FIND v(dout1_6) AT=240.025n

.meas tran vdout1_7ck470 FIND v(dout1_7) AT=240.025n

.meas tran vdout1_8ck470 FIND v(dout1_8) AT=240.025n

.meas tran vdout1_9ck470 FIND v(dout1_9) AT=240.025n

.meas tran vdout1_10ck470 FIND v(dout1_10) AT=240.025n

.meas tran vdout1_11ck470 FIND v(dout1_11) AT=240.025n

.meas tran vdout1_12ck470 FIND v(dout1_12) AT=240.025n

.meas tran vdout1_13ck470 FIND v(dout1_13) AT=240.025n

.meas tran vdout1_14ck470 FIND v(dout1_14) AT=240.025n

.meas tran vdout1_15ck470 FIND v(dout1_15) AT=240.025n

.meas tran vdout1_16ck470 FIND v(dout1_16) AT=240.025n

.meas tran vdout1_17ck470 FIND v(dout1_17) AT=240.025n

.meas tran vdout1_18ck470 FIND v(dout1_18) AT=240.025n

.meas tran vdout1_19ck470 FIND v(dout1_19) AT=240.025n

.meas tran vdout1_20ck470 FIND v(dout1_20) AT=240.025n

.meas tran vdout1_21ck470 FIND v(dout1_21) AT=240.025n

.meas tran vdout1_22ck470 FIND v(dout1_22) AT=240.025n

.meas tran vdout1_23ck470 FIND v(dout1_23) AT=240.025n

.meas tran vdout1_24ck470 FIND v(dout1_24) AT=240.025n

.meas tran vdout1_25ck470 FIND v(dout1_25) AT=240.025n

.meas tran vdout1_26ck470 FIND v(dout1_26) AT=240.025n

.meas tran vdout1_27ck470 FIND v(dout1_27) AT=240.025n

.meas tran vdout1_28ck470 FIND v(dout1_28) AT=240.025n

.meas tran vdout1_29ck470 FIND v(dout1_29) AT=240.025n

.meas tran vdout1_30ck470 FIND v(dout1_30) AT=240.025n

.meas tran vdout1_31ck470 FIND v(dout1_31) AT=240.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_16ck550 FIND v(dout1_16) AT=280.025n

.meas tran vdout1_17ck550 FIND v(dout1_17) AT=280.025n

.meas tran vdout1_18ck550 FIND v(dout1_18) AT=280.025n

.meas tran vdout1_19ck550 FIND v(dout1_19) AT=280.025n

.meas tran vdout1_20ck550 FIND v(dout1_20) AT=280.025n

.meas tran vdout1_21ck550 FIND v(dout1_21) AT=280.025n

.meas tran vdout1_22ck550 FIND v(dout1_22) AT=280.025n

.meas tran vdout1_23ck550 FIND v(dout1_23) AT=280.025n

.meas tran vdout1_24ck550 FIND v(dout1_24) AT=280.025n

.meas tran vdout1_25ck550 FIND v(dout1_25) AT=280.025n

.meas tran vdout1_26ck550 FIND v(dout1_26) AT=280.025n

.meas tran vdout1_27ck550 FIND v(dout1_27) AT=280.025n

.meas tran vdout1_28ck550 FIND v(dout1_28) AT=280.025n

.meas tran vdout1_29ck550 FIND v(dout1_29) AT=280.025n

.meas tran vdout1_30ck550 FIND v(dout1_30) AT=280.025n

.meas tran vdout1_31ck550 FIND v(dout1_31) AT=280.025n

.meas tran vdout1_0ck560 FIND v(dout1_0) AT=285.025n

.meas tran vdout1_1ck560 FIND v(dout1_1) AT=285.025n

.meas tran vdout1_2ck560 FIND v(dout1_2) AT=285.025n

.meas tran vdout1_3ck560 FIND v(dout1_3) AT=285.025n

.meas tran vdout1_4ck560 FIND v(dout1_4) AT=285.025n

.meas tran vdout1_5ck560 FIND v(dout1_5) AT=285.025n

.meas tran vdout1_6ck560 FIND v(dout1_6) AT=285.025n

.meas tran vdout1_7ck560 FIND v(dout1_7) AT=285.025n

.meas tran vdout1_8ck560 FIND v(dout1_8) AT=285.025n

.meas tran vdout1_9ck560 FIND v(dout1_9) AT=285.025n

.meas tran vdout1_10ck560 FIND v(dout1_10) AT=285.025n

.meas tran vdout1_11ck560 FIND v(dout1_11) AT=285.025n

.meas tran vdout1_12ck560 FIND v(dout1_12) AT=285.025n

.meas tran vdout1_13ck560 FIND v(dout1_13) AT=285.025n

.meas tran vdout1_14ck560 FIND v(dout1_14) AT=285.025n

.meas tran vdout1_15ck560 FIND v(dout1_15) AT=285.025n

.meas tran vdout1_16ck560 FIND v(dout1_16) AT=285.025n

.meas tran vdout1_17ck560 FIND v(dout1_17) AT=285.025n

.meas tran vdout1_18ck560 FIND v(dout1_18) AT=285.025n

.meas tran vdout1_19ck560 FIND v(dout1_19) AT=285.025n

.meas tran vdout1_20ck560 FIND v(dout1_20) AT=285.025n

.meas tran vdout1_21ck560 FIND v(dout1_21) AT=285.025n

.meas tran vdout1_22ck560 FIND v(dout1_22) AT=285.025n

.meas tran vdout1_23ck560 FIND v(dout1_23) AT=285.025n

.meas tran vdout1_24ck560 FIND v(dout1_24) AT=285.025n

.meas tran vdout1_25ck560 FIND v(dout1_25) AT=285.025n

.meas tran vdout1_26ck560 FIND v(dout1_26) AT=285.025n

.meas tran vdout1_27ck560 FIND v(dout1_27) AT=285.025n

.meas tran vdout1_28ck560 FIND v(dout1_28) AT=285.025n

.meas tran vdout1_29ck560 FIND v(dout1_29) AT=285.025n

.meas tran vdout1_30ck560 FIND v(dout1_30) AT=285.025n

.meas tran vdout1_31ck560 FIND v(dout1_31) AT=285.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_22ck570 FIND v(dout1_22) AT=290.025n

.meas tran vdout1_23ck570 FIND v(dout1_23) AT=290.025n

.meas tran vdout1_24ck570 FIND v(dout1_24) AT=290.025n

.meas tran vdout1_25ck570 FIND v(dout1_25) AT=290.025n

.meas tran vdout1_26ck570 FIND v(dout1_26) AT=290.025n

.meas tran vdout1_27ck570 FIND v(dout1_27) AT=290.025n

.meas tran vdout1_28ck570 FIND v(dout1_28) AT=290.025n

.meas tran vdout1_29ck570 FIND v(dout1_29) AT=290.025n

.meas tran vdout1_30ck570 FIND v(dout1_30) AT=290.025n

.meas tran vdout1_31ck570 FIND v(dout1_31) AT=290.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_17ck590 FIND v(dout1_17) AT=300.025n

.meas tran vdout1_18ck590 FIND v(dout1_18) AT=300.025n

.meas tran vdout1_19ck590 FIND v(dout1_19) AT=300.025n

.meas tran vdout1_20ck590 FIND v(dout1_20) AT=300.025n

.meas tran vdout1_21ck590 FIND v(dout1_21) AT=300.025n

.meas tran vdout1_22ck590 FIND v(dout1_22) AT=300.025n

.meas tran vdout1_23ck590 FIND v(dout1_23) AT=300.025n

.meas tran vdout1_24ck590 FIND v(dout1_24) AT=300.025n

.meas tran vdout1_25ck590 FIND v(dout1_25) AT=300.025n

.meas tran vdout1_26ck590 FIND v(dout1_26) AT=300.025n

.meas tran vdout1_27ck590 FIND v(dout1_27) AT=300.025n

.meas tran vdout1_28ck590 FIND v(dout1_28) AT=300.025n

.meas tran vdout1_29ck590 FIND v(dout1_29) AT=300.025n

.meas tran vdout1_30ck590 FIND v(dout1_30) AT=300.025n

.meas tran vdout1_31ck590 FIND v(dout1_31) AT=300.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_8ck630 FIND v(dout1_8) AT=320.025n

.meas tran vdout1_9ck630 FIND v(dout1_9) AT=320.025n

.meas tran vdout1_10ck630 FIND v(dout1_10) AT=320.025n

.meas tran vdout1_11ck630 FIND v(dout1_11) AT=320.025n

.meas tran vdout1_12ck630 FIND v(dout1_12) AT=320.025n

.meas tran vdout1_13ck630 FIND v(dout1_13) AT=320.025n

.meas tran vdout1_14ck630 FIND v(dout1_14) AT=320.025n

.meas tran vdout1_15ck630 FIND v(dout1_15) AT=320.025n

.meas tran vdout1_16ck630 FIND v(dout1_16) AT=320.025n

.meas tran vdout1_17ck630 FIND v(dout1_17) AT=320.025n

.meas tran vdout1_18ck630 FIND v(dout1_18) AT=320.025n

.meas tran vdout1_19ck630 FIND v(dout1_19) AT=320.025n

.meas tran vdout1_20ck630 FIND v(dout1_20) AT=320.025n

.meas tran vdout1_21ck630 FIND v(dout1_21) AT=320.025n

.meas tran vdout1_22ck630 FIND v(dout1_22) AT=320.025n

.meas tran vdout1_23ck630 FIND v(dout1_23) AT=320.025n

.meas tran vdout1_24ck630 FIND v(dout1_24) AT=320.025n

.meas tran vdout1_25ck630 FIND v(dout1_25) AT=320.025n

.meas tran vdout1_26ck630 FIND v(dout1_26) AT=320.025n

.meas tran vdout1_27ck630 FIND v(dout1_27) AT=320.025n

.meas tran vdout1_28ck630 FIND v(dout1_28) AT=320.025n

.meas tran vdout1_29ck630 FIND v(dout1_29) AT=320.025n

.meas tran vdout1_30ck630 FIND v(dout1_30) AT=320.025n

.meas tran vdout1_31ck630 FIND v(dout1_31) AT=320.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_19ck640 FIND v(dout1_19) AT=325.025n

.meas tran vdout1_20ck640 FIND v(dout1_20) AT=325.025n

.meas tran vdout1_21ck640 FIND v(dout1_21) AT=325.025n

.meas tran vdout1_22ck640 FIND v(dout1_22) AT=325.025n

.meas tran vdout1_23ck640 FIND v(dout1_23) AT=325.025n

.meas tran vdout1_24ck640 FIND v(dout1_24) AT=325.025n

.meas tran vdout1_25ck640 FIND v(dout1_25) AT=325.025n

.meas tran vdout1_26ck640 FIND v(dout1_26) AT=325.025n

.meas tran vdout1_27ck640 FIND v(dout1_27) AT=325.025n

.meas tran vdout1_28ck640 FIND v(dout1_28) AT=325.025n

.meas tran vdout1_29ck640 FIND v(dout1_29) AT=325.025n

.meas tran vdout1_30ck640 FIND v(dout1_30) AT=325.025n

.meas tran vdout1_31ck640 FIND v(dout1_31) AT=325.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_19ck650 FIND v(dout1_19) AT=330.025n

.meas tran vdout1_20ck650 FIND v(dout1_20) AT=330.025n

.meas tran vdout1_21ck650 FIND v(dout1_21) AT=330.025n

.meas tran vdout1_22ck650 FIND v(dout1_22) AT=330.025n

.meas tran vdout1_23ck650 FIND v(dout1_23) AT=330.025n

.meas tran vdout1_24ck650 FIND v(dout1_24) AT=330.025n

.meas tran vdout1_25ck650 FIND v(dout1_25) AT=330.025n

.meas tran vdout1_26ck650 FIND v(dout1_26) AT=330.025n

.meas tran vdout1_27ck650 FIND v(dout1_27) AT=330.025n

.meas tran vdout1_28ck650 FIND v(dout1_28) AT=330.025n

.meas tran vdout1_29ck650 FIND v(dout1_29) AT=330.025n

.meas tran vdout1_30ck650 FIND v(dout1_30) AT=330.025n

.meas tran vdout1_31ck650 FIND v(dout1_31) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_19ck660 FIND v(dout1_19) AT=335.025n

.meas tran vdout1_20ck660 FIND v(dout1_20) AT=335.025n

.meas tran vdout1_21ck660 FIND v(dout1_21) AT=335.025n

.meas tran vdout1_22ck660 FIND v(dout1_22) AT=335.025n

.meas tran vdout1_23ck660 FIND v(dout1_23) AT=335.025n

.meas tran vdout1_24ck660 FIND v(dout1_24) AT=335.025n

.meas tran vdout1_25ck660 FIND v(dout1_25) AT=335.025n

.meas tran vdout1_26ck660 FIND v(dout1_26) AT=335.025n

.meas tran vdout1_27ck660 FIND v(dout1_27) AT=335.025n

.meas tran vdout1_28ck660 FIND v(dout1_28) AT=335.025n

.meas tran vdout1_29ck660 FIND v(dout1_29) AT=335.025n

.meas tran vdout1_30ck660 FIND v(dout1_30) AT=335.025n

.meas tran vdout1_31ck660 FIND v(dout1_31) AT=335.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_19ck680 FIND v(dout1_19) AT=345.025n

.meas tran vdout1_20ck680 FIND v(dout1_20) AT=345.025n

.meas tran vdout1_21ck680 FIND v(dout1_21) AT=345.025n

.meas tran vdout1_22ck680 FIND v(dout1_22) AT=345.025n

.meas tran vdout1_23ck680 FIND v(dout1_23) AT=345.025n

.meas tran vdout1_24ck680 FIND v(dout1_24) AT=345.025n

.meas tran vdout1_25ck680 FIND v(dout1_25) AT=345.025n

.meas tran vdout1_26ck680 FIND v(dout1_26) AT=345.025n

.meas tran vdout1_27ck680 FIND v(dout1_27) AT=345.025n

.meas tran vdout1_28ck680 FIND v(dout1_28) AT=345.025n

.meas tran vdout1_29ck680 FIND v(dout1_29) AT=345.025n

.meas tran vdout1_30ck680 FIND v(dout1_30) AT=345.025n

.meas tran vdout1_31ck680 FIND v(dout1_31) AT=345.025n

.meas tran vdout1_0ck690 FIND v(dout1_0) AT=350.025n

.meas tran vdout1_1ck690 FIND v(dout1_1) AT=350.025n

.meas tran vdout1_2ck690 FIND v(dout1_2) AT=350.025n

.meas tran vdout1_3ck690 FIND v(dout1_3) AT=350.025n

.meas tran vdout1_4ck690 FIND v(dout1_4) AT=350.025n

.meas tran vdout1_5ck690 FIND v(dout1_5) AT=350.025n

.meas tran vdout1_6ck690 FIND v(dout1_6) AT=350.025n

.meas tran vdout1_7ck690 FIND v(dout1_7) AT=350.025n

.meas tran vdout1_8ck690 FIND v(dout1_8) AT=350.025n

.meas tran vdout1_9ck690 FIND v(dout1_9) AT=350.025n

.meas tran vdout1_10ck690 FIND v(dout1_10) AT=350.025n

.meas tran vdout1_11ck690 FIND v(dout1_11) AT=350.025n

.meas tran vdout1_12ck690 FIND v(dout1_12) AT=350.025n

.meas tran vdout1_13ck690 FIND v(dout1_13) AT=350.025n

.meas tran vdout1_14ck690 FIND v(dout1_14) AT=350.025n

.meas tran vdout1_15ck690 FIND v(dout1_15) AT=350.025n

.meas tran vdout1_16ck690 FIND v(dout1_16) AT=350.025n

.meas tran vdout1_17ck690 FIND v(dout1_17) AT=350.025n

.meas tran vdout1_18ck690 FIND v(dout1_18) AT=350.025n

.meas tran vdout1_19ck690 FIND v(dout1_19) AT=350.025n

.meas tran vdout1_20ck690 FIND v(dout1_20) AT=350.025n

.meas tran vdout1_21ck690 FIND v(dout1_21) AT=350.025n

.meas tran vdout1_22ck690 FIND v(dout1_22) AT=350.025n

.meas tran vdout1_23ck690 FIND v(dout1_23) AT=350.025n

.meas tran vdout1_24ck690 FIND v(dout1_24) AT=350.025n

.meas tran vdout1_25ck690 FIND v(dout1_25) AT=350.025n

.meas tran vdout1_26ck690 FIND v(dout1_26) AT=350.025n

.meas tran vdout1_27ck690 FIND v(dout1_27) AT=350.025n

.meas tran vdout1_28ck690 FIND v(dout1_28) AT=350.025n

.meas tran vdout1_29ck690 FIND v(dout1_29) AT=350.025n

.meas tran vdout1_30ck690 FIND v(dout1_30) AT=350.025n

.meas tran vdout1_31ck690 FIND v(dout1_31) AT=350.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_22ck740 FIND v(dout1_22) AT=375.025n

.meas tran vdout1_23ck740 FIND v(dout1_23) AT=375.025n

.meas tran vdout1_24ck740 FIND v(dout1_24) AT=375.025n

.meas tran vdout1_25ck740 FIND v(dout1_25) AT=375.025n

.meas tran vdout1_26ck740 FIND v(dout1_26) AT=375.025n

.meas tran vdout1_27ck740 FIND v(dout1_27) AT=375.025n

.meas tran vdout1_28ck740 FIND v(dout1_28) AT=375.025n

.meas tran vdout1_29ck740 FIND v(dout1_29) AT=375.025n

.meas tran vdout1_30ck740 FIND v(dout1_30) AT=375.025n

.meas tran vdout1_31ck740 FIND v(dout1_31) AT=375.025n

.meas tran vdout1_0ck780 FIND v(dout1_0) AT=395.025n

.meas tran vdout1_1ck780 FIND v(dout1_1) AT=395.025n

.meas tran vdout1_2ck780 FIND v(dout1_2) AT=395.025n

.meas tran vdout1_3ck780 FIND v(dout1_3) AT=395.025n

.meas tran vdout1_4ck780 FIND v(dout1_4) AT=395.025n

.meas tran vdout1_5ck780 FIND v(dout1_5) AT=395.025n

.meas tran vdout1_6ck780 FIND v(dout1_6) AT=395.025n

.meas tran vdout1_7ck780 FIND v(dout1_7) AT=395.025n

.meas tran vdout1_8ck780 FIND v(dout1_8) AT=395.025n

.meas tran vdout1_9ck780 FIND v(dout1_9) AT=395.025n

.meas tran vdout1_10ck780 FIND v(dout1_10) AT=395.025n

.meas tran vdout1_11ck780 FIND v(dout1_11) AT=395.025n

.meas tran vdout1_12ck780 FIND v(dout1_12) AT=395.025n

.meas tran vdout1_13ck780 FIND v(dout1_13) AT=395.025n

.meas tran vdout1_14ck780 FIND v(dout1_14) AT=395.025n

.meas tran vdout1_15ck780 FIND v(dout1_15) AT=395.025n

.meas tran vdout1_16ck780 FIND v(dout1_16) AT=395.025n

.meas tran vdout1_17ck780 FIND v(dout1_17) AT=395.025n

.meas tran vdout1_18ck780 FIND v(dout1_18) AT=395.025n

.meas tran vdout1_19ck780 FIND v(dout1_19) AT=395.025n

.meas tran vdout1_20ck780 FIND v(dout1_20) AT=395.025n

.meas tran vdout1_21ck780 FIND v(dout1_21) AT=395.025n

.meas tran vdout1_22ck780 FIND v(dout1_22) AT=395.025n

.meas tran vdout1_23ck780 FIND v(dout1_23) AT=395.025n

.meas tran vdout1_24ck780 FIND v(dout1_24) AT=395.025n

.meas tran vdout1_25ck780 FIND v(dout1_25) AT=395.025n

.meas tran vdout1_26ck780 FIND v(dout1_26) AT=395.025n

.meas tran vdout1_27ck780 FIND v(dout1_27) AT=395.025n

.meas tran vdout1_28ck780 FIND v(dout1_28) AT=395.025n

.meas tran vdout1_29ck780 FIND v(dout1_29) AT=395.025n

.meas tran vdout1_30ck780 FIND v(dout1_30) AT=395.025n

.meas tran vdout1_31ck780 FIND v(dout1_31) AT=395.025n

.meas tran vdout1_0ck790 FIND v(dout1_0) AT=400.025n

.meas tran vdout1_1ck790 FIND v(dout1_1) AT=400.025n

.meas tran vdout1_2ck790 FIND v(dout1_2) AT=400.025n

.meas tran vdout1_3ck790 FIND v(dout1_3) AT=400.025n

.meas tran vdout1_4ck790 FIND v(dout1_4) AT=400.025n

.meas tran vdout1_5ck790 FIND v(dout1_5) AT=400.025n

.meas tran vdout1_6ck790 FIND v(dout1_6) AT=400.025n

.meas tran vdout1_7ck790 FIND v(dout1_7) AT=400.025n

.meas tran vdout1_8ck790 FIND v(dout1_8) AT=400.025n

.meas tran vdout1_9ck790 FIND v(dout1_9) AT=400.025n

.meas tran vdout1_10ck790 FIND v(dout1_10) AT=400.025n

.meas tran vdout1_11ck790 FIND v(dout1_11) AT=400.025n

.meas tran vdout1_12ck790 FIND v(dout1_12) AT=400.025n

.meas tran vdout1_13ck790 FIND v(dout1_13) AT=400.025n

.meas tran vdout1_14ck790 FIND v(dout1_14) AT=400.025n

.meas tran vdout1_15ck790 FIND v(dout1_15) AT=400.025n

.meas tran vdout1_16ck790 FIND v(dout1_16) AT=400.025n

.meas tran vdout1_17ck790 FIND v(dout1_17) AT=400.025n

.meas tran vdout1_18ck790 FIND v(dout1_18) AT=400.025n

.meas tran vdout1_19ck790 FIND v(dout1_19) AT=400.025n

.meas tran vdout1_20ck790 FIND v(dout1_20) AT=400.025n

.meas tran vdout1_21ck790 FIND v(dout1_21) AT=400.025n

.meas tran vdout1_22ck790 FIND v(dout1_22) AT=400.025n

.meas tran vdout1_23ck790 FIND v(dout1_23) AT=400.025n

.meas tran vdout1_24ck790 FIND v(dout1_24) AT=400.025n

.meas tran vdout1_25ck790 FIND v(dout1_25) AT=400.025n

.meas tran vdout1_26ck790 FIND v(dout1_26) AT=400.025n

.meas tran vdout1_27ck790 FIND v(dout1_27) AT=400.025n

.meas tran vdout1_28ck790 FIND v(dout1_28) AT=400.025n

.meas tran vdout1_29ck790 FIND v(dout1_29) AT=400.025n

.meas tran vdout1_30ck790 FIND v(dout1_30) AT=400.025n

.meas tran vdout1_31ck790 FIND v(dout1_31) AT=400.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_8ck810 FIND v(dout1_8) AT=410.025n

.meas tran vdout1_9ck810 FIND v(dout1_9) AT=410.025n

.meas tran vdout1_10ck810 FIND v(dout1_10) AT=410.025n

.meas tran vdout1_11ck810 FIND v(dout1_11) AT=410.025n

.meas tran vdout1_12ck810 FIND v(dout1_12) AT=410.025n

.meas tran vdout1_13ck810 FIND v(dout1_13) AT=410.025n

.meas tran vdout1_14ck810 FIND v(dout1_14) AT=410.025n

.meas tran vdout1_15ck810 FIND v(dout1_15) AT=410.025n

.meas tran vdout1_16ck810 FIND v(dout1_16) AT=410.025n

.meas tran vdout1_17ck810 FIND v(dout1_17) AT=410.025n

.meas tran vdout1_18ck810 FIND v(dout1_18) AT=410.025n

.meas tran vdout1_19ck810 FIND v(dout1_19) AT=410.025n

.meas tran vdout1_20ck810 FIND v(dout1_20) AT=410.025n

.meas tran vdout1_21ck810 FIND v(dout1_21) AT=410.025n

.meas tran vdout1_22ck810 FIND v(dout1_22) AT=410.025n

.meas tran vdout1_23ck810 FIND v(dout1_23) AT=410.025n

.meas tran vdout1_24ck810 FIND v(dout1_24) AT=410.025n

.meas tran vdout1_25ck810 FIND v(dout1_25) AT=410.025n

.meas tran vdout1_26ck810 FIND v(dout1_26) AT=410.025n

.meas tran vdout1_27ck810 FIND v(dout1_27) AT=410.025n

.meas tran vdout1_28ck810 FIND v(dout1_28) AT=410.025n

.meas tran vdout1_29ck810 FIND v(dout1_29) AT=410.025n

.meas tran vdout1_30ck810 FIND v(dout1_30) AT=410.025n

.meas tran vdout1_31ck810 FIND v(dout1_31) AT=410.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_16ck820 FIND v(dout1_16) AT=415.025n

.meas tran vdout1_17ck820 FIND v(dout1_17) AT=415.025n

.meas tran vdout1_18ck820 FIND v(dout1_18) AT=415.025n

.meas tran vdout1_19ck820 FIND v(dout1_19) AT=415.025n

.meas tran vdout1_20ck820 FIND v(dout1_20) AT=415.025n

.meas tran vdout1_21ck820 FIND v(dout1_21) AT=415.025n

.meas tran vdout1_22ck820 FIND v(dout1_22) AT=415.025n

.meas tran vdout1_23ck820 FIND v(dout1_23) AT=415.025n

.meas tran vdout1_24ck820 FIND v(dout1_24) AT=415.025n

.meas tran vdout1_25ck820 FIND v(dout1_25) AT=415.025n

.meas tran vdout1_26ck820 FIND v(dout1_26) AT=415.025n

.meas tran vdout1_27ck820 FIND v(dout1_27) AT=415.025n

.meas tran vdout1_28ck820 FIND v(dout1_28) AT=415.025n

.meas tran vdout1_29ck820 FIND v(dout1_29) AT=415.025n

.meas tran vdout1_30ck820 FIND v(dout1_30) AT=415.025n

.meas tran vdout1_31ck820 FIND v(dout1_31) AT=415.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_0ck870 FIND v(dout1_0) AT=440.025n

.meas tran vdout1_1ck870 FIND v(dout1_1) AT=440.025n

.meas tran vdout1_2ck870 FIND v(dout1_2) AT=440.025n

.meas tran vdout1_3ck870 FIND v(dout1_3) AT=440.025n

.meas tran vdout1_4ck870 FIND v(dout1_4) AT=440.025n

.meas tran vdout1_5ck870 FIND v(dout1_5) AT=440.025n

.meas tran vdout1_6ck870 FIND v(dout1_6) AT=440.025n

.meas tran vdout1_7ck870 FIND v(dout1_7) AT=440.025n

.meas tran vdout1_8ck870 FIND v(dout1_8) AT=440.025n

.meas tran vdout1_9ck870 FIND v(dout1_9) AT=440.025n

.meas tran vdout1_10ck870 FIND v(dout1_10) AT=440.025n

.meas tran vdout1_11ck870 FIND v(dout1_11) AT=440.025n

.meas tran vdout1_12ck870 FIND v(dout1_12) AT=440.025n

.meas tran vdout1_13ck870 FIND v(dout1_13) AT=440.025n

.meas tran vdout1_14ck870 FIND v(dout1_14) AT=440.025n

.meas tran vdout1_15ck870 FIND v(dout1_15) AT=440.025n

.meas tran vdout1_16ck870 FIND v(dout1_16) AT=440.025n

.meas tran vdout1_17ck870 FIND v(dout1_17) AT=440.025n

.meas tran vdout1_18ck870 FIND v(dout1_18) AT=440.025n

.meas tran vdout1_19ck870 FIND v(dout1_19) AT=440.025n

.meas tran vdout1_20ck870 FIND v(dout1_20) AT=440.025n

.meas tran vdout1_21ck870 FIND v(dout1_21) AT=440.025n

.meas tran vdout1_22ck870 FIND v(dout1_22) AT=440.025n

.meas tran vdout1_23ck870 FIND v(dout1_23) AT=440.025n

.meas tran vdout1_24ck870 FIND v(dout1_24) AT=440.025n

.meas tran vdout1_25ck870 FIND v(dout1_25) AT=440.025n

.meas tran vdout1_26ck870 FIND v(dout1_26) AT=440.025n

.meas tran vdout1_27ck870 FIND v(dout1_27) AT=440.025n

.meas tran vdout1_28ck870 FIND v(dout1_28) AT=440.025n

.meas tran vdout1_29ck870 FIND v(dout1_29) AT=440.025n

.meas tran vdout1_30ck870 FIND v(dout1_30) AT=440.025n

.meas tran vdout1_31ck870 FIND v(dout1_31) AT=440.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_16ck920 FIND v(dout1_16) AT=465.025n

.meas tran vdout1_17ck920 FIND v(dout1_17) AT=465.025n

.meas tran vdout1_18ck920 FIND v(dout1_18) AT=465.025n

.meas tran vdout1_19ck920 FIND v(dout1_19) AT=465.025n

.meas tran vdout1_20ck920 FIND v(dout1_20) AT=465.025n

.meas tran vdout1_21ck920 FIND v(dout1_21) AT=465.025n

.meas tran vdout1_22ck920 FIND v(dout1_22) AT=465.025n

.meas tran vdout1_23ck920 FIND v(dout1_23) AT=465.025n

.meas tran vdout1_24ck920 FIND v(dout1_24) AT=465.025n

.meas tran vdout1_25ck920 FIND v(dout1_25) AT=465.025n

.meas tran vdout1_26ck920 FIND v(dout1_26) AT=465.025n

.meas tran vdout1_27ck920 FIND v(dout1_27) AT=465.025n

.meas tran vdout1_28ck920 FIND v(dout1_28) AT=465.025n

.meas tran vdout1_29ck920 FIND v(dout1_29) AT=465.025n

.meas tran vdout1_30ck920 FIND v(dout1_30) AT=465.025n

.meas tran vdout1_31ck920 FIND v(dout1_31) AT=465.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_0ck970 FIND v(dout1_0) AT=490.025n

.meas tran vdout1_1ck970 FIND v(dout1_1) AT=490.025n

.meas tran vdout1_2ck970 FIND v(dout1_2) AT=490.025n

.meas tran vdout1_3ck970 FIND v(dout1_3) AT=490.025n

.meas tran vdout1_4ck970 FIND v(dout1_4) AT=490.025n

.meas tran vdout1_5ck970 FIND v(dout1_5) AT=490.025n

.meas tran vdout1_6ck970 FIND v(dout1_6) AT=490.025n

.meas tran vdout1_7ck970 FIND v(dout1_7) AT=490.025n

.meas tran vdout1_8ck970 FIND v(dout1_8) AT=490.025n

.meas tran vdout1_9ck970 FIND v(dout1_9) AT=490.025n

.meas tran vdout1_10ck970 FIND v(dout1_10) AT=490.025n

.meas tran vdout1_11ck970 FIND v(dout1_11) AT=490.025n

.meas tran vdout1_12ck970 FIND v(dout1_12) AT=490.025n

.meas tran vdout1_13ck970 FIND v(dout1_13) AT=490.025n

.meas tran vdout1_14ck970 FIND v(dout1_14) AT=490.025n

.meas tran vdout1_15ck970 FIND v(dout1_15) AT=490.025n

.meas tran vdout1_16ck970 FIND v(dout1_16) AT=490.025n

.meas tran vdout1_17ck970 FIND v(dout1_17) AT=490.025n

.meas tran vdout1_18ck970 FIND v(dout1_18) AT=490.025n

.meas tran vdout1_19ck970 FIND v(dout1_19) AT=490.025n

.meas tran vdout1_20ck970 FIND v(dout1_20) AT=490.025n

.meas tran vdout1_21ck970 FIND v(dout1_21) AT=490.025n

.meas tran vdout1_22ck970 FIND v(dout1_22) AT=490.025n

.meas tran vdout1_23ck970 FIND v(dout1_23) AT=490.025n

.meas tran vdout1_24ck970 FIND v(dout1_24) AT=490.025n

.meas tran vdout1_25ck970 FIND v(dout1_25) AT=490.025n

.meas tran vdout1_26ck970 FIND v(dout1_26) AT=490.025n

.meas tran vdout1_27ck970 FIND v(dout1_27) AT=490.025n

.meas tran vdout1_28ck970 FIND v(dout1_28) AT=490.025n

.meas tran vdout1_29ck970 FIND v(dout1_29) AT=490.025n

.meas tran vdout1_30ck970 FIND v(dout1_30) AT=490.025n

.meas tran vdout1_31ck970 FIND v(dout1_31) AT=490.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_23ck990 FIND v(dout1_23) AT=500.025n

.meas tran vdout1_24ck990 FIND v(dout1_24) AT=500.025n

.meas tran vdout1_25ck990 FIND v(dout1_25) AT=500.025n

.meas tran vdout1_26ck990 FIND v(dout1_26) AT=500.025n

.meas tran vdout1_27ck990 FIND v(dout1_27) AT=500.025n

.meas tran vdout1_28ck990 FIND v(dout1_28) AT=500.025n

.meas tran vdout1_29ck990 FIND v(dout1_29) AT=500.025n

.meas tran vdout1_30ck990 FIND v(dout1_30) AT=500.025n

.meas tran vdout1_31ck990 FIND v(dout1_31) AT=500.025n

.meas tran vdout1_0ck1000 FIND v(dout1_0) AT=505.025n

.meas tran vdout1_1ck1000 FIND v(dout1_1) AT=505.025n

.meas tran vdout1_2ck1000 FIND v(dout1_2) AT=505.025n

.meas tran vdout1_3ck1000 FIND v(dout1_3) AT=505.025n

.meas tran vdout1_4ck1000 FIND v(dout1_4) AT=505.025n

.meas tran vdout1_5ck1000 FIND v(dout1_5) AT=505.025n

.meas tran vdout1_6ck1000 FIND v(dout1_6) AT=505.025n

.meas tran vdout1_7ck1000 FIND v(dout1_7) AT=505.025n

.meas tran vdout1_8ck1000 FIND v(dout1_8) AT=505.025n

.meas tran vdout1_9ck1000 FIND v(dout1_9) AT=505.025n

.meas tran vdout1_10ck1000 FIND v(dout1_10) AT=505.025n

.meas tran vdout1_11ck1000 FIND v(dout1_11) AT=505.025n

.meas tran vdout1_12ck1000 FIND v(dout1_12) AT=505.025n

.meas tran vdout1_13ck1000 FIND v(dout1_13) AT=505.025n

.meas tran vdout1_14ck1000 FIND v(dout1_14) AT=505.025n

.meas tran vdout1_15ck1000 FIND v(dout1_15) AT=505.025n

.meas tran vdout1_16ck1000 FIND v(dout1_16) AT=505.025n

.meas tran vdout1_17ck1000 FIND v(dout1_17) AT=505.025n

.meas tran vdout1_18ck1000 FIND v(dout1_18) AT=505.025n

.meas tran vdout1_19ck1000 FIND v(dout1_19) AT=505.025n

.meas tran vdout1_20ck1000 FIND v(dout1_20) AT=505.025n

.meas tran vdout1_21ck1000 FIND v(dout1_21) AT=505.025n

.meas tran vdout1_22ck1000 FIND v(dout1_22) AT=505.025n

.meas tran vdout1_23ck1000 FIND v(dout1_23) AT=505.025n

.meas tran vdout1_24ck1000 FIND v(dout1_24) AT=505.025n

.meas tran vdout1_25ck1000 FIND v(dout1_25) AT=505.025n

.meas tran vdout1_26ck1000 FIND v(dout1_26) AT=505.025n

.meas tran vdout1_27ck1000 FIND v(dout1_27) AT=505.025n

.meas tran vdout1_28ck1000 FIND v(dout1_28) AT=505.025n

.meas tran vdout1_29ck1000 FIND v(dout1_29) AT=505.025n

.meas tran vdout1_30ck1000 FIND v(dout1_30) AT=505.025n

.meas tran vdout1_31ck1000 FIND v(dout1_31) AT=505.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_17ck1020 FIND v(dout1_17) AT=515.025n

.meas tran vdout1_18ck1020 FIND v(dout1_18) AT=515.025n

.meas tran vdout1_19ck1020 FIND v(dout1_19) AT=515.025n

.meas tran vdout1_20ck1020 FIND v(dout1_20) AT=515.025n

.meas tran vdout1_21ck1020 FIND v(dout1_21) AT=515.025n

.meas tran vdout1_22ck1020 FIND v(dout1_22) AT=515.025n

.meas tran vdout1_23ck1020 FIND v(dout1_23) AT=515.025n

.meas tran vdout1_24ck1020 FIND v(dout1_24) AT=515.025n

.meas tran vdout1_25ck1020 FIND v(dout1_25) AT=515.025n

.meas tran vdout1_26ck1020 FIND v(dout1_26) AT=515.025n

.meas tran vdout1_27ck1020 FIND v(dout1_27) AT=515.025n

.meas tran vdout1_28ck1020 FIND v(dout1_28) AT=515.025n

.meas tran vdout1_29ck1020 FIND v(dout1_29) AT=515.025n

.meas tran vdout1_30ck1020 FIND v(dout1_30) AT=515.025n

.meas tran vdout1_31ck1020 FIND v(dout1_31) AT=515.025n

.meas tran vdout1_0ck1040 FIND v(dout1_0) AT=525.025n

.meas tran vdout1_1ck1040 FIND v(dout1_1) AT=525.025n

.meas tran vdout1_2ck1040 FIND v(dout1_2) AT=525.025n

.meas tran vdout1_3ck1040 FIND v(dout1_3) AT=525.025n

.meas tran vdout1_4ck1040 FIND v(dout1_4) AT=525.025n

.meas tran vdout1_5ck1040 FIND v(dout1_5) AT=525.025n

.meas tran vdout1_6ck1040 FIND v(dout1_6) AT=525.025n

.meas tran vdout1_7ck1040 FIND v(dout1_7) AT=525.025n

.meas tran vdout1_8ck1040 FIND v(dout1_8) AT=525.025n

.meas tran vdout1_9ck1040 FIND v(dout1_9) AT=525.025n

.meas tran vdout1_10ck1040 FIND v(dout1_10) AT=525.025n

.meas tran vdout1_11ck1040 FIND v(dout1_11) AT=525.025n

.meas tran vdout1_12ck1040 FIND v(dout1_12) AT=525.025n

.meas tran vdout1_13ck1040 FIND v(dout1_13) AT=525.025n

.meas tran vdout1_14ck1040 FIND v(dout1_14) AT=525.025n

.meas tran vdout1_15ck1040 FIND v(dout1_15) AT=525.025n

.meas tran vdout1_16ck1040 FIND v(dout1_16) AT=525.025n

.meas tran vdout1_17ck1040 FIND v(dout1_17) AT=525.025n

.meas tran vdout1_18ck1040 FIND v(dout1_18) AT=525.025n

.meas tran vdout1_19ck1040 FIND v(dout1_19) AT=525.025n

.meas tran vdout1_20ck1040 FIND v(dout1_20) AT=525.025n

.meas tran vdout1_21ck1040 FIND v(dout1_21) AT=525.025n

.meas tran vdout1_22ck1040 FIND v(dout1_22) AT=525.025n

.meas tran vdout1_23ck1040 FIND v(dout1_23) AT=525.025n

.meas tran vdout1_24ck1040 FIND v(dout1_24) AT=525.025n

.meas tran vdout1_25ck1040 FIND v(dout1_25) AT=525.025n

.meas tran vdout1_26ck1040 FIND v(dout1_26) AT=525.025n

.meas tran vdout1_27ck1040 FIND v(dout1_27) AT=525.025n

.meas tran vdout1_28ck1040 FIND v(dout1_28) AT=525.025n

.meas tran vdout1_29ck1040 FIND v(dout1_29) AT=525.025n

.meas tran vdout1_30ck1040 FIND v(dout1_30) AT=525.025n

.meas tran vdout1_31ck1040 FIND v(dout1_31) AT=525.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_23ck1070 FIND v(dout1_23) AT=540.025n

.meas tran vdout1_24ck1070 FIND v(dout1_24) AT=540.025n

.meas tran vdout1_25ck1070 FIND v(dout1_25) AT=540.025n

.meas tran vdout1_26ck1070 FIND v(dout1_26) AT=540.025n

.meas tran vdout1_27ck1070 FIND v(dout1_27) AT=540.025n

.meas tran vdout1_28ck1070 FIND v(dout1_28) AT=540.025n

.meas tran vdout1_29ck1070 FIND v(dout1_29) AT=540.025n

.meas tran vdout1_30ck1070 FIND v(dout1_30) AT=540.025n

.meas tran vdout1_31ck1070 FIND v(dout1_31) AT=540.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_23ck1090 FIND v(dout1_23) AT=550.025n

.meas tran vdout1_24ck1090 FIND v(dout1_24) AT=550.025n

.meas tran vdout1_25ck1090 FIND v(dout1_25) AT=550.025n

.meas tran vdout1_26ck1090 FIND v(dout1_26) AT=550.025n

.meas tran vdout1_27ck1090 FIND v(dout1_27) AT=550.025n

.meas tran vdout1_28ck1090 FIND v(dout1_28) AT=550.025n

.meas tran vdout1_29ck1090 FIND v(dout1_29) AT=550.025n

.meas tran vdout1_30ck1090 FIND v(dout1_30) AT=550.025n

.meas tran vdout1_31ck1090 FIND v(dout1_31) AT=550.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_22ck1100 FIND v(dout1_22) AT=555.025n

.meas tran vdout1_23ck1100 FIND v(dout1_23) AT=555.025n

.meas tran vdout1_24ck1100 FIND v(dout1_24) AT=555.025n

.meas tran vdout1_25ck1100 FIND v(dout1_25) AT=555.025n

.meas tran vdout1_26ck1100 FIND v(dout1_26) AT=555.025n

.meas tran vdout1_27ck1100 FIND v(dout1_27) AT=555.025n

.meas tran vdout1_28ck1100 FIND v(dout1_28) AT=555.025n

.meas tran vdout1_29ck1100 FIND v(dout1_29) AT=555.025n

.meas tran vdout1_30ck1100 FIND v(dout1_30) AT=555.025n

.meas tran vdout1_31ck1100 FIND v(dout1_31) AT=555.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_19ck1110 FIND v(dout1_19) AT=560.025n

.meas tran vdout1_20ck1110 FIND v(dout1_20) AT=560.025n

.meas tran vdout1_21ck1110 FIND v(dout1_21) AT=560.025n

.meas tran vdout1_22ck1110 FIND v(dout1_22) AT=560.025n

.meas tran vdout1_23ck1110 FIND v(dout1_23) AT=560.025n

.meas tran vdout1_24ck1110 FIND v(dout1_24) AT=560.025n

.meas tran vdout1_25ck1110 FIND v(dout1_25) AT=560.025n

.meas tran vdout1_26ck1110 FIND v(dout1_26) AT=560.025n

.meas tran vdout1_27ck1110 FIND v(dout1_27) AT=560.025n

.meas tran vdout1_28ck1110 FIND v(dout1_28) AT=560.025n

.meas tran vdout1_29ck1110 FIND v(dout1_29) AT=560.025n

.meas tran vdout1_30ck1110 FIND v(dout1_30) AT=560.025n

.meas tran vdout1_31ck1110 FIND v(dout1_31) AT=560.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_23ck1200 FIND v(dout1_23) AT=605.025n

.meas tran vdout1_24ck1200 FIND v(dout1_24) AT=605.025n

.meas tran vdout1_25ck1200 FIND v(dout1_25) AT=605.025n

.meas tran vdout1_26ck1200 FIND v(dout1_26) AT=605.025n

.meas tran vdout1_27ck1200 FIND v(dout1_27) AT=605.025n

.meas tran vdout1_28ck1200 FIND v(dout1_28) AT=605.025n

.meas tran vdout1_29ck1200 FIND v(dout1_29) AT=605.025n

.meas tran vdout1_30ck1200 FIND v(dout1_30) AT=605.025n

.meas tran vdout1_31ck1200 FIND v(dout1_31) AT=605.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_22ck1220 FIND v(dout1_22) AT=615.025n

.meas tran vdout1_23ck1220 FIND v(dout1_23) AT=615.025n

.meas tran vdout1_24ck1220 FIND v(dout1_24) AT=615.025n

.meas tran vdout1_25ck1220 FIND v(dout1_25) AT=615.025n

.meas tran vdout1_26ck1220 FIND v(dout1_26) AT=615.025n

.meas tran vdout1_27ck1220 FIND v(dout1_27) AT=615.025n

.meas tran vdout1_28ck1220 FIND v(dout1_28) AT=615.025n

.meas tran vdout1_29ck1220 FIND v(dout1_29) AT=615.025n

.meas tran vdout1_30ck1220 FIND v(dout1_30) AT=615.025n

.meas tran vdout1_31ck1220 FIND v(dout1_31) AT=615.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_19ck1240 FIND v(dout1_19) AT=625.025n

.meas tran vdout1_20ck1240 FIND v(dout1_20) AT=625.025n

.meas tran vdout1_21ck1240 FIND v(dout1_21) AT=625.025n

.meas tran vdout1_22ck1240 FIND v(dout1_22) AT=625.025n

.meas tran vdout1_23ck1240 FIND v(dout1_23) AT=625.025n

.meas tran vdout1_24ck1240 FIND v(dout1_24) AT=625.025n

.meas tran vdout1_25ck1240 FIND v(dout1_25) AT=625.025n

.meas tran vdout1_26ck1240 FIND v(dout1_26) AT=625.025n

.meas tran vdout1_27ck1240 FIND v(dout1_27) AT=625.025n

.meas tran vdout1_28ck1240 FIND v(dout1_28) AT=625.025n

.meas tran vdout1_29ck1240 FIND v(dout1_29) AT=625.025n

.meas tran vdout1_30ck1240 FIND v(dout1_30) AT=625.025n

.meas tran vdout1_31ck1240 FIND v(dout1_31) AT=625.025n

.meas tran vdout1_0ck1250 FIND v(dout1_0) AT=630.025n

.meas tran vdout1_1ck1250 FIND v(dout1_1) AT=630.025n

.meas tran vdout1_2ck1250 FIND v(dout1_2) AT=630.025n

.meas tran vdout1_3ck1250 FIND v(dout1_3) AT=630.025n

.meas tran vdout1_4ck1250 FIND v(dout1_4) AT=630.025n

.meas tran vdout1_5ck1250 FIND v(dout1_5) AT=630.025n

.meas tran vdout1_6ck1250 FIND v(dout1_6) AT=630.025n

.meas tran vdout1_7ck1250 FIND v(dout1_7) AT=630.025n

.meas tran vdout1_8ck1250 FIND v(dout1_8) AT=630.025n

.meas tran vdout1_9ck1250 FIND v(dout1_9) AT=630.025n

.meas tran vdout1_10ck1250 FIND v(dout1_10) AT=630.025n

.meas tran vdout1_11ck1250 FIND v(dout1_11) AT=630.025n

.meas tran vdout1_12ck1250 FIND v(dout1_12) AT=630.025n

.meas tran vdout1_13ck1250 FIND v(dout1_13) AT=630.025n

.meas tran vdout1_14ck1250 FIND v(dout1_14) AT=630.025n

.meas tran vdout1_15ck1250 FIND v(dout1_15) AT=630.025n

.meas tran vdout1_16ck1250 FIND v(dout1_16) AT=630.025n

.meas tran vdout1_17ck1250 FIND v(dout1_17) AT=630.025n

.meas tran vdout1_18ck1250 FIND v(dout1_18) AT=630.025n

.meas tran vdout1_19ck1250 FIND v(dout1_19) AT=630.025n

.meas tran vdout1_20ck1250 FIND v(dout1_20) AT=630.025n

.meas tran vdout1_21ck1250 FIND v(dout1_21) AT=630.025n

.meas tran vdout1_22ck1250 FIND v(dout1_22) AT=630.025n

.meas tran vdout1_23ck1250 FIND v(dout1_23) AT=630.025n

.meas tran vdout1_24ck1250 FIND v(dout1_24) AT=630.025n

.meas tran vdout1_25ck1250 FIND v(dout1_25) AT=630.025n

.meas tran vdout1_26ck1250 FIND v(dout1_26) AT=630.025n

.meas tran vdout1_27ck1250 FIND v(dout1_27) AT=630.025n

.meas tran vdout1_28ck1250 FIND v(dout1_28) AT=630.025n

.meas tran vdout1_29ck1250 FIND v(dout1_29) AT=630.025n

.meas tran vdout1_30ck1250 FIND v(dout1_30) AT=630.025n

.meas tran vdout1_31ck1250 FIND v(dout1_31) AT=630.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_22ck1320 FIND v(dout1_22) AT=665.025n

.meas tran vdout1_23ck1320 FIND v(dout1_23) AT=665.025n

.meas tran vdout1_24ck1320 FIND v(dout1_24) AT=665.025n

.meas tran vdout1_25ck1320 FIND v(dout1_25) AT=665.025n

.meas tran vdout1_26ck1320 FIND v(dout1_26) AT=665.025n

.meas tran vdout1_27ck1320 FIND v(dout1_27) AT=665.025n

.meas tran vdout1_28ck1320 FIND v(dout1_28) AT=665.025n

.meas tran vdout1_29ck1320 FIND v(dout1_29) AT=665.025n

.meas tran vdout1_30ck1320 FIND v(dout1_30) AT=665.025n

.meas tran vdout1_31ck1320 FIND v(dout1_31) AT=665.025n

.meas tran vdout1_0ck1330 FIND v(dout1_0) AT=670.025n

.meas tran vdout1_1ck1330 FIND v(dout1_1) AT=670.025n

.meas tran vdout1_2ck1330 FIND v(dout1_2) AT=670.025n

.meas tran vdout1_3ck1330 FIND v(dout1_3) AT=670.025n

.meas tran vdout1_4ck1330 FIND v(dout1_4) AT=670.025n

.meas tran vdout1_5ck1330 FIND v(dout1_5) AT=670.025n

.meas tran vdout1_6ck1330 FIND v(dout1_6) AT=670.025n

.meas tran vdout1_7ck1330 FIND v(dout1_7) AT=670.025n

.meas tran vdout1_8ck1330 FIND v(dout1_8) AT=670.025n

.meas tran vdout1_9ck1330 FIND v(dout1_9) AT=670.025n

.meas tran vdout1_10ck1330 FIND v(dout1_10) AT=670.025n

.meas tran vdout1_11ck1330 FIND v(dout1_11) AT=670.025n

.meas tran vdout1_12ck1330 FIND v(dout1_12) AT=670.025n

.meas tran vdout1_13ck1330 FIND v(dout1_13) AT=670.025n

.meas tran vdout1_14ck1330 FIND v(dout1_14) AT=670.025n

.meas tran vdout1_15ck1330 FIND v(dout1_15) AT=670.025n

.meas tran vdout1_16ck1330 FIND v(dout1_16) AT=670.025n

.meas tran vdout1_17ck1330 FIND v(dout1_17) AT=670.025n

.meas tran vdout1_18ck1330 FIND v(dout1_18) AT=670.025n

.meas tran vdout1_19ck1330 FIND v(dout1_19) AT=670.025n

.meas tran vdout1_20ck1330 FIND v(dout1_20) AT=670.025n

.meas tran vdout1_21ck1330 FIND v(dout1_21) AT=670.025n

.meas tran vdout1_22ck1330 FIND v(dout1_22) AT=670.025n

.meas tran vdout1_23ck1330 FIND v(dout1_23) AT=670.025n

.meas tran vdout1_24ck1330 FIND v(dout1_24) AT=670.025n

.meas tran vdout1_25ck1330 FIND v(dout1_25) AT=670.025n

.meas tran vdout1_26ck1330 FIND v(dout1_26) AT=670.025n

.meas tran vdout1_27ck1330 FIND v(dout1_27) AT=670.025n

.meas tran vdout1_28ck1330 FIND v(dout1_28) AT=670.025n

.meas tran vdout1_29ck1330 FIND v(dout1_29) AT=670.025n

.meas tran vdout1_30ck1330 FIND v(dout1_30) AT=670.025n

.meas tran vdout1_31ck1330 FIND v(dout1_31) AT=670.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_16ck1360 FIND v(dout1_16) AT=685.025n

.meas tran vdout1_17ck1360 FIND v(dout1_17) AT=685.025n

.meas tran vdout1_18ck1360 FIND v(dout1_18) AT=685.025n

.meas tran vdout1_19ck1360 FIND v(dout1_19) AT=685.025n

.meas tran vdout1_20ck1360 FIND v(dout1_20) AT=685.025n

.meas tran vdout1_21ck1360 FIND v(dout1_21) AT=685.025n

.meas tran vdout1_22ck1360 FIND v(dout1_22) AT=685.025n

.meas tran vdout1_23ck1360 FIND v(dout1_23) AT=685.025n

.meas tran vdout1_24ck1360 FIND v(dout1_24) AT=685.025n

.meas tran vdout1_25ck1360 FIND v(dout1_25) AT=685.025n

.meas tran vdout1_26ck1360 FIND v(dout1_26) AT=685.025n

.meas tran vdout1_27ck1360 FIND v(dout1_27) AT=685.025n

.meas tran vdout1_28ck1360 FIND v(dout1_28) AT=685.025n

.meas tran vdout1_29ck1360 FIND v(dout1_29) AT=685.025n

.meas tran vdout1_30ck1360 FIND v(dout1_30) AT=685.025n

.meas tran vdout1_31ck1360 FIND v(dout1_31) AT=685.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_22ck1410 FIND v(dout1_22) AT=710.025n

.meas tran vdout1_23ck1410 FIND v(dout1_23) AT=710.025n

.meas tran vdout1_24ck1410 FIND v(dout1_24) AT=710.025n

.meas tran vdout1_25ck1410 FIND v(dout1_25) AT=710.025n

.meas tran vdout1_26ck1410 FIND v(dout1_26) AT=710.025n

.meas tran vdout1_27ck1410 FIND v(dout1_27) AT=710.025n

.meas tran vdout1_28ck1410 FIND v(dout1_28) AT=710.025n

.meas tran vdout1_29ck1410 FIND v(dout1_29) AT=710.025n

.meas tran vdout1_30ck1410 FIND v(dout1_30) AT=710.025n

.meas tran vdout1_31ck1410 FIND v(dout1_31) AT=710.025n

.meas tran vdout1_0ck1450 FIND v(dout1_0) AT=730.025n

.meas tran vdout1_1ck1450 FIND v(dout1_1) AT=730.025n

.meas tran vdout1_2ck1450 FIND v(dout1_2) AT=730.025n

.meas tran vdout1_3ck1450 FIND v(dout1_3) AT=730.025n

.meas tran vdout1_4ck1450 FIND v(dout1_4) AT=730.025n

.meas tran vdout1_5ck1450 FIND v(dout1_5) AT=730.025n

.meas tran vdout1_6ck1450 FIND v(dout1_6) AT=730.025n

.meas tran vdout1_7ck1450 FIND v(dout1_7) AT=730.025n

.meas tran vdout1_8ck1450 FIND v(dout1_8) AT=730.025n

.meas tran vdout1_9ck1450 FIND v(dout1_9) AT=730.025n

.meas tran vdout1_10ck1450 FIND v(dout1_10) AT=730.025n

.meas tran vdout1_11ck1450 FIND v(dout1_11) AT=730.025n

.meas tran vdout1_12ck1450 FIND v(dout1_12) AT=730.025n

.meas tran vdout1_13ck1450 FIND v(dout1_13) AT=730.025n

.meas tran vdout1_14ck1450 FIND v(dout1_14) AT=730.025n

.meas tran vdout1_15ck1450 FIND v(dout1_15) AT=730.025n

.meas tran vdout1_16ck1450 FIND v(dout1_16) AT=730.025n

.meas tran vdout1_17ck1450 FIND v(dout1_17) AT=730.025n

.meas tran vdout1_18ck1450 FIND v(dout1_18) AT=730.025n

.meas tran vdout1_19ck1450 FIND v(dout1_19) AT=730.025n

.meas tran vdout1_20ck1450 FIND v(dout1_20) AT=730.025n

.meas tran vdout1_21ck1450 FIND v(dout1_21) AT=730.025n

.meas tran vdout1_22ck1450 FIND v(dout1_22) AT=730.025n

.meas tran vdout1_23ck1450 FIND v(dout1_23) AT=730.025n

.meas tran vdout1_24ck1450 FIND v(dout1_24) AT=730.025n

.meas tran vdout1_25ck1450 FIND v(dout1_25) AT=730.025n

.meas tran vdout1_26ck1450 FIND v(dout1_26) AT=730.025n

.meas tran vdout1_27ck1450 FIND v(dout1_27) AT=730.025n

.meas tran vdout1_28ck1450 FIND v(dout1_28) AT=730.025n

.meas tran vdout1_29ck1450 FIND v(dout1_29) AT=730.025n

.meas tran vdout1_30ck1450 FIND v(dout1_30) AT=730.025n

.meas tran vdout1_31ck1450 FIND v(dout1_31) AT=730.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_16ck1480 FIND v(dout1_16) AT=745.025n

.meas tran vdout1_17ck1480 FIND v(dout1_17) AT=745.025n

.meas tran vdout1_18ck1480 FIND v(dout1_18) AT=745.025n

.meas tran vdout1_19ck1480 FIND v(dout1_19) AT=745.025n

.meas tran vdout1_20ck1480 FIND v(dout1_20) AT=745.025n

.meas tran vdout1_21ck1480 FIND v(dout1_21) AT=745.025n

.meas tran vdout1_22ck1480 FIND v(dout1_22) AT=745.025n

.meas tran vdout1_23ck1480 FIND v(dout1_23) AT=745.025n

.meas tran vdout1_24ck1480 FIND v(dout1_24) AT=745.025n

.meas tran vdout1_25ck1480 FIND v(dout1_25) AT=745.025n

.meas tran vdout1_26ck1480 FIND v(dout1_26) AT=745.025n

.meas tran vdout1_27ck1480 FIND v(dout1_27) AT=745.025n

.meas tran vdout1_28ck1480 FIND v(dout1_28) AT=745.025n

.meas tran vdout1_29ck1480 FIND v(dout1_29) AT=745.025n

.meas tran vdout1_30ck1480 FIND v(dout1_30) AT=745.025n

.meas tran vdout1_31ck1480 FIND v(dout1_31) AT=745.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_22ck1500 FIND v(dout1_22) AT=755.025n

.meas tran vdout1_23ck1500 FIND v(dout1_23) AT=755.025n

.meas tran vdout1_24ck1500 FIND v(dout1_24) AT=755.025n

.meas tran vdout1_25ck1500 FIND v(dout1_25) AT=755.025n

.meas tran vdout1_26ck1500 FIND v(dout1_26) AT=755.025n

.meas tran vdout1_27ck1500 FIND v(dout1_27) AT=755.025n

.meas tran vdout1_28ck1500 FIND v(dout1_28) AT=755.025n

.meas tran vdout1_29ck1500 FIND v(dout1_29) AT=755.025n

.meas tran vdout1_30ck1500 FIND v(dout1_30) AT=755.025n

.meas tran vdout1_31ck1500 FIND v(dout1_31) AT=755.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_16ck1560 FIND v(dout1_16) AT=785.025n

.meas tran vdout1_17ck1560 FIND v(dout1_17) AT=785.025n

.meas tran vdout1_18ck1560 FIND v(dout1_18) AT=785.025n

.meas tran vdout1_19ck1560 FIND v(dout1_19) AT=785.025n

.meas tran vdout1_20ck1560 FIND v(dout1_20) AT=785.025n

.meas tran vdout1_21ck1560 FIND v(dout1_21) AT=785.025n

.meas tran vdout1_22ck1560 FIND v(dout1_22) AT=785.025n

.meas tran vdout1_23ck1560 FIND v(dout1_23) AT=785.025n

.meas tran vdout1_24ck1560 FIND v(dout1_24) AT=785.025n

.meas tran vdout1_25ck1560 FIND v(dout1_25) AT=785.025n

.meas tran vdout1_26ck1560 FIND v(dout1_26) AT=785.025n

.meas tran vdout1_27ck1560 FIND v(dout1_27) AT=785.025n

.meas tran vdout1_28ck1560 FIND v(dout1_28) AT=785.025n

.meas tran vdout1_29ck1560 FIND v(dout1_29) AT=785.025n

.meas tran vdout1_30ck1560 FIND v(dout1_30) AT=785.025n

.meas tran vdout1_31ck1560 FIND v(dout1_31) AT=785.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_19ck1600 FIND v(dout1_19) AT=805.025n

.meas tran vdout1_20ck1600 FIND v(dout1_20) AT=805.025n

.meas tran vdout1_21ck1600 FIND v(dout1_21) AT=805.025n

.meas tran vdout1_22ck1600 FIND v(dout1_22) AT=805.025n

.meas tran vdout1_23ck1600 FIND v(dout1_23) AT=805.025n

.meas tran vdout1_24ck1600 FIND v(dout1_24) AT=805.025n

.meas tran vdout1_25ck1600 FIND v(dout1_25) AT=805.025n

.meas tran vdout1_26ck1600 FIND v(dout1_26) AT=805.025n

.meas tran vdout1_27ck1600 FIND v(dout1_27) AT=805.025n

.meas tran vdout1_28ck1600 FIND v(dout1_28) AT=805.025n

.meas tran vdout1_29ck1600 FIND v(dout1_29) AT=805.025n

.meas tran vdout1_30ck1600 FIND v(dout1_30) AT=805.025n

.meas tran vdout1_31ck1600 FIND v(dout1_31) AT=805.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_19ck1650 FIND v(dout1_19) AT=830.025n

.meas tran vdout1_20ck1650 FIND v(dout1_20) AT=830.025n

.meas tran vdout1_21ck1650 FIND v(dout1_21) AT=830.025n

.meas tran vdout1_22ck1650 FIND v(dout1_22) AT=830.025n

.meas tran vdout1_23ck1650 FIND v(dout1_23) AT=830.025n

.meas tran vdout1_24ck1650 FIND v(dout1_24) AT=830.025n

.meas tran vdout1_25ck1650 FIND v(dout1_25) AT=830.025n

.meas tran vdout1_26ck1650 FIND v(dout1_26) AT=830.025n

.meas tran vdout1_27ck1650 FIND v(dout1_27) AT=830.025n

.meas tran vdout1_28ck1650 FIND v(dout1_28) AT=830.025n

.meas tran vdout1_29ck1650 FIND v(dout1_29) AT=830.025n

.meas tran vdout1_30ck1650 FIND v(dout1_30) AT=830.025n

.meas tran vdout1_31ck1650 FIND v(dout1_31) AT=830.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_22ck1690 FIND v(dout1_22) AT=850.025n

.meas tran vdout1_23ck1690 FIND v(dout1_23) AT=850.025n

.meas tran vdout1_24ck1690 FIND v(dout1_24) AT=850.025n

.meas tran vdout1_25ck1690 FIND v(dout1_25) AT=850.025n

.meas tran vdout1_26ck1690 FIND v(dout1_26) AT=850.025n

.meas tran vdout1_27ck1690 FIND v(dout1_27) AT=850.025n

.meas tran vdout1_28ck1690 FIND v(dout1_28) AT=850.025n

.meas tran vdout1_29ck1690 FIND v(dout1_29) AT=850.025n

.meas tran vdout1_30ck1690 FIND v(dout1_30) AT=850.025n

.meas tran vdout1_31ck1690 FIND v(dout1_31) AT=850.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_19ck1710 FIND v(dout1_19) AT=860.025n

.meas tran vdout1_20ck1710 FIND v(dout1_20) AT=860.025n

.meas tran vdout1_21ck1710 FIND v(dout1_21) AT=860.025n

.meas tran vdout1_22ck1710 FIND v(dout1_22) AT=860.025n

.meas tran vdout1_23ck1710 FIND v(dout1_23) AT=860.025n

.meas tran vdout1_24ck1710 FIND v(dout1_24) AT=860.025n

.meas tran vdout1_25ck1710 FIND v(dout1_25) AT=860.025n

.meas tran vdout1_26ck1710 FIND v(dout1_26) AT=860.025n

.meas tran vdout1_27ck1710 FIND v(dout1_27) AT=860.025n

.meas tran vdout1_28ck1710 FIND v(dout1_28) AT=860.025n

.meas tran vdout1_29ck1710 FIND v(dout1_29) AT=860.025n

.meas tran vdout1_30ck1710 FIND v(dout1_30) AT=860.025n

.meas tran vdout1_31ck1710 FIND v(dout1_31) AT=860.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_16ck1720 FIND v(dout1_16) AT=865.025n

.meas tran vdout1_17ck1720 FIND v(dout1_17) AT=865.025n

.meas tran vdout1_18ck1720 FIND v(dout1_18) AT=865.025n

.meas tran vdout1_19ck1720 FIND v(dout1_19) AT=865.025n

.meas tran vdout1_20ck1720 FIND v(dout1_20) AT=865.025n

.meas tran vdout1_21ck1720 FIND v(dout1_21) AT=865.025n

.meas tran vdout1_22ck1720 FIND v(dout1_22) AT=865.025n

.meas tran vdout1_23ck1720 FIND v(dout1_23) AT=865.025n

.meas tran vdout1_24ck1720 FIND v(dout1_24) AT=865.025n

.meas tran vdout1_25ck1720 FIND v(dout1_25) AT=865.025n

.meas tran vdout1_26ck1720 FIND v(dout1_26) AT=865.025n

.meas tran vdout1_27ck1720 FIND v(dout1_27) AT=865.025n

.meas tran vdout1_28ck1720 FIND v(dout1_28) AT=865.025n

.meas tran vdout1_29ck1720 FIND v(dout1_29) AT=865.025n

.meas tran vdout1_30ck1720 FIND v(dout1_30) AT=865.025n

.meas tran vdout1_31ck1720 FIND v(dout1_31) AT=865.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_19ck1780 FIND v(dout1_19) AT=895.025n

.meas tran vdout1_20ck1780 FIND v(dout1_20) AT=895.025n

.meas tran vdout1_21ck1780 FIND v(dout1_21) AT=895.025n

.meas tran vdout1_22ck1780 FIND v(dout1_22) AT=895.025n

.meas tran vdout1_23ck1780 FIND v(dout1_23) AT=895.025n

.meas tran vdout1_24ck1780 FIND v(dout1_24) AT=895.025n

.meas tran vdout1_25ck1780 FIND v(dout1_25) AT=895.025n

.meas tran vdout1_26ck1780 FIND v(dout1_26) AT=895.025n

.meas tran vdout1_27ck1780 FIND v(dout1_27) AT=895.025n

.meas tran vdout1_28ck1780 FIND v(dout1_28) AT=895.025n

.meas tran vdout1_29ck1780 FIND v(dout1_29) AT=895.025n

.meas tran vdout1_30ck1780 FIND v(dout1_30) AT=895.025n

.meas tran vdout1_31ck1780 FIND v(dout1_31) AT=895.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_16ck1820 FIND v(dout1_16) AT=915.025n

.meas tran vdout1_17ck1820 FIND v(dout1_17) AT=915.025n

.meas tran vdout1_18ck1820 FIND v(dout1_18) AT=915.025n

.meas tran vdout1_19ck1820 FIND v(dout1_19) AT=915.025n

.meas tran vdout1_20ck1820 FIND v(dout1_20) AT=915.025n

.meas tran vdout1_21ck1820 FIND v(dout1_21) AT=915.025n

.meas tran vdout1_22ck1820 FIND v(dout1_22) AT=915.025n

.meas tran vdout1_23ck1820 FIND v(dout1_23) AT=915.025n

.meas tran vdout1_24ck1820 FIND v(dout1_24) AT=915.025n

.meas tran vdout1_25ck1820 FIND v(dout1_25) AT=915.025n

.meas tran vdout1_26ck1820 FIND v(dout1_26) AT=915.025n

.meas tran vdout1_27ck1820 FIND v(dout1_27) AT=915.025n

.meas tran vdout1_28ck1820 FIND v(dout1_28) AT=915.025n

.meas tran vdout1_29ck1820 FIND v(dout1_29) AT=915.025n

.meas tran vdout1_30ck1820 FIND v(dout1_30) AT=915.025n

.meas tran vdout1_31ck1820 FIND v(dout1_31) AT=915.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_23ck1830 FIND v(dout1_23) AT=920.025n

.meas tran vdout1_24ck1830 FIND v(dout1_24) AT=920.025n

.meas tran vdout1_25ck1830 FIND v(dout1_25) AT=920.025n

.meas tran vdout1_26ck1830 FIND v(dout1_26) AT=920.025n

.meas tran vdout1_27ck1830 FIND v(dout1_27) AT=920.025n

.meas tran vdout1_28ck1830 FIND v(dout1_28) AT=920.025n

.meas tran vdout1_29ck1830 FIND v(dout1_29) AT=920.025n

.meas tran vdout1_30ck1830 FIND v(dout1_30) AT=920.025n

.meas tran vdout1_31ck1830 FIND v(dout1_31) AT=920.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_8ck1850 FIND v(dout1_8) AT=930.025n

.meas tran vdout1_9ck1850 FIND v(dout1_9) AT=930.025n

.meas tran vdout1_10ck1850 FIND v(dout1_10) AT=930.025n

.meas tran vdout1_11ck1850 FIND v(dout1_11) AT=930.025n

.meas tran vdout1_12ck1850 FIND v(dout1_12) AT=930.025n

.meas tran vdout1_13ck1850 FIND v(dout1_13) AT=930.025n

.meas tran vdout1_14ck1850 FIND v(dout1_14) AT=930.025n

.meas tran vdout1_15ck1850 FIND v(dout1_15) AT=930.025n

.meas tran vdout1_16ck1850 FIND v(dout1_16) AT=930.025n

.meas tran vdout1_17ck1850 FIND v(dout1_17) AT=930.025n

.meas tran vdout1_18ck1850 FIND v(dout1_18) AT=930.025n

.meas tran vdout1_19ck1850 FIND v(dout1_19) AT=930.025n

.meas tran vdout1_20ck1850 FIND v(dout1_20) AT=930.025n

.meas tran vdout1_21ck1850 FIND v(dout1_21) AT=930.025n

.meas tran vdout1_22ck1850 FIND v(dout1_22) AT=930.025n

.meas tran vdout1_23ck1850 FIND v(dout1_23) AT=930.025n

.meas tran vdout1_24ck1850 FIND v(dout1_24) AT=930.025n

.meas tran vdout1_25ck1850 FIND v(dout1_25) AT=930.025n

.meas tran vdout1_26ck1850 FIND v(dout1_26) AT=930.025n

.meas tran vdout1_27ck1850 FIND v(dout1_27) AT=930.025n

.meas tran vdout1_28ck1850 FIND v(dout1_28) AT=930.025n

.meas tran vdout1_29ck1850 FIND v(dout1_29) AT=930.025n

.meas tran vdout1_30ck1850 FIND v(dout1_30) AT=930.025n

.meas tran vdout1_31ck1850 FIND v(dout1_31) AT=930.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_8ck1860 FIND v(dout1_8) AT=935.025n

.meas tran vdout1_9ck1860 FIND v(dout1_9) AT=935.025n

.meas tran vdout1_10ck1860 FIND v(dout1_10) AT=935.025n

.meas tran vdout1_11ck1860 FIND v(dout1_11) AT=935.025n

.meas tran vdout1_12ck1860 FIND v(dout1_12) AT=935.025n

.meas tran vdout1_13ck1860 FIND v(dout1_13) AT=935.025n

.meas tran vdout1_14ck1860 FIND v(dout1_14) AT=935.025n

.meas tran vdout1_15ck1860 FIND v(dout1_15) AT=935.025n

.meas tran vdout1_16ck1860 FIND v(dout1_16) AT=935.025n

.meas tran vdout1_17ck1860 FIND v(dout1_17) AT=935.025n

.meas tran vdout1_18ck1860 FIND v(dout1_18) AT=935.025n

.meas tran vdout1_19ck1860 FIND v(dout1_19) AT=935.025n

.meas tran vdout1_20ck1860 FIND v(dout1_20) AT=935.025n

.meas tran vdout1_21ck1860 FIND v(dout1_21) AT=935.025n

.meas tran vdout1_22ck1860 FIND v(dout1_22) AT=935.025n

.meas tran vdout1_23ck1860 FIND v(dout1_23) AT=935.025n

.meas tran vdout1_24ck1860 FIND v(dout1_24) AT=935.025n

.meas tran vdout1_25ck1860 FIND v(dout1_25) AT=935.025n

.meas tran vdout1_26ck1860 FIND v(dout1_26) AT=935.025n

.meas tran vdout1_27ck1860 FIND v(dout1_27) AT=935.025n

.meas tran vdout1_28ck1860 FIND v(dout1_28) AT=935.025n

.meas tran vdout1_29ck1860 FIND v(dout1_29) AT=935.025n

.meas tran vdout1_30ck1860 FIND v(dout1_30) AT=935.025n

.meas tran vdout1_31ck1860 FIND v(dout1_31) AT=935.025n

.meas tran vdout1_0ck1870 FIND v(dout1_0) AT=940.025n

.meas tran vdout1_1ck1870 FIND v(dout1_1) AT=940.025n

.meas tran vdout1_2ck1870 FIND v(dout1_2) AT=940.025n

.meas tran vdout1_3ck1870 FIND v(dout1_3) AT=940.025n

.meas tran vdout1_4ck1870 FIND v(dout1_4) AT=940.025n

.meas tran vdout1_5ck1870 FIND v(dout1_5) AT=940.025n

.meas tran vdout1_6ck1870 FIND v(dout1_6) AT=940.025n

.meas tran vdout1_7ck1870 FIND v(dout1_7) AT=940.025n

.meas tran vdout1_8ck1870 FIND v(dout1_8) AT=940.025n

.meas tran vdout1_9ck1870 FIND v(dout1_9) AT=940.025n

.meas tran vdout1_10ck1870 FIND v(dout1_10) AT=940.025n

.meas tran vdout1_11ck1870 FIND v(dout1_11) AT=940.025n

.meas tran vdout1_12ck1870 FIND v(dout1_12) AT=940.025n

.meas tran vdout1_13ck1870 FIND v(dout1_13) AT=940.025n

.meas tran vdout1_14ck1870 FIND v(dout1_14) AT=940.025n

.meas tran vdout1_15ck1870 FIND v(dout1_15) AT=940.025n

.meas tran vdout1_16ck1870 FIND v(dout1_16) AT=940.025n

.meas tran vdout1_17ck1870 FIND v(dout1_17) AT=940.025n

.meas tran vdout1_18ck1870 FIND v(dout1_18) AT=940.025n

.meas tran vdout1_19ck1870 FIND v(dout1_19) AT=940.025n

.meas tran vdout1_20ck1870 FIND v(dout1_20) AT=940.025n

.meas tran vdout1_21ck1870 FIND v(dout1_21) AT=940.025n

.meas tran vdout1_22ck1870 FIND v(dout1_22) AT=940.025n

.meas tran vdout1_23ck1870 FIND v(dout1_23) AT=940.025n

.meas tran vdout1_24ck1870 FIND v(dout1_24) AT=940.025n

.meas tran vdout1_25ck1870 FIND v(dout1_25) AT=940.025n

.meas tran vdout1_26ck1870 FIND v(dout1_26) AT=940.025n

.meas tran vdout1_27ck1870 FIND v(dout1_27) AT=940.025n

.meas tran vdout1_28ck1870 FIND v(dout1_28) AT=940.025n

.meas tran vdout1_29ck1870 FIND v(dout1_29) AT=940.025n

.meas tran vdout1_30ck1870 FIND v(dout1_30) AT=940.025n

.meas tran vdout1_31ck1870 FIND v(dout1_31) AT=940.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_23ck1890 FIND v(dout1_23) AT=950.025n

.meas tran vdout1_24ck1890 FIND v(dout1_24) AT=950.025n

.meas tran vdout1_25ck1890 FIND v(dout1_25) AT=950.025n

.meas tran vdout1_26ck1890 FIND v(dout1_26) AT=950.025n

.meas tran vdout1_27ck1890 FIND v(dout1_27) AT=950.025n

.meas tran vdout1_28ck1890 FIND v(dout1_28) AT=950.025n

.meas tran vdout1_29ck1890 FIND v(dout1_29) AT=950.025n

.meas tran vdout1_30ck1890 FIND v(dout1_30) AT=950.025n

.meas tran vdout1_31ck1890 FIND v(dout1_31) AT=950.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_23ck1910 FIND v(dout1_23) AT=960.025n

.meas tran vdout1_24ck1910 FIND v(dout1_24) AT=960.025n

.meas tran vdout1_25ck1910 FIND v(dout1_25) AT=960.025n

.meas tran vdout1_26ck1910 FIND v(dout1_26) AT=960.025n

.meas tran vdout1_27ck1910 FIND v(dout1_27) AT=960.025n

.meas tran vdout1_28ck1910 FIND v(dout1_28) AT=960.025n

.meas tran vdout1_29ck1910 FIND v(dout1_29) AT=960.025n

.meas tran vdout1_30ck1910 FIND v(dout1_30) AT=960.025n

.meas tran vdout1_31ck1910 FIND v(dout1_31) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_23ck1920 FIND v(dout1_23) AT=965.025n

.meas tran vdout1_24ck1920 FIND v(dout1_24) AT=965.025n

.meas tran vdout1_25ck1920 FIND v(dout1_25) AT=965.025n

.meas tran vdout1_26ck1920 FIND v(dout1_26) AT=965.025n

.meas tran vdout1_27ck1920 FIND v(dout1_27) AT=965.025n

.meas tran vdout1_28ck1920 FIND v(dout1_28) AT=965.025n

.meas tran vdout1_29ck1920 FIND v(dout1_29) AT=965.025n

.meas tran vdout1_30ck1920 FIND v(dout1_30) AT=965.025n

.meas tran vdout1_31ck1920 FIND v(dout1_31) AT=965.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_22ck1950 FIND v(dout1_22) AT=980.025n

.meas tran vdout1_23ck1950 FIND v(dout1_23) AT=980.025n

.meas tran vdout1_24ck1950 FIND v(dout1_24) AT=980.025n

.meas tran vdout1_25ck1950 FIND v(dout1_25) AT=980.025n

.meas tran vdout1_26ck1950 FIND v(dout1_26) AT=980.025n

.meas tran vdout1_27ck1950 FIND v(dout1_27) AT=980.025n

.meas tran vdout1_28ck1950 FIND v(dout1_28) AT=980.025n

.meas tran vdout1_29ck1950 FIND v(dout1_29) AT=980.025n

.meas tran vdout1_30ck1950 FIND v(dout1_30) AT=980.025n

.meas tran vdout1_31ck1950 FIND v(dout1_31) AT=980.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_16ck1980 FIND v(dout1_16) AT=995.025n

.meas tran vdout1_17ck1980 FIND v(dout1_17) AT=995.025n

.meas tran vdout1_18ck1980 FIND v(dout1_18) AT=995.025n

.meas tran vdout1_19ck1980 FIND v(dout1_19) AT=995.025n

.meas tran vdout1_20ck1980 FIND v(dout1_20) AT=995.025n

.meas tran vdout1_21ck1980 FIND v(dout1_21) AT=995.025n

.meas tran vdout1_22ck1980 FIND v(dout1_22) AT=995.025n

.meas tran vdout1_23ck1980 FIND v(dout1_23) AT=995.025n

.meas tran vdout1_24ck1980 FIND v(dout1_24) AT=995.025n

.meas tran vdout1_25ck1980 FIND v(dout1_25) AT=995.025n

.meas tran vdout1_26ck1980 FIND v(dout1_26) AT=995.025n

.meas tran vdout1_27ck1980 FIND v(dout1_27) AT=995.025n

.meas tran vdout1_28ck1980 FIND v(dout1_28) AT=995.025n

.meas tran vdout1_29ck1980 FIND v(dout1_29) AT=995.025n

.meas tran vdout1_30ck1980 FIND v(dout1_30) AT=995.025n

.meas tran vdout1_31ck1980 FIND v(dout1_31) AT=995.025n

.meas tran vdout1_0ck2000 FIND v(dout1_0) AT=1005.025n

.meas tran vdout1_1ck2000 FIND v(dout1_1) AT=1005.025n

.meas tran vdout1_2ck2000 FIND v(dout1_2) AT=1005.025n

.meas tran vdout1_3ck2000 FIND v(dout1_3) AT=1005.025n

.meas tran vdout1_4ck2000 FIND v(dout1_4) AT=1005.025n

.meas tran vdout1_5ck2000 FIND v(dout1_5) AT=1005.025n

.meas tran vdout1_6ck2000 FIND v(dout1_6) AT=1005.025n

.meas tran vdout1_7ck2000 FIND v(dout1_7) AT=1005.025n

.meas tran vdout1_8ck2000 FIND v(dout1_8) AT=1005.025n

.meas tran vdout1_9ck2000 FIND v(dout1_9) AT=1005.025n

.meas tran vdout1_10ck2000 FIND v(dout1_10) AT=1005.025n

.meas tran vdout1_11ck2000 FIND v(dout1_11) AT=1005.025n

.meas tran vdout1_12ck2000 FIND v(dout1_12) AT=1005.025n

.meas tran vdout1_13ck2000 FIND v(dout1_13) AT=1005.025n

.meas tran vdout1_14ck2000 FIND v(dout1_14) AT=1005.025n

.meas tran vdout1_15ck2000 FIND v(dout1_15) AT=1005.025n

.meas tran vdout1_16ck2000 FIND v(dout1_16) AT=1005.025n

.meas tran vdout1_17ck2000 FIND v(dout1_17) AT=1005.025n

.meas tran vdout1_18ck2000 FIND v(dout1_18) AT=1005.025n

.meas tran vdout1_19ck2000 FIND v(dout1_19) AT=1005.025n

.meas tran vdout1_20ck2000 FIND v(dout1_20) AT=1005.025n

.meas tran vdout1_21ck2000 FIND v(dout1_21) AT=1005.025n

.meas tran vdout1_22ck2000 FIND v(dout1_22) AT=1005.025n

.meas tran vdout1_23ck2000 FIND v(dout1_23) AT=1005.025n

.meas tran vdout1_24ck2000 FIND v(dout1_24) AT=1005.025n

.meas tran vdout1_25ck2000 FIND v(dout1_25) AT=1005.025n

.meas tran vdout1_26ck2000 FIND v(dout1_26) AT=1005.025n

.meas tran vdout1_27ck2000 FIND v(dout1_27) AT=1005.025n

.meas tran vdout1_28ck2000 FIND v(dout1_28) AT=1005.025n

.meas tran vdout1_29ck2000 FIND v(dout1_29) AT=1005.025n

.meas tran vdout1_30ck2000 FIND v(dout1_30) AT=1005.025n

.meas tran vdout1_31ck2000 FIND v(dout1_31) AT=1005.025n

.meas tran vdout1_0ck2020 FIND v(dout1_0) AT=1015.025n

.meas tran vdout1_1ck2020 FIND v(dout1_1) AT=1015.025n

.meas tran vdout1_2ck2020 FIND v(dout1_2) AT=1015.025n

.meas tran vdout1_3ck2020 FIND v(dout1_3) AT=1015.025n

.meas tran vdout1_4ck2020 FIND v(dout1_4) AT=1015.025n

.meas tran vdout1_5ck2020 FIND v(dout1_5) AT=1015.025n

.meas tran vdout1_6ck2020 FIND v(dout1_6) AT=1015.025n

.meas tran vdout1_7ck2020 FIND v(dout1_7) AT=1015.025n

.meas tran vdout1_8ck2020 FIND v(dout1_8) AT=1015.025n

.meas tran vdout1_9ck2020 FIND v(dout1_9) AT=1015.025n

.meas tran vdout1_10ck2020 FIND v(dout1_10) AT=1015.025n

.meas tran vdout1_11ck2020 FIND v(dout1_11) AT=1015.025n

.meas tran vdout1_12ck2020 FIND v(dout1_12) AT=1015.025n

.meas tran vdout1_13ck2020 FIND v(dout1_13) AT=1015.025n

.meas tran vdout1_14ck2020 FIND v(dout1_14) AT=1015.025n

.meas tran vdout1_15ck2020 FIND v(dout1_15) AT=1015.025n

.meas tran vdout1_16ck2020 FIND v(dout1_16) AT=1015.025n

.meas tran vdout1_17ck2020 FIND v(dout1_17) AT=1015.025n

.meas tran vdout1_18ck2020 FIND v(dout1_18) AT=1015.025n

.meas tran vdout1_19ck2020 FIND v(dout1_19) AT=1015.025n

.meas tran vdout1_20ck2020 FIND v(dout1_20) AT=1015.025n

.meas tran vdout1_21ck2020 FIND v(dout1_21) AT=1015.025n

.meas tran vdout1_22ck2020 FIND v(dout1_22) AT=1015.025n

.meas tran vdout1_23ck2020 FIND v(dout1_23) AT=1015.025n

.meas tran vdout1_24ck2020 FIND v(dout1_24) AT=1015.025n

.meas tran vdout1_25ck2020 FIND v(dout1_25) AT=1015.025n

.meas tran vdout1_26ck2020 FIND v(dout1_26) AT=1015.025n

.meas tran vdout1_27ck2020 FIND v(dout1_27) AT=1015.025n

.meas tran vdout1_28ck2020 FIND v(dout1_28) AT=1015.025n

.meas tran vdout1_29ck2020 FIND v(dout1_29) AT=1015.025n

.meas tran vdout1_30ck2020 FIND v(dout1_30) AT=1015.025n

.meas tran vdout1_31ck2020 FIND v(dout1_31) AT=1015.025n
